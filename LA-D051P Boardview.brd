# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
N29296707: length 105.4
  TOP w0.102: RC61.1 183.51,26.66 183.83,26.98 v1(184.08,26.98) v2(184.59,26.98)
  IN3 w0.102: v2(159.89,78.92) 159.44,78.48 159.44,75.16 159.97,74.64 163.15,74.64 163.3,74.79 163.3,75.78 163.42,75.9 163.59,75.9 163.71,75.78 163.71,72.83 163.81,72.73 164.01,72.73 164.12,72.83 164.12,75.78 164.24,75.9 164.4,75.9 164.52,75.78 164.52,72.83 164.62,72.73 164.83,72.73 164.93,72.83 164.93,75.5 165.05,75.62 165.22,75.62 165.34,75.5 165.34,72.83 165.44,72.73 165.64,72.73 165.74,72.83 165.74,74.69 165.86,74.81 166.03,74.81 166.15,74.69 166.15,72.83 166.25,72.73 168.11,72.73 169.37,71.46 169.37,68.1 167.25,65.98 167.25,60.6 167.06,60.42 167.06,59.63 167.95,58.74 171.86,58.74 172.25,58.35 178.32,58.35 179.31,57.36 184.23,57.36 186.53,55.06 186.53,48.08 187.28,47.33 187.28,39.28 184.7,36.69 183.75,36.69 180.02,32.96 180.02,30.6 183.64,26.98 v2(184.59,26.98)
  BOTTOM w0.102: RC52.2 v2(159.89,78.92)
N29351482: length 3.4
  TOP w0.102: RI1.5 15.55,44.7 15.42,44.57 15.04,44.57 14.9,44.71 RI1.6 14.9,45.96 RI94.1 v1(14.9,47.06)
N29351651: length 24.1
  TOP w0.102: QI1.6 16.2,35.06 15.74,34.6 v3(14.79,34.6) 14.41,34.6 13.94,35.07 13.94,48.72 11.74,50.92 11.74,53.9 12.14,54.3 JLED.5
N29409930: length 9.9
  TOP w0.254: QV74.2 84.58,71.9 84.58,70.59 RV2719.2 85.39,69.78 87.45,69.78 v1(87.92,70.25) 88.91,71.24 QV5.6 88.64,71.53 88.64,71.68 88.93,71.97 89.11,71.97 QV5.5
N29410477: length 6.8
  TOP w0.254: QV5.3 91.91,70.1 v1(94.35,70.1) 95,70.1 RV2720.2 CV59.1 96.27,69.71 QV7.4
N29411532: length 5.4
  TOP w0.102: RV129.1 87.69,66.92 87.12,66.35 v1(87.12,65.14)
  TOP w0.254: RV212.1 87.69,67.8 RV129.1 87.64,66.98 QV8.5 86.25,66.98 86.16,67.07 86.16,67.43 86.37,67.63 QV8.6
N29411851: length 4.8
  TOP w0.254: QV6.2 91.8,66.4 91.42,66.02 v1(90.1,66.02) CV66.2 RV129.2
N29413258: length 2.5
  TOP w0.102: RV2718.1 v1(82.23,66.48)
  TOP w0.508: RV2718.1 83.64,66.33 QV8.3
N30058541: length 4.5
  TOP w0.102: UC13.2 128.87,22.99 CC93.2 129.53,22.36 RC130.2 130.42,23.46 130.04,23.84 130.04,24.11 129.65,24.5 v1(129.6,24.5)
N30601882: length 4.5
  TOP w0.102: v1(83.88,70.29) RV211.1
  TOP w0.254: UV23.5 84.67,74.01 CV200.1 RV208.1 RV211.1
N32012960:
  vias: v1(148.14,116.08)
N32012964: length 5.7
  TOP w0.102: v2(147.25,119.69) v1(146.74,119.69)
  IN1 w0.762: 146.93,114.04 146.93,115.31 147.76,116.13 147.76,118.86
  vias: v2(145.41,113.59) v2(146.04,113.59) v2(147.88,119.69)
N32015249: length 2.5
  BOTTOM w0.102: PR679.1 v1(150.48,113.07)
  BOTTOM w0.254: PR679.1 150.34,114.17 PU606.7
N32027782: length 4.7
  TOP w0.102: v2(119.69,9.77) v1(119.69,10.28) 119.69,10.34 120.39,11.04 RE393.2
  BOTTOM w0.102: JDEG1.9 120.54,9.17 119.94,9.77 v2(119.69,9.77)
N32027839: length 4.3
  TOP w0.102: v2(120.05,5.13) 120.05,4.41 v1(120.42,4.04) 120.85,3.61 RE390.2
  BOTTOM w0.102: JDEG1.1 121.25,5.17 120.81,4.73 120.46,4.73 v2(120.05,5.13)
N32028607: length 1.1
  TOP w0.102: T4931.1 RE397.1
N32778757: length 2.7
  BOTTOM w0.254: PR671.1 81.17,98.35 v1(81.24,98.42) 81.59,98.78 81.59,99.81 81.66,99.88 PU605.1
N33124395: length 1.8
  BOTTOM w0.102: PC204.2 85.65,16.87 85.84,17.06 86.37,17.06 v1(86.61,16.82)
N33124472:
  vias: v1(92.64,17.33)
N33726059: length 2.9
  TOP w0.102: PR116.2 59.68,31.55 v1(59.81,31.68)
  TOP w0.254: PD102.1 58.41,30.22 58.81,30.61 PR116.2
N33726168: length 20.7
  TOP w0.102: v2(59.87,20.06) v1(59.87,20.57)
  TOP w0.254: PR114.2 PR120.2 62.69,31.12 PC128.1 60.58,30.2 PD102.2 60.38,30.16 v2(60.38,29.52)
  IN3 w0.254: v2(59.87,20.06) 55.94,23.99 55.94,28.82 56.64,29.52 v2(60.38,29.52)
  BOTTOM w0.254: PR121.2 59.87,19.63 v2(59.87,20.06)
N33965903: length 8.2
  BOTTOM w0.254: PR805.2 77.4,47.49 77.88,47.97 PR807.1 79.36,47.97 PC802.1 80.17,47.96 v1(80.77,47.36) 80.77,44.11 PR806.1
N33966216: length 3.1
  BOTTOM w0.102: PR808.2 79.01,45.25 79.24,45.01 79.69,45.01 v1(80.32,45.65)
  BOTTOM w0.254: PR808.2 78.52,46.15 PR824.1
N33966301: length 6.1
  BOTTOM w0.102: v1(77.07,48.3) PR804.1
  BOTTOM w0.203: PU801.4 75.93,46.16 75.61,46.49 PR802.1
  BOTTOM w0.254: PR803.1 PR804.1 76,47.38 PR802.1
N33966313: length 16.1
  IN3 w1.016: 62.54,52.82 69.78,52.82 71.11,51.49 71.11,49.2 73.78,46.54
  BOTTOM w0.102: v2(61.59,53.2) v1(61.59,54.09)
  vias: v2(61.59,52.57) v2(74.54,45.77) v2(74.99,45.33)
N33966437: length 4.3
  BOTTOM w0.203: PU801.11 76.33,40.62 76.64,40.31 77.41,40.31 PC805.1 79.06,38.66 v1(79.11,38.66)
N34009843: length 4.3
  BOTTOM w0.254: PBATT.3 15.49,18.06 PD3.3
N34010362: length 4.2
  BOTTOM w0.254: PBATT.5 15.47,20.52 16.87,19.12 PR15.1
N39352229: length 1.3
  BOTTOM w0.102: 62.67,9.39 v1(62.67,8.12)
N39352440:
  vias: v1(62.35,21.77)
N39352447: length 1.9
  BOTTOM w0.102: v1(62.35,20.44) PR108.1
  BOTTOM w0.254: PC113.2 62.32,19.45 PR108.1
N39352755: length 2
  BOTTOM w0.102: v1(62.16,32.11) 61.72,31.67 PC127.2
  BOTTOM w0.254: PR117.1 62.58,31.2 PC127.2
N55201771: length 14.6
  TOP w0.102: v2(198.84,74.18) 199.35,74.18 v1(199.76,74.6)
  TOP w0.254: v2(198.84,74.18) 198.81,74.22 RX12.2
  IN1 w0.254: v2(198.84,74.18) 198.18,74.85 198.18,75.94 199.26,77.02 199.26,78.67 201.1,80.51 202.43,80.51 202.75,80.83 202.75,82.9 JHDMI.13
N113223666: length 3.7
  TOP w0.076: RV43.2 54.79,84.38 54.22,84.95 53.59,84.95
  TOP w0.102: 53.59,84.95 v1(52.95,84.95) ; RV43.2 54.82,84.32 v2(55.5,85)
  BOTTOM w0.102: v2(55.5,85) UV1.B25
N113223669: length 1.7
  TOP w0.076: v2(56.3,84.21) 56.3,84.5 RV42.2
  BOTTOM w0.134: UV1.C24 56.7,83.81 v2(56.3,84.21)
N113223672: length 2.9
  TOP w0.076: v1(59.68,84.51) 59.68,84.36 59.07,83.75 RV41.1
  TOP w0.254: v2(58.81,82.63) 58.7,82.74 RV41.1
  BOTTOM w0.254: UV1.D22 58.44,83 v2(58.81,82.63)
N123563926: length 2.1
  TOP w0.102: v1(98.26,52.79) 98.69,52.36 RD12.1
  TOP w0.254: RD12.1 98.69,50.88 CD21.2
N123564541: length 2
  TOP w0.102: CD31.2 v1(111.63,34.54)
  TOP w0.254: RD16.1 CD31.2
N123564950: length 2.8
  TOP w0.102: CD49.2 v1(153.49,26.74)
  TOP w0.508: CD49.2 152.25,27.12 151.77,27.6 RD21.1
N124136876: length 19
  TOP w0.102: CC71.1 158.57,70.17 159.19,70.79 v1(159.19,71.11) 159.19,71.28 v2(159.46,71.55)
  BOTTOM w0.076: 149.73,77.14 148.52,78.35 148.14,78.35 146.54,79.95 UC1.BB10
  BOTTOM w0.102: v2(159.46,71.55) 159.46,72.23 158.2,73.5 154,73.5 151.55,75.94 150.93,75.94 149.73,77.14
N124150417: length 1.3
  TOP w0.254: T123.1 v2(133.91,97.02)
  BOTTOM w0.254: v2(133.91,97.02) 133.91,97.64 UC1.K32
N124150426: length 1.1
  TOP w0.254: T121.1 133.72,87.64 v2(133.9,87.81)
  BOTTOM w0.203: v2(133.9,87.81) UC1.AK32
N124433686: length 6.3
  BOTTOM w0.076: 108.97,78.6 110.02,79.66 112.09,79.66 112.27,79.83 112.27,80.45 UC1.BA70
  BOTTOM w0.102: T213.1 108.12,77.91 108.82,78.6 108.97,78.6
N124433695: length 8.1
  BOTTOM w0.076: UC1.BA68 112.45,80.92 111.88,80.92 111.74,80.78 111.17,80.78 111.09,80.7 110.54,80.7 110.33,80.5 110.33,80.29 108.83,78.79
  BOTTOM w0.102: 108.83,78.79 107.24,78.79 T215.1
N124433804: length 8.6
  BOTTOM w0.076: 108.83,77.97 110.18,79.33 112.36,79.33 113.02,79.99 UC1.BB68
  BOTTOM w0.102: T156.1 107,77.16 108.01,77.16 108.83,77.97
N124433815: length 9.5
  BOTTOM w0.076: 108.77,78.29 108.91,78.29 110.11,79.49 112.29,79.49 112.59,79.79 UC1.BB69
  BOTTOM w0.102: T157.1 105.8,77.35 107.83,77.35 108.77,78.29
N124433840: length 2
  TOP w0.076: v2(145.25,87.82) 145.06,88 T158.1
  BOTTOM w0.076: v2(145.25,87.82) 144.82,87.39 UC1.AK13
N124433849: length 1.3
  TOP w0.076: T159.1 145.82,87.72 v2(145.82,87.78)
  BOTTOM w0.076: UC1.AK12 145.47,87.43 v2(145.82,87.78)
N124433912: length 2.9
  TOP w0.076: T162.1 148.62,84.73 148.62,83.14 v2(148.99,82.76)
  BOTTOM w0.076: UC1.AU5 149.33,83.1 v2(148.99,82.76)
N124433921: length 1.3
  TOP w0.076: T163.1 149.52,83.86 v2(148.98,83.86)
  BOTTOM w0.076: v2(148.98,83.86) 149.09,83.75 UC1.AT5
N124434211: length 15.9
  BOTTOM w0.076: 151.25,77.97 149.66,79.56 149.66,79.73 149.57,79.82 UC1.BB5
  BOTTOM w0.102: 151.25,77.97 152.51,77.97 153.76,76.72 154.54,76.72 155.59,75.67 159.46,75.67 159.75,75.96 161.19,75.96 161.41,75.75 162.74,75.75 T199.1
N124434229: length 28.1
  TOP w0.102: v1(167.57,62.54) 166.3,62.54 165.79,63.05 RC182.1 165.11,63.05 v2(164.97,63.2)
  IN3 w0.102: v2(164.97,63.2) 164.95,63.2 163.89,64.26 163.89,65.09 160.92,68.06 160.92,71.03 155.06,76.89 v2(155.06,78.16)
  BOTTOM w0.076: 152.23,78.86 151.32,79.76 151.32,80.2 151.17,80.35 151.17,80.81 150.82,81.16 UC1.AY3
  BOTTOM w0.102: 152.23,78.86 153.64,78.86 154.34,78.16 v2(155.06,78.16)
N124434328: length 15.5
  BOTTOM w0.076: UC1.AY4 150.06,81.15 149.85,80.94 149.85,80.51 150.06,80.3 150.06,79.69 151.39,78.36 151.55,78.36
  BOTTOM w0.102: T214.1 161.14,76.78 159.91,76.78 159.29,76.15 155.76,76.15 153.55,78.36 151.55,78.36
N124434330: length 12.9
  BOTTOM w0.076: 152.06,78.55 151.43,78.55 150.84,79.14 150.84,79.84 UC1.BB3
  BOTTOM w0.102: 152.06,78.55 153.68,78.55 155.85,76.38 159.19,76.38 159.81,77 160.95,77 T216.1
N124434364: length 5.8
  BOTTOM w0.076: UC1.AW71 111.36,81.63 110.43,81.63 110.14,81.34 110.14,80.77 110,80.63 110,80.52 109.5,80.03
  BOTTOM w0.102: 109.5,80.03 109.26,79.78 107.34,79.78 T221.1
N124434366: length 5.2
  BOTTOM w0.076: T223.1 108.64,79.43 109.21,79.43 110.17,80.38 110.17,80.56 110.31,80.7 110.31,81.27 110.5,81.47 110.9,81.47 110.94,81.43 111.94,81.43 UC1.AW70
N124434499: length 4.3
  TOP w0.254: v2(110.75,81.1) 110.09,81.76 v1(110.09,82.92) RC183.1
  BOTTOM w0.254: UC1.AY71 v2(110.75,81.1)
N124727868: length 1.1
  TOP w0.076: v2(121.48,86) 121.09,85.6 T17.1
  BOTTOM w0.076: UC1.AN55 121.19,85.7 v2(121.48,86)
N124727876: length 1.2
  TOP w0.076: T18.1 121.75,84.67 v2(121.55,84.67)
  BOTTOM w0.076: UC1.AP53 v2(121.55,84.67)
N294148061: length 4
  TOP w0.102: QV74.1 88.17,74.01 v1(89.4,75.24)
  TOP w0.508: RV2721.1 87.57,74.48 QV74.1
N312638881: length 4.9
  BOTTOM w0.102: v1(94.14,107.9) 94.14,108.32 PR620.2
  BOTTOM w0.203: PR620.2 91.73,110.74 91.37,110.74 91.16,110.95 PU602.1

## Copper pours and planes (outline as drawn)
3V_SN on BOTTOM (solid shape): 70.16,18.28 70.16,15.61 70.1,15.55 69.21,15.55 69.14,15.61 69.14,16.44 67.94,17.64 67.94,18.53 68,18.6 69.84,18.6
3V_VIN on TOP (solid shape): 59.46,14.5 59.46,13.23 59.37,13.14 57.11,13.14 57.11,14.31 57.37,14.56 59.4,14.56
3V_VIN on BOTTOM (solid shape): 54.73,16.5 56.19,16.5 56.19,17.07 56.51,17.07 56.57,17.01 56.57,14.6 56.83,14.34 57.52,14.34 57.78,14.6 59.18,14.6 59.49,14.28 59.49,13.64 59.68,13.45 60.76,13.45 60.95,13.64 60.95,14.02 61.08,14.15 62.54,14.15 62.6,14.09 62.6,11.99 62.1,11.48 58.1,11.48 57.46,12.12 56.64,12.12 56.44,12.31 54.73,12.31 54.1,12.95 54.1,16.95 54.22,17.07 54.73,17.07
3VS on TOP (solid shape): 173.47,19.98 173.47,19.55 173.44,19.52 172.95,19.52 172.93,19.5 172.93,19 172.96,18.97 173.43,18.97 173.47,18.94 173.47,18.75 173.45,18.74 172.94,18.74 172.93,18.72 172.93,18.19 172.94,18.17 173.44,18.17 173.47,18.15 173.47,16.24 173.16,15.93 173.16,15.04 172.9,14.79 171.38,14.79 171.25,14.91 171.25,15.57 171.26,15.6 171.29,15.62 171.53,15.96 171.29,16.29 171.26,16.31 171.25,16.34 171.25,19.92 171.38,20.04 173.4,20.04
3VS_GATE on TOP (solid shape): 173.22,11.61 174.86,11.61 175.42,11.61 175.55,11.48 175.55,10.82 175.44,10.72 172.9,10.72 172.78,10.85 172.78,11.48 172.59,11.68 172.59,11.8 173.03,11.8
5V_SN on BOTTOM (solid shape): 70.67,30.34 70.67,27.8 70.61,27.74 69.72,27.74 69.65,27.8 69.65,29.01 68.89,29.77 68.38,29.77 68.32,29.84 68.32,30.73 68.38,30.79 70.22,30.79
5V_VIN on TOP (solid shape): 60.32,25.96 60.32,24.57 57.84,24.57 57.84,25.58 57.97,25.71 58.67,25.71 59.05,26.09 60.19,26.09
5V_VIN on BOTTOM (solid shape): 60.25,25.9 60.25,25.39 60.45,25.2 61.65,25.2 61.78,25.33 61.78,25.71 61.97,25.9 63.43,25.9 63.49,25.84 63.49,23.87 61.02,21.39 58.67,21.39 58.67,21.96 57.27,21.96 57.27,21.39 56.83,21.39 56.57,21.64 56.57,25.26 56.89,25.58 58.54,25.58 59.05,26.09 60.06,26.09
5VS on TOP (solid shape): 169.86,18.47 169.86,16.37 169.6,16.12 169.6,15.95 169.6,15.8 169.64,15.76 169.71,15.68 169.79,15.62 169.92,15.49 169.92,14.85 169.86,14.79 168.97,14.79 168.84,14.91 167.13,14.91 166.93,15.1 166.93,16.31 167.51,16.31 167.51,17.77 166.93,17.77 166.93,18.34 167.13,18.53 169.79,18.53
5VS_GATE on TOP (solid shape): 171.56,11.38 172.42,11.38 172.52,11.28 172.52,10.91 172.4,10.79 171.81,10.79 171.43,10.41 170.48,10.41 170.24,10.64 170.24,11.55 170.36,11.68 171.27,11.68
+0.675V_DDRA_VREFDQ on BOTTOM (solid shape): 96.32,48.63 96.32,46.73 96.26,46.66 95.62,46.66 95.31,46.98 95.31,48.57 95.5,48.76 96.2,48.76
+0.675VS_VTT on TOP (solid shape): 173.09,35.49 173.09,33.52 172.78,33.2 172.78,25.96 172.59,25.77 171.25,25.77 171.19,25.84 171.19,33.96 171.7,34.47 171.7,35.36 171.95,35.61 172.97,35.61
+0.675VS_VTT on TOP (solid shape): 160.9,48.38 160.9,46.85 160.33,46.28 160.33,42.41 161.09,41.65 161.09,38.6 161.03,38.54 159.7,38.54 159.44,38.79 159.44,41.2 158.87,41.77 158.87,46.85 159.44,47.43 159.44,48.44 159.57,48.57 160.71,48.57
+0.675VS_VTT on BOTTOM (solid shape): 100.89,10.34 100.89,9.26 100.7,9.07 98.8,9.07 98.61,9.26 98.61,10.47 98.8,10.66 100.58,10.66
+0.675VS_VTT on BOTTOM (solid shape): 160.14,48.57 160.14,46.85 159.95,46.66 159.06,46.66 158.93,46.79 158.93,48.57 159.06,48.7 160.01,48.7
+0.675VS_VTT on BOTTOM (solid shape): 172.71,35.68 172.71,33.84 172.59,33.71 171.51,33.71 171.38,33.84 171.38,35.68 171.51,35.81 172.59,35.81
+0.675VS_VTT on BOTTOM (solid shape): 91.5,9.96 91.5,7.99 91.18,7.67 89.91,7.67 89.72,7.87 89.72,10.15 89.85,10.28 91.18,10.28
+0.675VS_VTT on BOTTOM (solid shape): 160.46,40.25 161.28,40.25 161.28,38.73 160.39,38.73 160.14,38.47 159.38,38.47 159.25,38.6 159.25,40.44 159.31,40.5 160.2,40.5
+0.675VS_VTT on BOTTOM (solid shape): 175.95,31.36 175.95,29.33 173.16,26.53 173.16,23.93 172.78,23.55 171.89,23.55 171.7,23.74 171.7,27.49 174.43,30.22 174.43,31.3 174.62,31.49 175.82,31.49
+0.675VS_VTT on BOTTOM (solid shape): outline of 648 points within 113.15,19.87 172.21,24.18
+0.675VS_VTT on IN1 (solid shape): 99.82,10.09 99.82,9.39 99.05,8.63 97.28,8.63 97.28,10.09 97.34,10.15 97.78,10.15 98.1,10.47 99.43,10.47
+0.675VS_VTT on IN1 (solid shape): 92.83,9.83 92.83,8.88 92.58,8.63 90.23,8.63 89.97,8.88 89.97,9.96 90.16,10.15 92.51,10.15
+0.675VSP on BOTTOM (solid shape): 89.53,10.6 89.53,9.71 88.96,9.71 88.96,8.25 89.53,8.25 89.53,6.91 89.4,6.79 86.86,6.79 86.67,6.98 86.67,9.77 85.59,10.85 85.59,12.37 85.65,12.44 85.78,12.44 85.85,12.37 85.85,11.36 86.29,10.91 87.24,10.91 87.43,11.1 87.43,11.42 86.42,12.44 86.42,12.82 86.48,12.88 87.24,12.88
+1.0V_APLL on TOP (solid shape): outline of 81 points within 153.79,96.68 156.39,100.62
+1.0V_APLL on IN3 (solid shape): outline of 767 points within 139.97,94.99 155.36,97.4
+1.0V_CLK4_F100OC on TOP (solid shape): 152.88,100.64 153.86,100.64 153.91,100.59 153.91,99.99 153.81,99.88 152.96,99.88 152.65,100.19 152.19,100.19 152.09,100.19 151.78,99.88 151.78,97.19 151.45,96.86 151.04,96.86 151.01,96.88 150.99,96.91 150.87,97.17 150.6,97.24 150.55,97.29 150.55,97.29 149.98,97.86 149.86,97.86 149.72,97.99 149.72,98.61 150.43,99.32 150.43,99.88 151.45,100.9 152.63,100.9
+1.0V_CLK4_F100OC on IN1 (solid shape): outline of 500 points within 140.13,94.73 150.34,98.6
+1.0V_CLK5 on TOP (solid shape): outline of 554 points within 140.61,95.77 147.03,100.88
+1.0V_CLK6_24TBT on TOP (solid shape): outline of 351 points within 143.24,101.43 150.56,105.5
+1.0V_CLK6_24TBT on IN1 (solid shape): outline of 243 points within 144.2,97.02 148.08,103.69
+1.0V_MPHYJP on TOP (solid shape): 187.25,81.4 187.25,78.99 187.06,78.79 183.89,78.79 183.57,79.11 183.57,81.78 183.7,81.91 186.75,81.91
+1.0V_MPHYPLL on TOP (solid shape): 144.2,96.83 144.2,95.94 144.33,95.81 144.33,95.37 144.14,95.37 143.96,95.19 143.96,93.79 143.95,93.78 143.25,93.78 143.19,93.84 143.19,94.1 143.06,94.23 142.69,94.23 142.68,94.36 142.61,94.49 142.61,94.8 142.74,94.92 142.74,95.3 142.68,95.37 141.92,95.37 141.47,95.81 141.47,95.94 141.6,96.07 141.73,96.07 142.17,95.62 142.61,95.62 142.74,95.75 142.74,96 142.87,96.13 143.31,96.13 143.44,96.26 143.44,96.7 143.63,96.89 144.14,96.89
+1.0V_MPHYPLL on TOP (solid shape): outline of 958 points within 152.08,75.75 183.38,89.65
+1.0V_MPHYPLL on IN2 (solid shape): outline of 3851 points within 138.17,81.84 163.76,96.51
+1.0V_PRIM on TOP (solid shape): 94.61,65.08 94.61,63.94 94.42,63.75 93.15,63.75 93.02,63.87 93.02,65.33 93.15,65.46 94.23,65.46
+1.0V_PRIM on TOP (solid shape): 188.02,78.48 188.02,76.95 187.93,76.87 186.79,76.87 186.62,76.7 186.62,76.51 186.62,76.5 186.62,76 186.81,75.81 186.81,74.6 186.75,74.54 186.18,74.54 185.73,74.1 185.73,72.95 183.19,72.95 183.19,74.73 183.19,74.73 183.19,74.92 183.57,75.3 183.57,78.16 183.95,78.54 187.95,78.54
+1.0V_PRIM on TOP (solid shape): 142.04,95.11 142.04,95.09 142.03,95.02 142.04,94.95 142.04,94.4 142.04,94.39 142.01,94.27 142.04,94.15 142.04,94.14 142.04,94.03 142.58,93.5 142.58,91.15 142.49,91.05 142.49,90.67 141.98,90.16 141.98,88.38 141.92,88.32 141.38,88.32 141.37,88.43 141.37,88.55 141.34,88.57 141.34,89.59 141.41,89.65 141.41,90.16 140.84,90.73 140.84,90.99 141.22,91.37 141.6,91.37 141.85,91.62 141.85,92.13 142.04,92.32 142.04,92.38 142.07,92.41 142.07,92.58 142.07,92.74 142.04,92.76 142.04,92.83 141.4,93.47 141.4,93.48 141.35,93.58 141.28,93.65 141.28,94.67 141.41,94.8 141.41,95.11 141.53,95.24 141.92,95.24
+1.0V_PRIM on TOP (solid shape): outline of 1557 points within 149.87,39.68 185.35,82.19
+1.0V_PRIM on BOTTOM (solid shape): 140.26,93.02 140.52,93.02 140.65,93.15 140.84,93.15 140.9,93.08 140.9,92.96 140.39,92.45 140.01,92.45 139.88,92.32 139.69,92.32 139.57,92.45 139.57,92.64 139.82,92.89 139.82,93.02 139.95,93.15 140.14,93.15
+1.0V_PRIM on IN2 (solid shape): 99.18,36.06 99.18,35.49 98.86,35.17 97.66,35.17 97.34,35.49 97.34,36.06 97.59,36.31 98.93,36.31
+1.0V_PRIM on IN2 (solid shape): 173.35,41.58 173.35,39.49 173.03,39.17 172.4,39.17 172.08,39.49 172.08,41.33 172.4,41.65 173.28,41.65
+1.0V_PRIM on IN3 (solid shape): 98.55,35.68 98.55,35.42 98.29,35.17 97.59,35.17 97.21,34.79 96.45,34.79 96.2,35.04 96.2,35.68 96.7,36.19 98.04,36.19
+1.0V_PRIM on IN3 (solid shape): outline of 101 points within 93.85,59.24 96.01,66.72
+1.0V_PRIM on IN3 (solid shape): outline of 7001 points within 94.23,78.4 152.14,96.38
+1.0V_PRIM on TOP: 148.7,99.96 148.65,99.91 148.2,99.91 148.14,99.92 148.08,99.91 147.74,99.91 147.65,100 147.65,101.17 148.28,101.17 148.47,101.36 150.62,101.36 150.64,101.38 150.74,101.48 150.74,102.4 150.64,102.49 150.64,105.95 151.14,106.44 155.23,106.44 156.03,105.64 156.03,101.39 155.95,101.31 151.62,101.31 150.97,100.65 149.4,100.65 149.36,100.61 149.29,100.61 149.29,100.55 149.14,100.4 149.11,100.41 148.76,100.34 148.69,99.99
+1.0V_PRIM on VCC: 153.13,85.08 152.33,85.89 152.33,86.65 148.37,90.61 146.72,90.61 145.83,91.49 139.5,91.49 139.5,95.83 140.94,97.27 145.13,97.27 146.11,98.25 146.11,99.58 152.2,105.68 152.2,109.04 154.09,110.93 168.99,110.93 173.09,106.82 173.09,80.19 176.08,77.21 176.08,71.3 173.79,71.3 164.84,80.26 164.84,97.57 162.09,100.32 157.62,100.32 156.9,99.6 156.9,89 155.95,88.04 155.95,86.46 154.57,85.08
+1.0V_PRIM_D on TOP (solid shape): 92.28,65.29 92.28,62.75 92.13,62.6 91.24,62.6 91.18,62.67 91.18,65.27 91.31,65.4 92.18,65.4
+1.0V_PRIM_JP on TOP (solid shape): 167.44,44.63 167.57,44.5 168.52,44.5 169.03,45.01 170.55,45.01 170.68,44.89 170.68,42.22 170.24,41.77 167.57,41.77 166.11,43.23 165.92,43.23 165.79,43.36 165.79,44.35 169.54,44.35 169.54,44.3 169.55,44.25 169.57,44.2 169.6,44.15 169.63,44.11 169.67,44.07 169.72,44.04 169.76,44.02 169.81,44 169.87,44 169.92,44 169.97,44 170.02,44.02 170.07,44.04 170.12,44.07 170.16,44.11 170.19,44.15 170.22,44.2 170.24,44.25 170.25,44.3 170.25,44.35 170.25,44.41 170.24,44.46 170.22,44.51 170.19,44.55 170.16,44.6 170.12,44.63 170.07,44.66 170.02,44.68 169.97,44.7 169.92,44.71 169.87,44.71 169.81,44.7 169.76,44.68 169.72,44.66 169.67,44.63 169.63,44.6 169.6,44.55 169.57,44.51 169.55,44.46 169.54,44.41 169.54,44.35 165.79,44.35 165.79,45.77 167.44,45.77
+1.0V_VCCSTU on TOP (solid shape): 177.35,79.81 177.35,78.86 177.48,78.73 177.48,77.4 177.41,77.33 176.4,77.33 175.95,77.78 175.95,79.68 176.14,79.87 177.29,79.87
+1.0VS_DGPU on TOP (solid shape): outline of 2158 points within 52.57,59.87 90.1,72.02
+1.0VS_DGPU on BOTTOM (solid shape): outline of 257 points within 52.7,59.87 68.58,70.14
+1.0VS_DGPU on IN1 (solid shape): outline of 399 points within 53.96,61.21 59.58,68.76
+1.0VS_VCCIO on TOP (solid shape): 135.44,89.34 135.44,88.38 135.53,88.3 135.53,85.89 135.35,85.71 134.24,85.71 134.11,85.84 134.11,86.41 134.23,86.54 134.48,86.54 134.87,86.92 134.87,89.34 134.93,89.4 135.38,89.4
+1.0VS_VCCIO on TOP (solid shape): 128.2,86.8 128.2,85.84 128.01,85.65 127.56,85.65 127.44,85.78 127.44,86.67 127.31,86.8 126.74,86.8 126.29,86.35 120.64,86.35 120.58,86.41 120.58,86.99 120.71,87.11 125.41,87.11 125.72,87.43 127.56,87.43
+1.0VS_VCCIO on TOP (solid shape): 170.43,55.1 170.43,51.49 167.76,48.82 167.51,48.82 166.49,47.81 164.46,47.81 164.46,48.31 163.06,48.31 163.06,47.74 162.43,47.74 162.05,48.12 162.05,51.05 162.62,51.62 165.48,51.62 167.57,53.71 167.57,55.36 168.01,55.81 169.72,55.81
+1.0VS_VCCIO on IN1 (solid shape): 135.6,87.81 135.6,85.88 135.41,85.68 133.82,85.68 133.74,85.73 133.73,85.83 133.64,86.22 133.24,86.21 133.17,86.19 133.1,86.22 132.9,86.41 128.77,86.41 128.07,85.72 127.73,85.72 127.47,85.97 127.47,86.77 128.07,87.37 134.74,87.37 134.93,87.56 134.93,87.81 135.11,87.99 135.42,87.99
+1.0VS_VCCIO on VCC: 166.41,52.57 147.24,71.74 147.24,76.58 145.66,78.16 145.66,78.77 141.73,82.71 141.73,85.69 141.32,86.1 128.48,86.1 128.09,85.72 127.73,85.72 127.31,86.14 127.31,89.02 137.41,89.02 139.38,90.99 145.62,90.99 146.51,90.1 148.16,90.1 151.82,86.44 151.82,85.67 152.92,84.57 154.43,84.57 154.43,81.65 155,81.08 155,80.89 154.43,80.32 154.43,75.13 167.82,61.74 167.82,60.91 168.93,59.81 169.81,59.81 170.36,59.26 170.36,52.57
+1.0VS_VCCSTG on BOTTOM (solid shape): 138.97,102.77 139,102.76 139.29,102.76 139.51,102.53 139.51,102.01 139.4,101.91 139.23,101.91 139.06,101.74 139.06,101.67 139.07,101.58 139.1,101.5 139.11,101.49 139.11,100.77 139.1,100.76 139.06,100.62 139.1,100.48 139.11,100.47 139.11,100.42 139.21,100.32 139.21,100.13 139.2,100.11 139.19,100.1 139.14,100.03 139.11,99.95 139.11,99.94 139.06,99.88 138.78,99.88 138.75,99.91 138.75,99.93 138.47,100.17 138.19,99.93 138.17,99.9 138.14,99.88 138.04,99.88 137.66,100.27 137.66,100.38 137.67,100.4 137.78,100.52 137.82,100.66 137.87,100.74 137.97,100.74 138.1,100.71 138.24,100.74 138.34,100.74 138.39,100.66 138.81,100.42 138.81,100.9 138.76,100.99 138.81,101.07 138.95,101.31 138.82,101.55 138.77,101.63 138.82,101.71 138.89,101.8 138.92,101.92 138.92,102.01 138.9,102.12 138.82,102.21 138.78,102.29 138.82,102.37 138.9,102.46 138.92,102.57 138.92,102.66 138.92,102.71 138.92,102.73 138.93,102.76
+1.0VS_VCCSTG_IO on TOP (solid shape): 164.84,47.49 164.84,45.2 164.97,45.08 165.41,45.08 165.54,44.95 165.54,42.03 165.41,41.9 162.87,41.9 162.17,42.6 162.17,47.3 162.43,47.55 164.78,47.55
+1.8V_PRIM on TOP (solid shape): 165.26,90.78 165.26,90.28 164.78,89.8 163.02,89.8 162.92,89.91 162.92,90.74 163.13,90.95 165.09,90.95
+1.8V_PRIM on TOP (solid shape): 182.62,72.89 182.62,71.94 182.37,71.68 180.4,71.68 180.08,72 180.08,73.08 180.14,73.14 182.37,73.14
+1.8V_PRIM on TOP (solid shape): outline of 404 points within 143.4,88.06 158.6,92.03
+1.8V_PRIM on BOTTOM (solid shape): 178.05,55.43 178.05,54.79 177.86,54.6 176.9,54.6 176.46,55.05 176.46,55.17 176.9,55.62 177.86,55.62
+1.8V_PRIM on BOTTOM (solid shape): 86.42,33.46 86.29,33.33 85.94,33.33 85.94,33.9 84.54,33.9 84.54,33.33 84.23,33.33 84.16,33.39 84.16,35.04 85.12,36 86.42,36
+1.8V_PRIM on IN1 (solid shape): 182.87,72.76 182.87,70.86 182.68,70.67 182.05,70.67 181.86,70.86 181.86,72.76 181.98,72.89 182.75,72.89
+1.8V_PRIM on IN1 (solid shape): 178.3,56.7 178.3,54.79 178.05,54.54 177.35,54.54 177.16,54.73 177.16,56.63 177.35,56.82 178.17,56.82
+1.8V_PRIM on IN3 (solid shape): 165.84,90.01 165.84,89.79 165.29,89.24 165.12,89.24 163.91,90.45 163.91,90.7 164.09,90.87 164.97,90.87
+1.8V_PRIM on IN3 (solid shape): 182.7,73.26 182.7,71.71 182.57,71.58 181,71.58 180.59,71.99 180.59,73.32 180.75,73.49 182.47,73.49
+1.8V_PRIM_VS on TOP (solid shape): 180.14,75.49 181.1,75.49 181.98,74.6 181.98,74.1 181.79,73.91 180.08,73.91 178.81,75.18 178.81,75.94 178.94,76.06 179.57,76.06
+1.8VALWP on BOTTOM (solid shape): 86.42,33.01 86.42,32.69 84.7,30.98 84.7,28.57 83.69,28.57 83.31,28.95 83.31,29.33 82.86,29.77 82.35,29.77 82.16,29.96 82.16,32.57 82.73,33.14 86.29,33.14
+1.8VS on TOP (solid shape): 180.97,79.18 180.97,77.65 180.9,77.59 180.14,77.59 179.89,77.33 178.94,77.33 178.87,77.4 178.87,78.92 179.32,79.37 180.78,79.37
+1.35V_VDDQ on TOP (solid shape): outline of 22056 points within 97.78,23.74 151.89,87.49
+1.35V_VDDQ on BOTTOM (solid shape): 105.59,32.38 105.59,30.03 107.12,28.5 107.12,22.79 104.23,19.9 103.63,19.9 102.64,18.91 101.15,18.91 100.13,19.93 100.13,20.57 100.7,20.57 100.7,22.66 100.13,22.66 100.13,25.84 100.7,25.84 100.7,27.87 100.13,27.87 100.13,28.57 98.86,29.84 98.86,33.33 99.69,34.15 103.82,34.15
+1.35V_VDDQ on BOTTOM (solid shape): 135.7,40.87 135.7,38.64 135.53,38.47 135.36,38.47 135.36,38.51 135.23,38.64 135.23,40.56 135.1,40.69 133.97,40.69 133.84,40.56 133.84,37.52 133.59,37.27 131.91,37.27 131.53,37.65 120.93,37.65 120.86,37.73 120.86,39.65 120.93,39.72 121.2,39.72 121.26,39.66 121.26,38.38 121.34,38.31 122.48,38.31 122.65,38.47 122.65,39.69 122.74,39.78 122.95,39.78 123.06,39.68 123.06,38.64 123.33,38.36 124.33,38.36 124.44,38.47 124.44,39.64 124.55,39.76 124.79,39.76 124.88,39.68 124.88,38.47 125.11,38.23 126.08,38.23 126.24,38.4 126.24,39.83 126.34,39.93 126.65,39.93 126.65,38.26 126.79,38.12 127.92,38.12 128.06,38.26 128.06,39.89 128.1,39.93 128.44,39.93 128.44,38.47 128.58,38.33 129.62,38.33 129.85,38.57 129.85,39.92 129.86,39.93 130.24,39.93 130.24,38.41 130.45,38.2 131.28,38.2 131.66,38.57 131.66,39.9 131.69,39.93 132.05,39.93 132.05,38.1 132.37,37.78 132.81,37.78 132.81,37.78 133.3,37.78 133.46,37.94 133.46,40.65 133.41,40.7 133.4,40.7 133.4,41.02 133.53,41.15 135.41,41.15
+1.35V_VDDQ on BOTTOM (solid shape): outline of 86 points within 119.46,45.76 135.38,51.25
+1.35V_VDDQ on BOTTOM (solid shape): 145.52,36.43 145.93,36.01 145.93,34.64 145.83,34.54 145.63,34.54 145.56,34.61 145.56,35.6 145.27,35.89 145.03,35.89 144.99,35.86 144.77,35.86 144.7,35.92 144.45,35.92 144.14,35.61 144.14,34.61 144.04,34.52 143.82,34.52 143.77,34.57 143.77,35.74 143.58,35.93 142.48,35.93 142.34,35.79 142.34,34.57 142.26,34.49 141.98,34.49 141.96,34.51 141.96,35.8 141.66,36.1 140.72,36.1 140.59,35.98 140.59,34.56 140.52,34.49 140.23,34.49 140.14,34.58 140.14,35.87 139.85,36.16 138.91,36.16 138.75,36 138.75,34.58 138.69,34.52 138.43,34.52 138.35,34.59 138.35,35.79 138.14,36 137.17,36 137.04,35.87 137.04,35.86 136.98,35.79 136.98,34.6 136.87,34.49 136.66,34.49 136.54,34.61 136.54,35.72 136.32,35.94 135.32,35.94 135.17,35.8 135.17,34.56 135.07,34.45 134.78,34.45 134.73,34.5 134.73,35.81 134.61,35.93 133.66,35.93 133.35,35.62 133.35,34.63 133.21,34.49 133.03,34.49 132.95,34.57 132.95,36.48 133.22,36.75 145.52,36.75
+1.35V_VDDQ on BOTTOM (solid shape): outline of 467 points within 132.84,23.23 148.57,26.92
+1.35V_VDDQC on TOP (solid shape): 128.39,88.26 128.39,87.75 128.64,87.49 129.15,87.49 129.17,87.48 129.17,85.88 129.18,85.87 129.09,85.78 128.52,85.78 128.32,85.98 128.32,86.8 127.56,87.56 126.87,87.56 126.68,87.75 126.68,88.19 126.87,88.38 128.26,88.38
+1.35VP on BOTTOM (solid shape): 99.94,28.44 99.94,19.87 101.09,18.72 101.09,13.58 100.51,13.01 97.34,13.01 96.89,13.45 96.89,26.98 97.08,27.17 97.08,28.38 97.66,28.95 99.43,28.95
+1.35VP on BOTTOM (solid shape): 84.64,12.37 84.64,11.68 83.69,10.72 83.69,10.15 83.56,10.02 83.11,10.02 82.92,9.83 82.92,9.52 82.61,9.2 80.83,9.2 80.77,9.26 80.77,9.77 80.83,9.83 82.16,9.83 82.38,10.06 82.38,10.31 84.13,12.06 84.13,12.25 84.32,12.44 84.58,12.44
+1.35VS_VRAM on TOP (solid shape): 59.15,104.34 59.26,104.36 59.33,104.27 59.33,102.09 58.97,101.73 58.92,101.72 58.88,101.71 58.81,101.7 58.75,101.75 58.64,101.86 58.48,101.91 58.46,101.91 58.34,102.03 58.34,102.05 58.01,102.25 57.8,101.94 57.77,101.85 57.69,101.82 57.65,101.82 57.57,101.85 57.54,101.94 57.47,102.17 57.24,102.25 57.22,102.25 57.1,102.37 57.1,102.41 57.14,102.49 57.22,102.51 57.46,102.58 57.54,102.81 57.54,102.83 57.75,103.04 57.75,103.28 57.8,103.37 57.91,103.36 58.16,103.32 58.34,103.51 58.34,103.52
+1.35VS_VRAM on TOP (solid shape): 54.06,98.03 54.67,98.03 54.97,98.34 54.97,98.34 55.01,98.42 55.1,98.44 55.28,98.45 55.43,98.56 55.52,98.6 55.6,98.55 55.87,98.4 56.15,98.55 56.22,98.59 56.3,98.57 56.32,98.55 56.32,98.4 56.35,98.37 56.38,98.29 56.33,98.21 56.23,98.1 56.2,97.95 56.2,97.92 56.16,97.89 55.87,97.89 55.41,97.43 55.2,97.43 55.19,97.47 54.72,97.71 54.63,97.19 54.65,97.12 54.63,97.05 54.59,97.01 54.57,96.97 54.52,96.92 54.44,96.91 54.33,96.93 54.21,96.9 54.14,96.9 54.08,96.95 53.93,97.08 53.73,97.1 53.7,97.09 53.53,97.26 53.53,97.27 53.23,97.45 53,97.2 52.96,97.13 52.89,97.11 52.85,97.11 52.78,97.13 52.74,97.2 52.67,97.37 52.5,97.45 52.41,97.52 52.44,97.62 52.52,97.71 52.54,97.71 52.68,97.8 52.74,97.96 52.78,98.03 52.85,98.05 53.1,98.15 53.2,98.4 53.23,98.47 53.29,98.51 53.38,98.53 53.45,98.57 53.48,98.6
+1.35VS_VRAM on TOP (solid shape): outline of 100 points within 66.88,96.31 71.02,99.21
+1.35VS_VRAM on TOP (solid shape): outline of 404 points within 71.07,98.26 73.87,103.66
+1.35VS_VRAM on TOP (solid shape): outline of 1004 points within 64.96,100.86 73.23,107.43
+1.35VS_VRAM on TOP (solid shape): outline of 23160 points within 29.5,60.38 98.23,112.01
+1.35VS_VRAM on BOTTOM (solid shape): 37.45,80.96 37.45,80.93 37.53,80.71 37.76,80.63 37.85,80.61 37.88,80.53 37.88,80.48 37.85,80.4 37.76,80.37 37.45,80.16 37.65,79.84 37.66,79.83 37.79,79.71 37.79,79.69 37.83,79.53 37.95,79.42 37.99,79.36 37.99,79.29 37.98,79.26 37.97,79.2 37.61,78.85 35.05,78.85 35.01,78.94 35.04,78.96 35.3,78.96 36.17,79.83 36.19,79.84 36.38,80.01 36.34,80.26 36.33,80.37 36.42,80.43 36.66,80.43 36.87,80.63 36.89,80.63 37.12,80.72 37.19,80.95 37.21,81.04 37.29,81.07 37.33,81.07
+1.35VS_VRAM on BOTTOM (solid shape): outline of 98 points within 58.94,70.3 66.09,81.6
+1.35VS_VRAM on BOTTOM (solid shape): outline of 200 points within 40.31,65.93 46,71.3
+1.35VS_VRAM on BOTTOM (solid shape): outline of 923 points within 32.44,64.93 38.83,73.21
+1.35VS_VRAM on BOTTOM (solid shape): outline of 14850 points within 29.14,60.4 75.88,112.64
+1.35VS_VRAM on IN2 (solid shape): outline of 3072 points within 70.22,84.76 89.97,107.69
+1VALWP on TOP (solid shape): 180.59,39.49 182.62,39.49 182.81,39.3 182.81,37.65 180.71,37.65 180.21,37.14 172.16,37.14 171.25,38.04 171.25,39.36 171.38,39.49 176.08,39.49 176.59,40 180.08,40
+1VALWP on BOTTOM (solid shape): 180.52,42.16 180.52,38.07 179.53,37.08 176.49,37.08 175.76,37.8 175.76,42.16 176.14,42.54 180.14,42.54
+3V_PRIM on TOP (solid shape): 140.2,93.08 140.3,93.08 140.34,93.07 140.39,93.06 140.45,93.06 140.51,93.07 140.54,93.08 140.9,93.08 141.22,92.76 141.22,92.45 141.09,92.32 140.96,92.32 140.89,92.24 140.77,92.13 140.01,92.13 139.88,92 139.88,91.11 139.78,91.01 136.54,91.01 136.52,90.99 136.45,90.99 136.39,91.05 136.39,91.62 136.45,91.69 137.79,91.69 138.11,92 138.11,92.6 139.48,92.6 139.48,92.55 139.49,92.5 139.5,92.45 139.52,92.41 139.55,92.37 139.59,92.33 139.63,92.3 139.67,92.28 139.72,92.26 139.77,92.26 139.82,92.26 139.87,92.26 139.92,92.28 139.96,92.3 140,92.33 140.04,92.37 140.07,92.41 140.09,92.45 140.1,92.5 140.11,92.55 140.11,92.6 140.1,92.65 140.09,92.7 140.07,92.74 140.04,92.78 140,92.82 139.96,92.85 139.92,92.87 139.87,92.88 139.82,92.89 139.77,92.89 139.72,92.88 139.67,92.87 139.63,92.85 139.59,92.82 139.55,92.78 139.52,92.74 139.5,92.7 139.49,92.65 139.48,92.6 138.11,92.6 138.11,92.76 138.42,93.08 139.38,93.08 139.57,93.27 140.01,93.27
+3V_PRIM on TOP (solid shape): outline of 994 points within 152.34,90.35 173.09,100.13
+3V_PRIM on BOTTOM (solid shape): 151.69,108.7 151.69,107.5 151.57,107.37 149.85,107.37 149.79,107.43 149.79,108.64 149.98,108.83 151.57,108.83
+3V_PRIM on IN1 (solid shape): outline of 1074 points within 139.06,88.49 154.04,93.21
+3V_PRIM on IN3 (solid shape): outline of 95 points within 138.83,90.64 154.35,92.82
+3V_PRIM_RTC on TOP (solid shape): outline of 82 points within 142.92,86.63 149.91,88.09
+3V_PRIMJP on TOP (solid shape): 175.7,94.1 175.7,92.07 175.44,91.81 173.48,91.81 173.28,92 173.28,94.1 173.48,94.29 175.51,94.29
+3VALW on TOP (solid shape): 189.92,97.53 189.92,94.54 189.86,94.48 188.97,94.48 188.84,94.61 188.84,96.51 188.72,96.64 188.72,97.72 188.78,97.78 189.67,97.78
+3VALW on TOP (solid shape): 176.08,99.56 176.08,95.24 175.89,95.05 173.73,95.05 173.28,95.5 173.28,98.04 173.48,98.23 174.05,98.23 174.62,98.8 174.62,99.69 174.75,99.81 175.82,99.81
+3VALW on TOP (solid shape): 174.94,14.09 174.94,11.8 174.87,11.74 173.98,11.74 173.48,11.74 173.22,11.99 171.79,11.99 171.49,12.28 171.49,12.56 171.25,12.81 171.25,13.39 171.38,13.52 171.95,13.52 173.28,14.85 174.17,14.85
+3VALW on TOP (solid shape): 153.73,16.69 153.73,15.17 155.57,13.33 155.57,10.28 155,9.71 151.69,9.71 151.57,9.83 151.57,10.85 151.69,10.98 154.55,10.98 154.81,11.23 154.81,12.95 154.62,13.14 151.69,13.14 151.38,13.45 151.38,14.02 151.89,14.53 152.81,14.53 152.9,14.62 152.9,16.63 153.09,16.82 153.6,16.82
+3VALW on BOTTOM (solid shape): 85.21,21.67 85.21,20.55 84.96,20.3 82.53,20.3 82.29,20.54 82.29,21.2 82.83,21.73 85.15,21.73
+3VALW on BOTTOM (solid shape): 189.9,98.45 189.9,96.39 189.71,96.2 189.12,96.2 188.69,96.63 188.69,98.31 188.88,98.5 189.84,98.5
+3VALW on BOTTOM (solid shape): 179.76,53.52 179.76,52.25 179.38,51.87 179.38,50.6 179.13,50.6 179.13,51.87 178.75,52.25 178.75,53.52 178.87,53.65 179.63,53.65
+3VALW on BOTTOM (solid shape): 80.07,13.83 80.07,9.26 79.88,9.07 78.35,9.07 78.1,9.33 78.1,10.79 78.67,10.79 78.67,12.82 78.1,12.82 78.1,13.9 78.35,14.15 79.75,14.15
+3VALW on BOTTOM (solid shape): outline of 121 points within 122.61,5.77 128.71,11.29
+3VALW on IN3 (solid shape): 189.79,97.84 189.79,96.26 189.6,96.07 189.29,96.07 188.21,97.15 188.21,98.1 188.27,98.16 189.48,98.16
+3VALW on IN3 (solid shape): 176.42,99.41 176.42,99.38 176.53,99.12 176.79,99.01 176.81,99.01 177.16,98.67 177.16,98.42 176.52,97.78 176.4,97.78 175.32,98.86 175.32,99.43 175.63,99.75 176.08,99.75
+3VALW on VCC: outline of 92 points within 77.34,1.27 213.13,99.24
+3VALW_DSW on IN1 (solid shape): outline of 877 points within 139.1,69.04 151.37,88.66
+3VALW_EC on TOP (solid shape): 152.39,15.68 152.39,14.85 152.27,14.72 151.82,14.72 150.55,13.45 148.65,13.45 148.58,13.52 148.58,14.09 148.71,14.22 150.04,14.22 151.57,15.74 152.33,15.74
+3VALWP on BOTTOM (solid shape): 72.95,16.12 77.78,16.12 78.03,15.87 78.03,14.15 77.91,14.02 77.91,10.21 77.75,10.06 71.15,10.06 71.05,10.15 71.05,16.31 71.24,16.5 72.57,16.5
+3VALWP on BOTTOM (solid shape): 64.51,18.79 64.51,17.58 64.32,17.39 62.79,17.39 62.6,17.2 62.6,16.44 62.54,16.37 62.41,16.37 62.35,16.44 62.35,17.58 62.73,17.96 63.49,17.96 63.75,18.22 63.75,18.79 63.87,18.91 64.38,18.91
+3VLP on BOTTOM (solid shape): 65.84,16.82 65.84,15.8 65.59,15.55 63.18,15.55 63.11,15.61 63.11,16.25 63.18,16.31 64.19,16.31 64.76,16.88 65.78,16.88
+3VS on TOP (solid shape): 185.8,86.49 185.8,84.71 185.65,84.55 182.5,84.55 182.12,84.93 182.12,86.14 182.62,86.63 185.67,86.63
+3VS on TOP (solid shape): 90.42,27.3 90.16,27.04 89.08,27.04 88.89,27.23 88.89,29.33 90.42,29.33
+3VS on TOP (solid shape): 10.92,103.37 10.92,102.99 10.25,102.32 10.25,101.46 10.12,101.34 9.23,101.34 9.17,101.4 9.17,102.7 10.03,103.56 10.72,103.56
+3VS on TOP (solid shape): 19.74,87.3 20.44,87.3 20.63,87.11 20.63,86.86 20.44,86.67 17.13,86.67 16.94,86.48 16.94,85.86 16.86,85.78 16.31,85.78 16.2,85.9 16.2,86.61 15.68,87.13 15.68,87.75 16,88.07 18.98,88.07
+3VS on TOP (solid shape): 22.54,78.79 22.54,78.35 22.85,78.03 22.85,76.89 22.03,76.06 20.82,76.06 20.69,76.19 18.98,76.19 18.79,76.38 18.79,77.72 19.04,77.97 20.95,77.97 21.52,78.54 21.52,78.79 21.65,78.92 22.41,78.92
+3VS on TOP (solid shape): 163.12,61.01 163.82,61.01 163.89,60.95 163.89,60.57 163.63,60.32 163.63,59.94 163.12,59.43 162.93,59.43 162.81,59.55 162.81,59.81 163,60 163,60.25 162.68,60.57 162.55,60.57 162.49,60.63 162.49,61.21 162.62,61.33 162.81,61.33
+3VS on TOP (solid shape): 95.12,57.33 95.12,57.01 94.86,56.76 94.61,56.76 94.16,57.2 89.59,57.2 89.08,56.7 89.08,55.68 88.96,55.55 88.96,54.86 88.83,54.73 87.56,54.73 87.43,54.86 87.43,55.87 87.44,55.88 87.7,56.71 87.81,57.57 87.81,57.58 88.26,58.03 92,58.03 92.26,58.28 94.16,58.28
+3VS on TOP (solid shape): 162.22,74.34 162.22,73.98 161.12,72.89 158.81,72.89 158.62,72.7 158.62,72.25 158.55,72.19 158.04,72.19 157.98,72.25 157.98,72.95 157.79,73.14 156.71,73.14 155.95,72.38 154.49,72.38 154.43,72.44 153.9,72.44 153.8,72.46 153.71,72.44 153.41,72.44 153.35,72.51 153.35,72.76 153.09,73.02 152.08,73.02 151.95,73.14 151.95,73.72 152.01,73.78 152.96,73.78 153.41,73.33 155.57,73.33 156.01,73.78 160.9,73.78 160.91,73.77 161.05,73.92 161.12,73.92 161.12,73.98 161.66,74.52 162.04,74.52
+3VS on TOP (solid shape): 179.28,19.65 182.76,19.65 185.38,17.03 185.38,16.11 185.28,16.01 183.92,16.01 183.88,16.05 183.88,17.26 183.5,17.64 181.92,17.64 181.7,17.43 181.7,16.13 181.63,16.06 180.33,16.06 180.25,16.15 180.25,16.66 179.63,17.28 177.91,17.28 177.45,16.82 175.38,16.82 174.81,16.25 173.79,16.25 173.64,16.4 173.64,18.3 173.6,18.34 173.12,18.34 173.11,18.35 173.11,18.55 173.12,18.57 173.6,18.57 173.64,18.61 173.64,19.11 173.62,19.13 173.12,19.13 173.09,19.16 173.09,19.35 173.12,19.38 173.59,19.38 173.64,19.43 173.64,22.32 173.79,22.47 176.46,22.47
+3VS on TOP (solid shape): outline of 120 points within 189.48,67.75 194.11,82.22
+3VS on BOTTOM (solid shape): 165.68,99.51 165.68,96.56 165.5,96.38 164.27,96.38 161.35,99.31 161.35,99.54 161.47,99.67 165.51,99.67
+3VS on BOTTOM (solid shape): 183.98,85.94 183.98,85.12 183.39,84.53 181.18,84.53 180.99,84.73 180.99,86.49 181.1,86.6 183.32,86.6
+3VS on BOTTOM (solid shape): 161.92,90.92 161.92,90.22 161.75,90.06 161.74,90.06 161.74,90.05 161.6,89.91 161.6,89.4 161.74,89.26 161.74,89.25 161.75,89.25 161.79,89.21 163.12,89.21 163.76,89.84 163.76,90.1 163.89,90.22 164.11,90.22 164.12,90.22 164.27,90.19 164.43,90.22 164.46,90.22 164.59,90.1 164.59,88.45 164.46,88.32 161.22,88.32 160.9,88.64 160.9,89.97 161.47,90.54 161.47,90.92 161.6,91.05 161.79,91.05
+3VS on IN2 (solid shape): outline of 147 points within 17.39,76 20.88,87.46
+3VS on IN3 (solid shape): 20.91,80.23 22.85,78.29 22.85,77.27 21.77,76.19 19.3,76.19 18.73,76.76 18.73,78.54 18.58,78.68 19.34,78.68 19.34,78.63 19.34,78.58 19.36,78.52 19.38,78.48 19.41,78.43 19.45,78.39 19.49,78.36 19.54,78.33 19.59,78.31 19.64,78.3 19.69,78.3 19.74,78.3 19.8,78.31 19.85,78.33 19.89,78.36 19.93,78.39 19.97,78.43 20,78.48 20.02,78.52 20.04,78.58 20.05,78.63 20.05,78.68 20.04,78.73 20.02,78.79 20,78.83 19.97,78.88 19.93,78.92 19.89,78.95 19.85,78.98 19.8,79 19.74,79.01 19.69,79.01 19.64,79.01 19.59,79 19.54,78.98 19.49,78.95 19.45,78.92 19.41,78.88 19.38,78.83 19.36,78.79 19.34,78.73 19.34,78.68 18.58,78.68 18.28,78.99 18.28,80 18.54,80.26 20.85,80.26
+3VS on IN3 (solid shape): outline of 276 points within 2.47,80.97 7.62,83.64
+3VS on VCC: 108.75,20.88 105,24.63 40.04,24.63 32.19,32.48 32.19,49.06 30.92,50.33 30.92,54.9 18.28,67.53 18.28,79.07 19.09,79.87 22.56,79.87 23.42,79.01 23.42,68.91 36.95,55.39 36.95,33.92 42.69,28.19 105.11,28.19 109.04,24.25 169.83,24.12 170.87,25.16 170.87,59.47 170.02,60.32 169.14,60.32 168.33,61.12 168.33,61.95 154.93,75.34 154.93,80.13 155.5,80.7 155.5,81.33 154.93,81.91 154.93,84.72 156.46,86.25 156.46,87.83 157.41,88.79 157.41,99.39 157.83,99.81 161.88,99.81 164.33,97.36 164.33,79.96 173.5,70.79 176.02,70.79 176.08,70.73 176.08,21.37 175.59,20.88
+3VS_D on TOP (solid shape): 92.32,60.89 92.32,60.13 92.77,59.68 94.16,59.68 94.48,59.36 94.48,59.11 94.29,58.92 92.09,58.92 91.9,58.73 91.9,58.35 91.24,58.35 91.18,58.41 91.18,61.14 91.24,61.21 92,61.21
+3VS_DGPU on TOP (solid shape): 89.91,61.21 89.91,59.36 89.85,59.3 87.88,59.3 87.56,59.62 87.56,60.16 87.61,60.24 87.7,60.25 88.05,60.36 87.99,60.72 87.99,60.81 88.07,60.89 88.45,60.89 88.83,61.27 89.85,61.27
+3VS_DGPU_AON on BOTTOM (solid shape): 70.55,69.55 70.55,69.24 70.39,69.08 70.39,68.72 70.55,68.56 70.55,68.24 70.16,67.85 69.82,67.85 69.2,68.47 69.05,68.47 68.87,68.65 68.87,69.3 69.25,69.68 70.42,69.68
+3VS_DGPU_AON on IN1 (solid shape): outline of 809 points within 74.35,68.44 86.04,91.62
+3VS_WLAN_NGFF on TOP (solid shape): 193.35,67.3 193.35,65.02 192.78,64.44 190.18,64.44 189.92,64.7 189.92,67.3 190.05,67.43 193.22,67.43
+3VS_WLAN_NGFF on TOP (solid shape): 174.36,69.16 174.36,68.74 174.36,68.73 174.36,65.65 174.17,65.46 172.27,65.46 172.21,65.52 172.21,69.23 172.49,69.52 174,69.52
+3VS_WLAN_NGFF on BOTTOM (solid shape): 175.15,69.44 175.15,68.47 175.11,68.43 173.65,68.43 173.52,68.56 173.52,69.49 173.62,69.59 175,69.59
+3VS_WLAN_NGFF on BOTTOM (solid shape): 191.73,66.95 191.73,64.75 191.51,64.53 190.18,64.53 190.05,64.66 190.05,67.11 190.56,67.62 191.06,67.62
+3VS_WLAN_NGFF on BOTTOM (solid shape): 174.43,67.36 174.43,66.54 174.16,66.27 174.11,66.25 173.84,66.25 173.83,66.26 173.73,66.28 173.62,66.26 173.61,66.25 173.48,66.25 173.38,66.16 173.38,64.65 173.29,64.56 172.61,64.56 172.53,64.64 172.53,67.02 173,67.49 174.3,67.49
+5V_CAM on TOP (solid shape): 18.54,67.3 18.54,65.65 18.47,65.59 17.54,65.59 17.04,65.08 15.55,65.08 15.49,65.14 15.49,65.78 15.87,66.16 15.87,67.36 15.93,67.43 18.41,67.43
+5V_CAM on BOTTOM (solid shape): 11.36,51.55 11.36,50.66 11.23,50.54 9.05,50.54 8.92,50.66 8.92,51.69 8.97,51.74 11.17,51.74
+5V_CAM on IN3 (solid shape): 13.07,52.25 13.07,51.49 12.19,50.6 10.79,50.6 10.53,50.85 10.53,51.55 10.66,51.68 11.74,51.68 12.44,52.38 12.95,52.38
+5V_CAM on IN3 (solid shape): 17.2,66.79 17.2,65.65 17.07,65.52 16.44,65.52 15.61,66.35 15.17,66.35 15.04,66.48 15.04,67.11 15.3,67.36 16.63,67.36
+5V_HDD on BOTTOM (solid shape): outline of 298 points within 175.63,5.13 188.65,13.07
+5V_PVDD on TOP (solid shape): 200.78,20.44 200.78,18.79 200.34,18.34 200.34,17.85 200.86,17.33 201.35,17.33 201.86,16.82 201.86,16.18 201.48,15.8 200.52,15.8 200.46,15.84 200.42,15.87 200.37,15.9 200.32,15.92 200.26,15.93 200.21,15.93 200.15,15.93 200.1,15.92 200.05,15.9 200,15.87 199.96,15.84 199.7,15.8 199.32,15.42 198.81,15.42 198.56,15.68 198.56,16.72 200.36,16.72 200.36,16.67 200.37,16.61 200.38,16.56 200.41,16.51 200.44,16.47 200.47,16.43 200.52,16.4 200.56,16.37 200.61,16.35 200.66,16.34 200.72,16.34 200.77,16.34 200.82,16.35 200.87,16.37 200.92,16.4 200.96,16.43 201,16.47 201.03,16.51 201.05,16.56 201.06,16.61 201.07,16.67 201.07,16.72 201.06,16.77 201.05,16.82 201.03,16.87 201,16.91 200.96,16.95 200.92,16.99 200.87,17.01 200.82,17.03 200.77,17.04 200.72,17.05 200.66,17.04 200.61,17.03 200.56,17.01 200.52,16.99 200.47,16.95 200.44,16.91 200.41,16.87 200.38,16.82 200.37,16.77 200.36,16.72 198.56,16.72 198.56,18.34 199.26,19.04 199.26,20.57 199.38,20.69 200.53,20.69
+5V_PVDD on BOTTOM (solid shape): 200.49,18.06 200.49,17.77 200.9,17.35 201.27,17.35 201.31,17.39 201.48,17.39 201.67,17.2 201.67,16.69 201.48,16.5 201.12,16.5 201.03,16.59 201.04,16.62 200.95,16.93 200.64,17.01 200.62,17.01 200.36,17.26 200.36,17.52 200.1,17.78 200.1,17.79 200.05,17.84 199.98,17.88 199.97,17.88 199.95,17.9 199.19,17.9 199.13,17.96 199.13,18.15 199.19,18.22 200.34,18.22
+5V_USB_PWR1 on TOP (solid shape): 198.36,51.36 198.36,46.72 196.97,45.33 196.97,45.33 196.78,45.14 195.19,45.14 194.68,45.64 193.61,45.64 193.48,45.77 193.48,47.11 193.68,47.31 194.44,47.31 194.58,47.45 197.19,47.45 197.19,47.4 197.19,47.35 197.21,47.3 197.23,47.25 197.26,47.2 197.3,47.16 197.34,47.13 197.39,47.1 197.44,47.09 197.49,47.07 197.54,47.07 197.6,47.07 197.65,47.09 197.7,47.1 197.74,47.13 197.78,47.16 197.82,47.2 197.85,47.25 197.87,47.3 197.89,47.35 197.9,47.4 197.9,47.45 197.89,47.51 197.87,47.56 197.85,47.6 197.82,47.65 197.78,47.69 197.74,47.72 197.7,47.75 197.65,47.77 197.6,47.78 197.54,47.78 197.49,47.78 197.44,47.77 197.39,47.75 197.34,47.72 197.3,47.69 197.26,47.65 197.23,47.6 197.21,47.56 197.19,47.51 197.19,47.45 194.58,47.45 194.75,47.62 194.75,49.75 194.76,49.75 194.76,50.56 194.75,50.56 194.75,51.17 195.19,51.62 198.1,51.62
+5V_USB_PWR1 on BOTTOM (solid shape): 199.88,61.85 199.88,58.22 199.57,57.92 199.57,57.9 199.51,57.84 199.51,54.09 199.32,53.9 199.32,52.12 197.61,50.41 194.62,50.41 193.86,51.17 193.86,54.03 195.13,55.3 195.13,57.99 195.21,58.07 196.07,58.07 196.07,58.07 196.89,58.07 197.73,58.92 197.73,61.84 198.29,62.4 199.33,62.4
+5V_USB_PWR2 on TOP (solid shape): outline of 120 points within 193.6,39.04 199.07,44.31
+5V_USB_PWR2 on BOTTOM (solid shape): 199.89,43.87 199.89,43.68 199.97,43.6 199.97,40.04 199.65,39.72 199.65,39.25 197.4,37 197.4,36.33 197.2,36.12 196.4,36.12 195.97,36.55 193.94,36.55 193.73,36.76 193.73,40.31 193.99,40.57 197.67,40.57 197.92,40.82 197.92,43.74 198.37,44.19 199.57,44.19
+5V_USB_PWR2 on IN1 (solid shape): 200.04,43.92 200.01,43.89 200.01,41.9 199.7,41.58 199.7,40.25 199.29,39.84 199.29,39.37 198.96,39.04 196.02,39.04 195.51,39.55 195.51,40.57 195.76,40.82 196.27,40.82 197.8,42.35 197.8,44 197.92,44.12 199.83,44.12
+5V_USB_PWR3 on BOTTOM (solid shape): 28,46.79 28,45.52 28.31,45.2 28.95,45.2 29.14,45.01 29.14,43.81 28.76,43.43 25.01,43.43 24.76,43.68 24.76,47.04 25.01,47.3 27.49,47.3
+5VA on TOP (solid shape): 194.82,24.31 194.82,23.72 195.18,23.36 195.32,23.36 195.64,23.04 195.64,22.28 195.57,22.22 194.18,22.22 194.14,22.25 194.14,23.02 193.73,23.42 191.79,23.42 191.69,23.52 191.69,24.13 191.75,24.18 192.59,24.18 192.78,24.38 194.75,24.38
+5VALW on TOP (solid shape): 169.25,13.58 169.92,13.58 169.98,13.52 169.98,12.75 169.89,12.66 169.89,11.83 170.11,11.61 170.11,10.52 169.93,10.34 167.7,10.34 167.44,10.6 167.44,13.52 167.82,13.9 168.93,13.9
+5VALW on TOP (solid shape): 93.59,62.63 93.59,60.82 93.53,60.76 93.02,60.76 92.89,60.89 92.89,61.52 92.64,61.78 91.24,61.78 91.18,61.84 91.18,61.97 91.24,62.03 92.7,62.03 92.96,62.28 92.96,62.67 93.08,62.79 93.43,62.79
+5VALW on TOP (solid shape): 15.8,64.32 16.31,64.32 16.31,64.89 16.88,64.89 17.58,64.19 18.47,64.19 18.54,64.13 18.54,63.05 18.28,62.79 16.38,62.79 16.25,62.67 16.25,61.97 16.06,61.78 14.09,61.78 13.39,61.08 13.39,58.09 13.26,57.97 12.19,57.97 12.06,58.09 12.06,62.16 14.79,64.89 15.8,64.89
+5VALW on TOP (solid shape): 190.05,46.88 190.54,46.88 191.04,47.38 191.94,47.38 192.21,47.11 192.21,45.9 191.95,45.65 191.26,45.65 191.07,45.46 191.07,45.02 191.07,44.88 191.32,44.63 192.07,44.63 192.33,44.38 192.33,41.64 192.14,41.46 191.64,41.46 190.94,40.76 188.46,40.76 188.33,40.89 188.33,46.66 188.02,46.98 188.02,47.74 188.14,47.87 189.05,47.87
+5VALW on BOTTOM (solid shape): 84.26,19.1 84.26,18.03 84.19,17.96 82.1,17.96 82.04,18.03 82.04,19.1 82.16,19.23 84.13,19.23
+5VALW on BOTTOM (solid shape): 32.06,44.5 32.06,43.68 32.38,43.36 32.38,41.9 32.19,41.71 29.84,41.71 29.65,41.9 29.65,44.82 29.97,45.14 31.43,45.14
+5VALW on BOTTOM (solid shape): 88.07,111.81 88.07,110.86 87.81,110.61 86.73,110.61 86.48,110.86 86.48,111.31 86.73,111.56 87.18,111.56 87.5,111.88 88,111.88
+5VALW on BOTTOM (solid shape): 77.08,22.01 77.83,22.01 77.83,22.57 78.29,22.57 78.29,22.01 79.04,22.01 79.04,22.57 79.79,22.57 79.88,22.48 79.88,20.69 79.43,20.25 75.81,20.25 75.49,20.57 75.49,22.28 75.79,22.57 77.08,22.57
+5VALW on IN3 (solid shape): 17.46,63.17 17.46,62.41 18.28,61.59 18.28,52 21.39,48.89 30.35,48.89 31.93,47.3 31.93,42.22 31.62,41.9 30.47,41.9 30.09,42.28 30.09,46.22 29.08,47.24 20.82,47.24 17.01,51.05 17.01,61.14 16.25,61.9 16.25,63.24 16.38,63.36 17.27,63.36
+5VALW on VCC: 161.33,11.1 159.23,13.2 107.86,13.2 103.98,17.07 33.56,17.07 23.3,27.34 23.3,49.97 30.56,49.97 31.68,48.84 31.68,32.27 39.83,24.12 104.79,24.12 108.54,20.37 175.8,20.37 176.59,21.16 176.59,49.08 189.37,49.08 191.45,47 191.45,40.93 190.9,40.38 188.67,40.38 183.19,34.89 183.19,19.27 178.89,14.98 172.48,14.98 171.7,14.19 171.7,11.34 171.47,11.1
+5VALWP on BOTTOM (solid shape): 73.65,28.5 73.65,28.12 73.87,27.91 79.33,27.91 79.43,27.8 79.43,26.28 79.18,26.03 79.18,24.01 79.89,23.3 79.89,22.83 79.79,22.72 75.61,22.72 74.19,21.3 71.76,21.3 71.56,21.51 71.56,28.25 71.94,28.63 73.53,28.63
+5VS on TOP (solid shape): 13.14,102.42 13.14,101.53 13.01,101.4 10.72,101.4 10.6,101.53 10.6,102.42 10.72,102.54 13.01,102.54
+5VS on TOP (solid shape): 9.07,70.35 9.07,70.03 8.57,69.52 8.57,68.7 8.38,68.51 5.39,68.51 5.14,68.76 5.14,70.41 5.39,70.67 8.76,70.67
+5VS on TOP (solid shape): 166.74,18.6 166.74,8.06 166.3,7.61 164.01,7.61 163.76,7.87 163.76,18.6 163.95,18.79 166.55,18.79
+5VS on TOP (solid shape): 197.29,78.92 197.29,77.27 197.03,77.02 196.76,77.02 195.94,77.83 195.94,78.3 196.35,78.71 196.35,78.86 196.37,78.92 196.37,78.98 196.38,78.99 197.22,78.99
+5VS on TOP (solid shape): 115.82,23.49 115.82,21.96 115.63,21.77 114.29,21.77 114.1,21.96 114.1,22.6 113.79,22.91 111.75,22.91 111.56,23.11 111.56,23.49 111.69,23.61 115.69,23.61
+5VS on TOP (solid shape): 14.53,57.81 14.53,57.08 14.36,56.9 11.97,56.9 11.82,57.05 11.82,57.52 11.98,57.68 12.24,57.68 12.24,57.68 13.28,57.68 13.63,58.04 14.31,58.04
+5VS on TOP (solid shape): 198.41,21.42 198.41,20.02 198.33,19.94 198.33,19.03 197.54,19.03 197.54,20.05 197.54,20.05 197.54,20.25 197.41,20.37 194.62,20.37 194.49,20.25 194.49,20.05 194.49,20.05 194.49,18.47 194.11,18.09 194.11,16.44 193.41,15.73 192.64,15.73 192.46,15.91 192.46,16.31 193.22,17.07 193.22,18.05 193.48,18.3 193.48,18.54 193.5,18.66 193.48,18.78 193.48,19.36 193.24,19.59 193.24,21.28 193.38,21.42 195.69,21.42 196.04,21.77 198.05,21.77
+5VS on BOTTOM (solid shape): 167.51,7.74 175.13,7.74 175.44,7.42 175.44,6.98 174.87,6.98 174.87,5.58 175.44,5.58 175.44,4.56 175.13,4.25 164.97,4.25 163.82,5.39 163.82,8.31 164.27,8.75 166.49,8.75
