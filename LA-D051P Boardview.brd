# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_A_CMD26: length 120.9
  TOP w0.102: v2(52.06,103.93) 52.11,103.93 UV9.P8 ; v2(71.38,103.95) 71.38,103.95 UV5.P2 ; UV7.P2 36.12,85.74 v2(35.76,86.1) ; v2(35.63,71.62) 35.63,71.62 36.03,71.23 UV6.P2
  TOP w0.124: RPV8.1 RPV8.2 41.14,96.9 41.31,96.72 v2(41.31,95.45)
  IN1 w0.089: v2(60.95,104.07) 60.82,104.2 59.74,104.2 59.44,104.5 59.23,104.5 59.14,104.41 56.57,104.41 56.44,104.54 56.44,104.77 56.32,104.89 53.65,104.89 53.04,104.28 52.86,104.28 52.25,104.89 51.62,104.89 51.55,104.83 50.81,104.83 49.78,103.8 49.43,103.8 43.43,97.79 43.43,97.36 42.59,96.52 42.59,96.13 41.92,95.45 v2(41.31,95.45) 41.13,95.27 41.13,94.89 41.48,94.53 41.48,94.36 41.36,94.25 41.19,94.25 41.01,94.43 40.87,94.43 40.72,94.29 40.72,94.14 40.91,93.96 40.91,93.79 40.79,93.67 40.62,93.67 40.43,93.86 40.29,93.86 40.15,93.71 40.15,93.57 40.33,93.38 40.33,93.21 40.21,93.1 40.04,93.1 39.86,93.28 39.71,93.28 35.53,89.1 35.53,88.91 35.62,88.83 35.62,88.7 35.55,88.63 35.07,88.63 34.94,88.51 34.94,88.32 35.07,88.19 35.26,88.19 35.39,88.07 35.39,87.88 35.26,87.75 35,87.75 34.87,87.62 34.87,85.86 35.4,85.33 35.4,85.08 34.8,84.48 34.8,81.83 34.36,81.38 34.36,79.1 34.73,78.73 35.06,78.73 35.24,78.55 35.24,78.27 35.36,78.15 35.6,78.15 35.73,78.02 v2(35.73,77.65)
  IN3 w0.102: v2(52.06,103.93) 51.94,104.06 51.94,104.22 52.16,104.45 52.32,104.45 52.83,103.93 54.67,103.93 54.9,103.71 56.21,103.71 56.61,103.31 58.03,103.31 58.63,103.91 59.22,103.91 59.25,103.88 59.65,103.88 59.96,104.2 60.83,104.2 v2(60.95,104.07) 61.09,103.93 64.5,103.93 65.05,104.48 66.7,104.48 67.23,103.95 v2(71.38,103.95) ; v2(35.63,71.62) 35.55,71.62 35.42,71.75 35.42,71.93 35.55,72.05 36,72.05 36.13,72.18 36.13,72.69 36.01,72.82 35.51,72.82 35.43,72.89 35.43,73.11 35.53,73.21 35.93,73.21 36,73.27 36,73.36 35.74,73.63 35.74,73.8 36.15,74.21 36.15,74.5 35.91,74.75 35.91,76.14 35.82,76.23 35.82,77.56 v2(35.73,77.65) 35.73,78.03 36,78.31 36,78.67 36.51,79.18 36.51,79.66 36.39,79.77 36.39,81.56 35.99,81.96 35.99,83.81 35.76,84.04 v2(35.76,86.1)
  BOTTOM w0.102: v2(35.76,86.1) 36.12,85.74 UV7.P2 ; UV6.P2 36.03,71.23 35.63,71.62 v2(35.63,71.62) ; v2(71.38,103.95) 71.38,103.95 UV5.P2 ; UV9.P8 52.42,103.58 v2(52.06,103.93)
  BOTTOM w0.124: v2(41.31,95.45) 41.31,95.26 v1(41.71,94.86) 43.13,93.45 43.96,93.45 44.45,92.96 45.4,92.96 45.78,92.58 45.78,91.79 46.6,90.96 50.31,87.25 50.31,82.43 53.61,79.14 53.97,79.14 54.1,79.27 55.45,79.27 UV1.J25
FB_A_CMD27: length 113.3
  TOP w0.102: v2(69.76,102.52) 70.3,101.98 UV5.M3 ; v2(38.13,81.27) 38.13,81.75 37.72,82.16 UV7.M3 ; UV6.M3 37.53,70.24 v2(37.53,69.92)
  TOP w0.124: v2(43.88,91.41) 43.34,90.86 RPV14.2 RPV14.1
  IN1 w0.089: v2(61.56,101.02) 61.14,100.6 60.34,100.6 58.97,101.97 56.57,101.97 56.39,101.79 53.89,101.79 53.84,101.85 52.25,101.85 51.39,100.98 49.63,100.98 46.42,97.76 46.42,94.37 44.44,92.39 44.44,91.97 v2(43.88,91.41) 43.88,91.04 44.06,90.86 44.06,90.73 43.11,89.78 42.86,89.78 42.35,90.29 41.97,90.29 41.84,90.42 41.84,90.99 41.72,91.11 41.55,91.11 41.43,90.99 41.43,90.42 41.31,90.29 40.73,90.29 39.44,89 39.44,88.59 39.07,88.21 38.65,88.21 38.35,87.91 38.35,87.75 38.41,87.68 38.6,87.68 38.72,87.57 38.72,86.92 38.59,86.8 38.16,86.8 38.03,86.67 38.03,86.48 38.16,86.35 38.28,86.35 38.41,86.22 38.41,85.97 38.28,85.84 37.86,85.84 37.74,85.72 37.74,85.46 37.86,85.33 38.37,85.33 38.47,85.23 38.47,85.03 38.37,84.93 37.98,84.93 37.85,84.8 37.85,84.33 37.9,84.28 37.9,81.78 37.73,81.6 37.73,79.21 38.7,78.23 v2(38.7,76.06) 38.7,74.86 38.49,74.64 38.49,70.88 v2(37.53,69.92)
  IN3 w0.102: v2(56.9,101.57) 56.79,101.57 56.67,101.44 56.67,101.09 56.79,100.96 57.16,100.96 57.29,101.09 57.29,101.76 57.41,101.89 57.97,101.89 58.09,101.77 58.09,101.33 57.96,101.2 57.96,101.02 58.16,100.81 58.34,100.81 58.44,100.91 58.44,101.11 58.52,101.2 58.66,101.2 58.81,101.04 58.81,100.63 58.94,100.5 59.11,100.5 59.24,100.63 59.24,100.87 59.37,100.99 60.31,100.99 60.82,100.48 61.3,100.48 61.56,100.73 v2(61.56,101.02) 62.6,101.02 63.19,100.44 64.82,100.44 65.37,100.98 66.13,100.98 66.61,101.46 68.37,101.46 68.68,101.77 69,101.77 v2(69.76,102.52) ; v2(38.13,81.27) 37.81,80.96 37.81,80.36 38.09,80.08 38.73,80.08 38.88,79.93 38.88,79.84 38.79,79.74 38.58,79.74 38.5,79.65 38.5,79.52 38.86,79.15 38.86,76.22 v2(38.7,76.06)
  IN3 w0.127: v2(56.3,78.42) 56.18,78.54 55.17,78.54 54.19,79.53 54.19,80.28 52.5,81.98 52.5,82.84 51.76,83.57 51.76,85.04 45.18,91.62 44.7,91.62 44.57,91.75 44.22,91.75 v2(43.88,91.41)
  BOTTOM w0.102: UV4.M3 56.01,101.98 56.42,101.57 v2(56.9,101.57) ; UV1.J24 v2(56.3,78.42)
FB_A_CMD28: length 122.3
  TOP w0.102: UV7.L3 38.74,84.68 38.74,83.95 v2(38.59,83.8) ; UV9.L7 53.49,100.96 54.3,100.96 v2(54.45,101.1) ; v2(38.49,68.4) 38.13,68.75 38.13,69.53 38.52,69.92 UV6.L3 ; UV5.L3 70.44,101.18 v2(70.45,101.17)
  TOP w0.124: v2(45.13,90.78) 45.36,90.55 RPV12.3 RPV12.4
  IN1 w0.089: v2(41.28,75.53) 41.79,76.04 41.79,78.5 40.07,80.22 40.07,81.97 40.27,82.16 40.27,83.65 39.86,84.05 39.86,84.61 40.3,85.05 40.3,86.31 40.25,86.36 40.25,87.24 42.11,89.09 43.3,89.09 43.39,89.18 43.5,89.18 43.74,88.95 44.01,88.67 44.18,88.67 44.3,88.79 44.3,88.96 43.82,89.44 43.82,89.61 43.94,89.73 44.1,89.73 44.59,89.24 44.76,89.24 44.88,89.36 44.88,89.53 44.4,90.01 44.4,90.19 44.6,90.39 44.78,90.39 45.26,89.92 45.44,89.92 45.62,90.1 45.62,90.28 v2(45.13,90.78) 45.79,91.44 45.79,92.77 49.22,96.2 49.22,97.73 49.46,97.97 49.86,97.97 51.33,99.45 51.81,99.45 51.86,99.39 53.12,99.39 53.56,99.84 54.12,99.84 54.52,99.43 56.02,99.43 56.21,99.62 59.06,99.62 60.29,98.39 62.22,98.39 62.31,98.3 v2(62.76,98.3)
  IN3 w0.102: v2(70.45,101.17) 71.18,101.17 71.3,101.05 71.3,100.7 71.18,100.58 67.11,100.58 66.96,100.42 66.96,99.9 66.67,99.6 66.42,99.6 65.84,99.03 65.07,99.03 64.93,98.89 64.56,98.89 63.98,98.3 v2(62.76,98.3) 62.4,98.3 62.27,98.43 60.44,98.43 59.75,99.12 59.46,99.12 59.39,99.18 58.51,99.18 57.9,99.8 56.38,99.8 55.63,100.55 53.74,100.55 53.55,100.74 53.55,100.87 53.66,100.99 54.34,100.99 v2(54.45,101.1) ; v2(38.49,68.4) 38.54,68.4 38.66,68.27 38.66,67.36 38.79,67.24 38.99,67.24 39.12,67.36 39.12,69.96 39.49,70.33 39.67,70.33 40.09,70.76 40.09,71.75 40.67,72.33 40.67,73.1 40.81,73.24 40.81,73.61 41.28,74.08 v2(41.28,75.53) 41.72,75.97 41.72,77.27 40.58,78.42 40.58,78.72 40.51,78.78 40.51,79.66 39.9,80.28 39.9,81.79 39.15,82.55 39.15,84.43 38.95,84.63 38.82,84.63 38.71,84.51 38.71,83.92 v2(38.59,83.8)
  BOTTOM w0.102: v2(70.45,101.17) 70.44,101.18 UV5.L3 ; UV9.L7 53.49,100.96 54.3,100.96 v2(54.45,101.1) ; UV6.L3 38.52,69.92 38.13,69.54 38.13,68.75 v2(38.49,68.4) ; v2(38.59,83.8) 38.74,83.95 38.74,84.68 UV7.L3
  BOTTOM w0.124: v2(45.13,90.78) 45.18,90.78 49.18,86.78 v1(49.18,86.16) 49.18,81.96 53.14,78.01 54.29,78.01 UV1.K27
FB_A_CMD29: length 135.6
  TOP w0.102: v2(37.05,83.92) 37.39,84.26 37.39,85.38 UV7.M2 ; UV9.M2 56.95,102.3 56.95,102.94 56.71,103.18 54.61,103.18 54.37,102.95 v2(54.37,102.58) ; UV6.M2 37.52,71.23 37.24,70.95 37.24,70.2 37.15,70.11 v2(37.15,69.19) ; UV5.M2 71.69,101.98 71.43,102.24 71.43,102.76 71.07,103.12 70.83,103.12 70.69,102.98 69.42,102.98 v2(68.98,102.55)
  TOP w0.124: RPV14.4 RPV14.3 43.11,91.36 43.88,92.13 v2(43.88,92.26)
  IN1 w0.089: v2(38.28,75.24) 38.28,78.22 37.5,79.01 37.5,81.82 37.7,82.02 37.7,84.17 37.53,84.33 37.53,85.98 37.79,86.24 37.79,87.78 42.03,92.02 42.21,92.02 42.35,91.88 42.35,91.69 42.14,91.48 42.14,90.69 42.25,90.59 42.45,90.59 42.55,90.69 42.55,91.29 42.67,91.41 42.84,91.41 42.96,91.29 42.96,90.69 43.06,90.59 43.41,90.59 43.48,90.66 43.48,91.58 43.88,91.98 v2(43.88,92.26) 44.13,92.51 46.11,94.49 46.11,97.89 50.13,101.91 51.94,101.91 52.19,102.16 53.84,102.16 54.01,102 56.15,102 56.36,102.2 59.17,102.2 59.93,101.44 v2(63.17,101.44)
  IN3 w0.102: v2(54.37,102.58) 54.37,102.52 54.8,102.09 58.55,102.09 58.67,101.97 59,101.97 59.54,101.43 61.19,101.43 61.21,101.44 v2(63.17,101.44) 63.51,101.78 63.88,101.78 64.01,101.65 64.01,101.24 64.14,101.11 64.39,101.11 64.52,101.24 64.52,101.78 64.64,101.91 65.02,101.91 65.14,101.78 65.14,101.34 65.27,101.21 66.03,101.21 66.16,101.34 66.16,101.85 66.29,101.97 67.56,101.97 67.81,101.72 68.34,101.72 68.98,102.36 v2(68.98,102.55) ; v2(37.05,83.92) 37.23,83.92 37.61,83.54 37.61,80.28 37.73,80.16 37.73,79.49 37.88,79.34 37.88,79.02 38.53,78.37 38.53,76.57 38.28,76.32 v2(38.28,75.24) 38.28,73.68 38.41,73.55 39.11,73.55 39.24,73.42 39.24,73.17 39.11,73.04 38.73,73.04 38.6,72.91 38.6,72.66 38.73,72.53 39.11,72.53 39.24,72.41 39.24,71.75 38.28,70.79 38.28,69.65 37.82,69.19 v2(37.15,69.19)
  BOTTOM w0.102: UV15.M2 37.39,81.23 36.75,81.23 36.52,81.46 36.52,83.57 36.87,83.92 v2(37.05,83.92) ; UV4.M2 52.79,102.3 54.09,102.3 v2(54.37,102.58) ; UV8.M2 66.95,102.18 67.23,102.45 67.97,102.45 68.07,102.55 v2(68.98,102.55) ; v2(37.15,69.19) 36.71,68.76 36.71,67.48 36.58,67.35 36.58,67.1 36.94,66.75 37.45,66.75 37.72,66.48 UV14.M2
  BOTTOM w0.124: UV1.K25 55.54,78.38 53.29,78.38 49.56,82.12 v1(49.56,83.87) 49.56,86.94 46.07,90.42 44.84,91.65 44.71,91.65 44.2,92.16 43.97,92.16 v2(43.88,92.26)
FB_A_CMD30: length 106.7
  TOP w0.102: UV9.M3 55.79,101.98 55.05,102.71 55.05,102.72 v2(55.05,102.72)
  TOP w0.124: v2(43.6,93.03) 42.72,93.91 RPV11.2 RPV11.1
  IN1 w0.089: v2(37.18,68.42) 36.7,68.9 36.7,69.65 38.18,71.14 38.18,74.58 37.83,74.93 v2(37.83,76.45) 37.98,76.6 37.98,78.09 37.19,78.88 37.19,82.04 37.5,82.35 37.5,84.01 37.28,84.23 37.28,86.11 37.48,86.31 37.48,87.91 42.03,92.45 42.21,92.45 42.98,91.68 43.15,91.68 43.43,91.96 43.43,92.07 43.33,92.17 43.07,92.17 42.54,92.7 42.54,92.96 42.87,93.29 43.34,93.29 v2(43.6,93.03) 44.54,93.97 45.14,93.97 45.81,94.63 45.81,98.02 50,102.21 51.86,102.21 52.06,102.42 53.94,102.42 54.16,102.2 55.83,102.2 56.13,102.51 59.29,102.51 59.95,101.85 v2(60.95,101.85)
  IN3 w0.102: v2(68.25,102.17) 68.13,102.28 65.27,102.28 65.23,102.25 63.44,102.25 63.02,101.83 61.5,101.83 61.48,101.85 v2(60.95,101.85) 59.44,101.85 59.06,102.23 58.75,102.23 58.68,102.29 54.89,102.29 54.76,102.42 54.76,102.59 54.88,102.72 v2(55.05,102.72) ; v2(37.83,76.45) 37.94,76.45 38.2,76.71 38.2,78.22 37.87,78.55 37.87,78.72 37.67,78.92 37.67,79.26 37.52,79.41 37.52,80.08 37.4,80.2 37.4,82.49 37.27,82.62 37.27,82.8 37.4,82.93 37.4,83.45 37.32,83.53 37.04,83.53 36.98,83.47 v2(36.98,83.15)
  BOTTOM w0.102: UV8.M3 67.94,102.17 v2(68.25,102.17) ; UV14.M3 37.72,67.88 v2(37.18,68.42) ; UV15.M3 37.72,82.41 v2(36.98,83.15)
  BOTTOM w0.124: v2(43.6,93.03) 43.84,93.03 44.29,92.58 45.24,92.58 45.4,92.42 45.4,91.63 v1(46,91.02) 49.93,87.09 49.93,82.28 53.45,78.76 54.24,78.76 UV1.J27
FB_A_D0: length 24.2
  TOP w0.102: UV9.F2 v2(56.87,96.78)
  IN3 w0.127: v2(62.09,81.81) 62.09,81.98 61.72,82.35 61.72,84.09 60.95,84.86 60.95,90.1 60.7,90.35 60.7,90.53 60.95,90.78 60.95,90.96 60.77,91.14 60.59,91.14 60.34,90.89 60.16,90.89 59.98,91.07 59.98,91.25 60.95,92.22 60.95,92.4 60.77,92.58 60.59,92.58 59.68,91.66 57.73,91.66 56.89,92.5 56.89,92.96 56.25,93.59 56.25,96.16 v2(56.87,96.78)
  BOTTOM w0.102: v2(56.87,96.78) 57.27,97.18 UV9.F2
  BOTTOM w0.127: UV1.E18 61.68,82.2 62.08,81.81 v2(62.09,81.81)
FB_A_D1: length 25.3
  TOP w0.102: UV9.E3 v2(56.07,96.78)
  IN3 w0.127: v2(61.3,80.97) 61.65,81.32 61.65,82.03 61.49,82.2 61.49,83.98 60.62,84.84 60.62,88.3 60.07,88.86 60.07,89.04 60.62,89.59 60.62,89.77 60.44,89.95 60.26,89.95 59.71,89.4 59.53,89.4 59.31,89.61 59.31,89.79 59.96,90.44 59.96,90.62 59.78,90.8 59.6,90.8 58.95,90.15 58.77,90.15 58.6,90.33 58.6,90.51 59.02,90.94 59.02,91.12 58.84,91.3 58.66,91.3 58.24,90.87 58.06,90.87 56.51,92.42 56.51,92.96 55.93,93.53 55.93,96.64 v2(56.07,96.78)
  BOTTOM w0.102: v2(56.07,96.78) 56.47,97.18 UV4.F7
  BOTTOM w0.127: v2(61.3,80.97) 61.3,80.98 UV1.F18
FB_A_D2: length 27.3
  TOP w0.102: UV9.H3 56.47,98.47 56.87,98.07 v2(56.87,97.58)
  IN3 w0.127: v2(56.87,97.58) 57.28,97.17 57.28,92.58 57.87,91.99 58.08,91.99 58.41,92.32 58.6,92.32 58.93,91.99 59.3,91.99 59.43,92.12 59.43,92.32 59.19,92.56 59.19,93.06 59.32,93.18 59.64,93.18 59.77,93.06 59.77,92.72 59.89,92.6 60.15,92.6 60.27,92.72 60.27,93.06 60.4,93.18 61.16,93.18 61.28,93.06 61.28,85.13 62.1,84.32 62.1,83.22 62.91,82.4 v2(62.91,81.75)
  BOTTOM w0.102: UV9.H3 56.47,98.53 56.87,98.13 v2(56.87,97.58)
  BOTTOM w0.127: v2(62.91,81.75) 62.91,81.75 UV1.E16
FB_A_D3: length 26.4
  TOP w0.102: v2(57.67,97.58) 57.74,97.65 57.74,97.93 57.59,98.07 57.36,98.07 UV9.G2
  IN3 w0.127: v2(62.11,80.94) 62.52,81.35 63.19,81.35 63.37,81.53 63.37,82.35 62.48,83.24 62.48,84.79 61.99,85.28 61.98,85.28 61.75,85.51 61.75,85.52 61.61,85.65 61.61,93.39 61.49,93.51 59.68,93.51 59.56,93.64 59.56,94.03 59.43,94.16 59.05,94.16 58.92,94.03 58.92,93.31 58.79,93.19 58.22,93.19 58.07,93.34 58.07,97.18 v2(57.67,97.58)
  BOTTOM w0.102: v2(57.67,97.58) 57.67,98.38 57.27,98.78 UV4.H8
  BOTTOM w0.127: v2(62.11,80.94) 62.52,81.35 UV1.F17
FB_A_D4: length 22.5
  TOP w0.102: UV9.H7 v2(52.87,98.38)
  IN3 w0.127: v2(52.87,98.38) 53.39,97.86 53.39,96.48 53.74,96.13 53.74,92.29 55,91.03 55.12,90.91 55.12,90.73 54.49,90.11 54.49,89.93 54.67,89.75 54.85,89.75 55.48,90.38 55.66,90.38 55.84,90.19 55.84,90.02 55.21,89.4 55.21,89.22 56.91,87.52 56.91,86.91 57.65,86.16 57.65,85.34 57.9,85.09 58.46,85.09 59.81,83.75 59.81,83.6 v2(59.61,83.4)
  BOTTOM w0.102: UV9.H7 v2(52.87,98.38)
  BOTTOM w0.127: UV1.D20 60.04,83.06 59.7,83.4 v2(59.61,83.4)
FB_A_D5: length 19.7
  TOP w0.102: v2(53.8,96.78) 53.4,97.18 UV9.F7
  IN3 w0.127: v2(53.8,96.78) 53.8,96.49 54.1,96.19 54.1,92.4 56.35,90.15 56.35,89.97 55.77,89.38 55.77,89.2 57.27,87.7 57.27,87.07 57.92,86.41 57.92,85.49 58.1,85.32 58.55,85.32 60.06,83.81 60.06,83 59.69,82.63 v2(59.57,82.63)
  BOTTOM w0.102: v2(53.8,96.78) 53.4,96.38 UV4.E3
  BOTTOM w0.127: UV1.D21 v2(59.57,82.63)
FB_A_D6: length 24.1
  TOP w0.102: UV9.H8 v2(52.07,98.38)
  IN3 w0.127: v2(52.07,98.38) 52.47,97.98 52.47,92.53 52.38,92.45 52.38,91.11 55.52,87.98 55.52,85.88 55.94,85.46 56.62,85.46 57.44,84.64 58.16,84.64 58.41,84.39 58.41,82.04 59.09,81.36 60.06,81.36 v2(60.46,80.96)
  BOTTOM w0.102: v2(52.07,98.38) 52.07,98.38 UV4.G2
  BOTTOM w0.127: UV1.F20 60.06,81.36 v2(60.46,80.96)
FB_A_D7: length 21.9
  TOP w0.102: UV9.F8 v2(52.87,96.78)
  IN3 w0.102: v2(59.63,81.81) 59.19,82.25 59.19,83.05
  IN3 w0.127: v2(52.87,96.78) 52.87,96.6 53.35,96.12 53.35,92.22 53.74,91.83 53.74,91.65 53.3,91.2 53.3,91.02 53.58,90.74 53.76,90.74 54.2,91.19 54.38,91.19 54.56,91.01 54.56,90.83 53.94,90.2 53.94,90.02 56.51,87.45 56.51,86.8 56.7,86.61 56.7,85.7 57.54,84.87 58.31,84.87 59.19,83.99 59.19,83.05
  BOTTOM w0.102: v2(52.87,96.78) 52.47,97.18 UV9.F8
  BOTTOM w0.127: UV1.E21 59.24,82.2 v2(59.63,81.81)
FB_A_D8: length 22.6
  TOP w0.102: UV5.F8 v2(66.55,96.78)
  IN1 w0.102: v2(63.78,81.79) 63.38,82.19 63.24,82.19 62.17,83.26 62.17,84.69 61.35,85.51 61.35,85.92 61.87,86.44 62.23,86.44 62.92,87.13 62.92,87.24 62.52,87.64 62.52,87.75 62.78,88.01 62.89,88.01 63.14,87.76 63.28,87.76 63.42,87.91 63.42,88.05 63.24,88.24 63.24,88.38 63.38,88.53 63.53,88.53 63.71,88.34 63.86,88.34 66.15,90.63 66.15,91.76 66.25,91.86 66.55,91.86 66.63,91.94 66.63,92.19 66.55,92.27 66.25,92.27 66.15,92.37 66.15,96.38 v2(66.55,96.78)
  BOTTOM w0.102: v2(66.55,96.78) UV5.F8
  BOTTOM w0.127: UV1.E15 63.78,81.82 v2(63.78,81.79)
FB_A_D9: length 22.8
  TOP w0.102: v2(66.55,97.58) 66.55,98.38 UV5.H8
  IN1 w0.102: v2(63.76,82.59) 63.61,82.59 63.19,83.01 62.83,83.01 62.43,83.41 62.43,84.8 61.73,85.5 61.73,85.85 61.95,86.08 62.38,86.08 63.58,87.27 63.78,87.27 63.96,87.09 64.06,87.09 64.31,87.34 64.31,87.45 63.98,87.79 63.98,88.03 66.94,90.99 66.94,97.19 v2(66.55,97.58)
  BOTTOM w0.102: v2(66.55,97.58) 66.55,98.22 66.62,98.3 66.82,98.3 66.95,98.17 UV8.G2 ; v2(63.76,82.59) 64.16,82.99 UV1.D15
FB_A_D10: length 24.3
  TOP w0.102: v2(68.58,97.78) 68.58,97.81 67.75,98.64 UV5.H7
  IN1 w0.102: v2(64.55,81.76) 64.55,82.48 64.02,83.01 63.48,83.01 63.32,83.17 63.32,83.65 63.05,83.92 63.05,84.46 63.4,84.81 63.4,86 64.72,87.32 64.72,87.47 64.36,87.84 64.36,87.98 64.5,88.12 64.65,88.12 65.01,87.76 65.15,87.76 65.3,87.9 65.3,88.05 64.93,88.41 64.93,88.55 67.24,90.86 67.24,92.19 67.32,92.27 67.66,92.27 67.76,92.37 67.76,96.96 v2(68.58,97.78)
  BOTTOM w0.102: v2(68.58,97.78) 68.58,98.05 67.85,98.78 UV5.H7
  BOTTOM w0.127: v2(64.55,81.76) 64.16,81.37 UV1.F15
FB_A_D11: length 25.6
  TOP w0.102: UV5.F7 v2(68.15,96.78)
  IN1 w0.102: v2(65.43,80.95) 65.03,81.35 65.03,82.29 64.17,83.14 64.17,83.55 63.95,83.77 63.51,83.77 63.35,83.93 63.35,84.38 63.7,84.73 63.7,85.87 65.8,87.97 65.8,88.12 65.44,88.48 65.44,88.63 65.58,88.77 65.73,88.77 66.09,88.4 66.24,88.4 66.42,88.59 66.42,88.73 66.05,89.1 66.05,89.24 66.22,89.41 66.36,89.41 66.72,89.05 66.88,89.05 67,89.17 67,89.34 66.65,89.69 66.65,89.84 66.79,89.98 66.94,89.98 67.29,89.63 67.46,89.63 67.58,89.74 67.58,89.91 67.22,90.27 67.22,90.41 67.37,90.56 67.51,90.56 67.8,90.26 67.97,90.26 68.09,90.38 68.09,90.55 67.8,90.84 67.8,90.99 68.09,91.28 68.09,93.25 67.98,93.36 67.98,96.61 v2(68.15,96.78)
  BOTTOM w0.102: UV8.E3 67.75,96.38 v2(68.15,96.78)
  BOTTOM w0.127: UV1.F13 v2(65.43,80.95)
FB_A_D12: length 24.2
  TOP w0.102: UV5.H3 70.95,98.78 v2(71.35,98.38)
  IN1 w0.102: v2(65.41,83.37) 65.87,83.83 65.87,85.59 66.48,86.2 66.63,86.2 67.01,85.82 67.15,85.82 67.29,85.96 67.29,86.1 66.91,86.48 66.91,86.63 67.06,86.77 67.2,86.77 67.58,86.39 67.73,86.39 67.87,86.54 67.87,86.68 67.49,87.06 67.49,87.2 68.07,87.78 68.21,87.78 68.64,87.34 68.75,87.34 68.93,87.52 68.93,87.63 68.5,88.07 68.5,88.21 69.56,89.27 69.56,89.68 69.63,89.76 70.04,89.76 70.12,89.83 70.12,90.11 70.04,90.19 69.63,90.19 69.56,90.26 69.56,90.52 69.63,90.59 70.04,90.59 70.12,90.67 70.12,97.15 v2(71.35,98.38)
  BOTTOM w0.102: v2(71.35,98.38) 70.95,98.78 UV5.H3
  BOTTOM w0.127: UV1.C13 65.43,83.39 65.43,83.39 v2(65.41,83.37)
FB_A_D13: length 22.6
  TOP w0.102: UV5.E3 v2(70.55,96.78)
  IN1 w0.102: v2(66.26,84.2) 66.66,84.6 66.66,85.28 66.8,85.41 67.25,85.41 69.42,87.58 69.42,87.72 68.98,88.16 68.98,88.26 69.16,88.44 69.27,88.44 69.72,87.99 69.83,87.99 70.11,88.27 70.11,88.38 69.66,88.82 69.66,88.94 69.82,89.11 69.97,89.11 70.4,88.67 70.51,88.67 70.69,88.85 70.69,88.96 70.4,89.25 70.4,89.41 70.61,89.61 71.29,89.61 71.39,89.72 71.39,89.92 71.29,90.02 70.56,90.02 70.48,90.1 70.48,90.35 70.56,90.43 71.29,90.43 71.39,90.53 71.39,90.73 71.29,90.83 70.56,90.83 70.48,90.91 70.48,96.71 v2(70.55,96.78)
  BOTTOM w0.102: v2(70.55,96.78) 70.95,97.18 UV8.F7
  BOTTOM w0.127: v2(66.26,84.2) 66.24,84.2 UV1.B13
FB_A_D14: length 24.6
  TOP w0.102: UV5.G2 v2(72.15,98.38)
  IN1 w0.102: v2(72.15,98.38) UV5.G2 71.75,92.58 72,92.32 72,88.32 70.42,86.73 70.27,86.73 69.97,87.03 69.83,87.03 69.68,86.89 69.68,86.75 69.98,86.45 69.98,86.3 69.84,86.16 69.7,86.16 69.4,86.46 69.25,86.46 69.11,86.32 69.11,86.17 69.41,85.87 69.41,85.73 69.27,85.58 69.12,85.58 68.82,85.88 68.68,85.88 68.53,85.74 68.53,85.6 68.83,85.3 68.83,85.15 68.69,85.01 68.55,85.01 68.25,85.31 68.1,85.31 67.96,85.17 67.96,85.02 68.26,84.72 68.26,84.58 67.72,84.04 67.72,83.41 66.89,82.58 v2(66.22,82.58)
  BOTTOM w0.102: v2(72.15,98.38) 71.75,98.78 UV8.H8
  BOTTOM w0.127: v2(66.22,82.58) UV1.E13
FB_A_D15: length 23.5
  TOP w0.102: UV5.F2 v2(71.35,96.78)
  IN1 w0.102: v2(66.22,83.38) 66.34,83.38 66.77,83.81 67.36,83.81 67.41,83.87 67.41,85.15 69.85,87.58 70,87.58 70.36,87.22 70.47,87.22 70.65,87.4 70.65,87.51 70.28,87.87 70.28,88.02 70.43,88.16 70.57,88.16 70.94,87.79 71.05,87.79 71.23,87.97 71.23,88.08 70.86,88.45 70.86,88.59 71,88.73 71.15,88.73 71.41,88.47 71.52,88.47 71.7,88.65 71.7,88.76 71.43,89.02 71.43,89.17 71.7,89.43 71.7,91.06 71.62,91.14 70.92,91.14 70.84,91.21 70.84,91.44 70.94,91.54 71.6,91.54 71.7,91.65 71.7,91.85 71.6,91.95 70.94,91.95 70.84,92.05 70.84,96.27 v2(71.35,96.78)
  BOTTOM w0.102: v2(71.35,96.78) 71.75,97.18 UV5.F2
  BOTTOM w0.127: v2(66.22,83.38) 66.22,83.4 65.84,83.02 UV1.D13
FB_A_D16: length 18.7
  TOP w0.102: UV5.C2 71.75,94.78 v2(71.35,94.38)
  IN3 w0.127: v2(63.75,84.19) 65.02,85.46 65.31,85.46 65.65,85.8 65.65,86.06 66.36,86.77 66.54,86.77 66.85,86.46 67.03,86.46 67.21,86.64 67.21,86.82 66.9,87.13 66.9,87.31 69.04,89.45 69.22,89.45 69.94,88.73 70.12,88.73 72.19,90.8 72.19,91.69 71.75,92.13 71.75,93.1 71.35,93.49 v2(71.35,94.38)
  BOTTOM w0.102: UV5.C2 71.35,94.38 v2(71.35,94.38)
  BOTTOM w0.127: UV1.B15 64.15,84.6 63.75,84.19 v2(63.75,84.19)
FB_A_D17: length 17
  TOP w0.102: UV5.C3 v2(71.35,95.18)
  IN3 w0.127: v2(71.35,95.18) 70.94,94.77 70.94,92.28 64.78,86.12 64.78,85.79 63.32,84.33 63.32,83.8 v2(63.73,83.39)
  BOTTOM w0.102: UV8.D7 70.95,95.58 v2(71.35,95.18) ; v2(63.73,83.39) 63.36,83.76 UV1.C16
FB_A_D18: length 17.9
  TOP w0.102: UV5.A2 v2(72.15,93.58)
  IN3 w0.127: v2(72.15,93.58) 72.15,93.38 72.55,92.98 72.55,90.69 70.03,88.17 69.85,88.17 69.13,88.89 68.95,88.89 68.77,88.71 68.77,88.53 69.48,87.82 69.48,87.64 69.27,87.43 69.09,87.43 68.38,88.13 68.18,88.13 67.49,87.43 67.49,87.18 68.07,86.61 68.07,86.41 67.24,85.59 66.52,85.59 66.27,85.34 v2(66.27,84.99)
  BOTTOM w0.102: UV8.B8 71.75,93.98 v2(72.15,93.58)
  BOTTOM w0.127: v2(66.27,84.99) 65.85,85.4 UV1.A13
FB_A_D19: length 18.5
  TOP w0.102: v2(71.35,92.78) 70.95,93.18 UV5.A3
  IN3 w0.127: v2(65.19,85.87) 65.19,86.07 69.13,90.01 69.31,90.01 70.03,89.29 70.21,89.29 70.39,89.47 70.39,89.65 69.67,90.37 69.67,90.55 69.85,90.73 70.03,90.73 70.75,90.01 70.93,90.01 71.11,90.19 71.11,90.37 70.39,91.09 70.39,91.27 70.57,91.45 70.75,91.45 71.45,90.74 71.63,90.74 71.81,90.92 71.81,91.1 71.11,91.8 71.11,91.98 71.35,92.23 v2(71.35,92.78)
  BOTTOM w0.102: v2(71.35,92.78) 70.95,93.18 UV5.A3
  BOTTOM w0.127: UV1.A15 64.41,85.4 64.89,85.87 v2(65.19,85.87)
FB_A_D20: length 17.3
  TOP w0.102: UV5.A7 v2(67.35,92.78)
  IN3 w0.127: v2(62.14,85.67) 62.43,85.96 62.43,86.2 65.78,89.55 65.78,89.73 65.26,90.25 65.26,90.43 65.44,90.61 65.62,90.61 66.14,90.09 66.32,90.09 66.55,90.32 66.55,90.5 66.03,91.02 66.03,91.2 66.21,91.38 66.39,91.38 66.91,90.86 67.09,90.86 67.27,91.04 67.27,91.22 66.75,91.74 66.75,91.92 66.93,92.1 67.11,92.1 67.63,91.58 67.81,91.58 68.07,91.83 68.07,92.06 v2(67.35,92.78)
  BOTTOM w0.102: UV5.A7 v2(67.35,92.78)
  BOTTOM w0.127: UV1.B18 62.09,85.01 62.09,85.62 v2(62.14,85.67)
FB_A_D21: length 15.9
  TOP w0.102: UV5.B8 v2(66.55,93.58)
  IN3 w0.127: v2(66.55,93.58) 66.95,93.18 66.95,92.58 64.7,90.34 64.7,90.22 65.22,89.7 65.22,89.46 65.04,89.28 64.86,89.28 64.17,89.96 64,89.96 63.82,89.78 63.82,89.61 64.49,88.93 64.49,88.75 64.31,88.57 64.13,88.57 63.71,88.99 63.53,88.99 63.3,88.76 63.3,88.58 63.62,88.26 63.62,87.85 62.73,86.96 v2(62.12,86.96)
  BOTTOM w0.102: v2(66.55,93.58) 66.95,93.18 UV8.A2
  BOTTOM w0.124: UV1.A18 61.68,85.81 62.12,86.25 v2(62.12,86.96)
FB_A_D22: length 16.3
  TOP w0.102: UV5.D7 v2(67.35,95.18)
  IN3 w0.102: v2(67.35,95.18) 66.97,94.8 65.52,94.8 65.28,94.55
  IN3 w0.127: 65.28,94.55 65.28,93.64 64.02,92.38 63.62,92.38 63.27,92.03 63.27,91.87 63.51,91.63 63.51,91.45 63.3,91.24 63.12,91.24 62.85,91.5 62.67,91.5 62.47,91.3 62.47,91.12 63.22,90.37 63.22,90.13 62.14,89.04 62.14,88.16 v2(62.12,88.17)
  BOTTOM w0.102: v2(67.35,95.18) 67.75,94.78 UV8.C3
  BOTTOM w0.124: UV1.A19 60.88,86.92 v2(62.12,88.17)
FB_A_D23: length 17.3
  TOP w0.102: UV5.C8 v2(66.55,94.38)
  IN3 w0.102: 66.15,92.76 66.15,94.34 66.26,94.45 66.47,94.45 v2(66.55,94.38)
  IN3 w0.127: v2(62.12,87.57) 62.54,87.99 62.54,88.98 64.49,90.92 64.49,91.1 64.13,91.46 64.13,91.64 64.31,91.82 64.49,91.82 64.85,91.46 65.03,91.46 65.21,91.64 65.21,91.82 64.66,92.37 64.66,92.55 64.84,92.73 65.02,92.73 65.57,92.18 65.75,92.18 66.15,92.58 66.15,92.76
  BOTTOM w0.102: UV5.C8 v2(66.55,94.38)
  BOTTOM w0.124: 61.27,85.93 61.71,86.37 61.71,87.16 v2(62.12,87.57)
  BOTTOM w0.127: 61.27,85.93 61.27,84.19 UV1.C19
FB_A_D24: length 16.3
  TOP w0.102: UV9.C8 v2(52.07,94.38)
  IN1 w0.102: v2(52.07,94.38) 52.34,94.38 52.47,94.25 52.47,86.45 52.6,86.33 52.86,86.33 52.99,86.45 52.99,86.99 53.11,87.11 53.28,87.11 53.4,86.99 53.4,86.45 53.52,86.33 55.69,86.33 55.82,86.2 55.82,85.44 v2(56.26,85)
  BOTTOM w0.102: UV9.C8 v2(52.07,94.38)
  BOTTOM w0.127: UV1.B24 56.39,84.6 56.26,84.73 v2(56.26,85)
FB_A_D25: length 17.6
  TOP w0.102: UV9.D7 v2(52.87,95.18)
  IN1 w0.102: v2(57.12,84.29) 56.78,84.64 56.78,86.24 56.9,86.37 57.12,86.37 57.25,86.49 57.25,87.43 56.5,88.18 56.37,88.18 56.09,87.9 55.91,87.9 55.79,88.02 55.79,88.19 56.05,88.46 56.05,88.62 55.94,88.74 55.77,88.74 55.02,88 54.88,88 53.67,89.2 53.67,92.51 53.6,92.58 53.6,94.45 v2(52.87,95.18)
  BOTTOM w0.102: UV4.C3 v2(52.87,95.18)
  BOTTOM w0.127: UV1.C23 57.55,83.86 v2(57.12,84.29)
FB_A_D26: length 14.2
  TOP w0.102: UV9.A7 53.27,92.83
  TOP w0.124: v2(52.88,92.42) 53.27,92.81 53.27,92.83
  IN1 w0.102: v2(55.95,86.63) 55.95,86.63 53.86,86.63 53.76,86.73 53.76,88.25 53.64,88.37 53.48,88.37 53.36,88.25 53.36,87.55 53.23,87.42 53,87.42 52.88,87.55 v2(52.88,92.42)
  BOTTOM w0.102: UV9.A7 53.27,92.81 53.04,92.58
  BOTTOM w0.124: v2(55.95,86.63) 55.63,86.63 55.51,86.5 55.51,86.22 ; 53.04,92.58 v2(52.88,92.42)
  BOTTOM w0.127: UV1.A25 55.63,85.4 55.51,85.53 55.51,86.22
FB_A_D27: length 15.2
  TOP w0.102: v2(52.87,93.58) 52.47,93.98 UV9.B8
  IN1 w0.102: v2(56.23,85.95) 56.42,86.13 56.42,86.78 56.85,87.22 56.85,87.4 56.56,87.69 56.38,87.69 55.63,86.94 55.45,86.94 55.32,87.07 55.32,87.25 55.63,87.57 55.63,87.75 55.51,87.87 55.33,87.87 54.61,87.16 54.43,87.16 54.24,87.35 54.24,87.53 54.49,87.77 54.49,87.95 53.29,89.15 53.29,93.15 v2(52.87,93.58)
  BOTTOM w0.102: UV4.A2 v2(52.87,93.58)
  BOTTOM w0.127: v2(56.23,85.95) 56.7,85.48 UV1.A24
FB_A_D28: length 17.5
  TOP w0.102: v2(56.87,93.58) 57.27,93.18 UV9.A2
  IN1 w0.102: v2(56.87,93.58) 56.48,93.19 56.48,92.61 55.62,91.75 55.62,91.56 55.78,91.4 55.92,91.4 56.79,92.27 56.94,92.27 57.08,92.13 57.08,91.98 56.21,91.11 56.21,90.97 56.36,90.83 56.5,90.83 57.37,91.7 57.51,91.7 57.66,91.55 57.66,91.41 56.79,90.54 56.79,90.4 59.42,87.76 v2(59.93,87.76)
  BOTTOM w0.102: UV4.B8 57.27,93.98 56.87,93.58 v2(56.87,93.58)
  BOTTOM w0.124: v2(59.93,87.76) 59.36,87.2 59.36,85.56 UV1.A21
FB_A_D29: length 17.5
  TOP w0.102: 56.13,92.83 56.47,93.17 UV9.A3
  TOP w0.124: v2(56.07,92.78) 56.07,92.76 56.13,92.83
  IN1 w0.102: v2(58.72,86.64) 58.29,86.64 58.16,86.51 58.16,84.83 58.29,84.7 59.45,84.7 59.58,84.83 59.58,87.17 55.26,91.5 55.26,91.96 v2(56.07,92.78)
  BOTTOM w0.102: UV9.A3 v2(56.07,92.78)
  BOTTOM w0.124: UV1.B21 58.84,84.96 58.84,85.55 59.1,85.81 59.1,86.18 58.72,86.56 v2(58.72,86.64)
FB_A_D30: length 19.1
  TOP w0.102: UV9.C2 v2(57.67,94.38)
  IN1 w0.102: v2(60.16,86.27) 60.16,86.57 60.72,87.14 60.72,88.01 59.94,88.79 59.94,89.02 60.42,89.5 60.42,89.68 60.28,89.82 60.1,89.82 59.24,88.97 59.08,88.97 58.96,89.09 58.96,89.26 59.81,90.12 59.81,90.26 59.67,90.4 59.53,90.4 59.09,89.96 58.92,89.96 58.8,90.08 58.8,90.25 59.24,90.69 59.24,90.83 57.84,92.23 57.84,92.38 58.06,92.6 58.06,94.69 57.94,94.82 57.8,94.82 57.67,94.69 v2(57.67,94.38)
  BOTTOM w0.102: UV9.C2 v2(57.67,94.38)
  BOTTOM w0.124: v2(60.16,86.27) 60.48,85.95 60.48,84.24 UV1.C20
FB_A_D31: length 19.1
  TOP w0.102: UV9.C3 v2(56.87,95.18)
  IN1 w0.102: v2(59.99,87.18) 59.99,87.2 60.36,87.58 60.36,87.94 60.11,88.19 59.42,88.19 58.48,89.14 58.48,89.28 58.74,89.54 58.74,89.71 58.62,89.83 58.45,89.83 58.19,89.57 58.04,89.57 57.87,89.75 57.87,89.89 58.72,90.75 58.72,90.92 58.6,91.04 58.44,91.04 57.58,90.18 57.44,90.18 57.29,90.32 57.29,90.47 58.16,91.34 58.16,91.48 57.28,92.36 57.28,94.77 v2(56.87,95.18)
  BOTTOM w0.102: UV4.D7 56.47,95.58 v2(56.87,95.18)
  BOTTOM w0.124: UV1.C21 59.69,84.29 59.69,86.04 59.74,86.09 59.74,86.92 59.99,87.17 v2(59.99,87.18)
FB_A_D32: length 29.7
  TOP w0.102: v2(42.92,81.3) 42.52,80.91 UV7.F8
  IN3 w0.102: v2(57.9,74.28) 57.15,74.28 56.34,73.47 56.34,73.18 55.95,72.8 55.95,72.28 55.83,72.16 55.27,72.16 54.86,72.57
  IN3 w0.127: v2(42.92,81.3) 43.31,81.7 44.68,81.7 44.92,81.46 44.92,79.55 44.92,79.55 44.92,79.54 45.26,79.2 45.88,79.2 46.55,78.53 46.55,77.77 48.58,75.74 48.58,75.56 48.07,75.04 48.07,74.86 48.25,74.69 48.43,74.69 48.94,75.2 49.12,75.2 49.37,74.95 49.37,74.77 48.86,74.26 48.86,74.08 49.03,73.9 49.21,73.9 49.73,74.41 49.91,74.41 50.13,74.19 50.13,74.01 49.62,73.5 49.62,73.32 49.8,73.14 49.98,73.14 50.49,73.65 50.67,73.65 50.85,73.47 50.85,73.29 50.6,73.03 50.6,72.85 50.77,72.67 50.95,72.67 51.21,72.93 51.39,72.93 51.65,72.67 52.75,72.67 52.85,72.57 54.86,72.57
  BOTTOM w0.102: UV7.F8 v2(42.92,81.3) ; v2(57.9,74.28) 58.32,73.86 UV1.R22
FB_A_D33: length 24.7
  TOP w0.102: v2(42.12,80.5) 41.32,80.5 40.92,80.9 UV7.H8
  IN3 w0.102: v2(57.14,73.44) 57.14,73.41 56.36,72.62 56.36,71.77 55.78,71.19 54.65,71.19 54.29,71.55 53.4,71.55 52.95,72 52.56,72
  IN3 w0.127: v2(42.12,80.5) 42.52,80.11 43.13,80.11 43.32,79.92 43.32,79.55 43.74,79.13 43.92,79.13 44.5,78.54 45.56,78.54 45.89,78.21 45.89,76.11 50,72 52.56,72
  BOTTOM w0.102: UV15.G2 41.63,80.81 41.63,80.58 41.77,80.44 42.05,80.44 v2(42.12,80.5)
  BOTTOM w0.127: v2(57.14,73.44) 56.72,73.86 UV1.R24
FB_A_D34: length 24.5
  TOP w0.102: UV7.F7 42.52,81.71 v2(42.92,82.1)
  IN3 w0.102: v2(58.76,73.49) 58.53,73.72 58.53,74.17 58.04,74.66 57.24,74.66 56.13,73.55 56.13,73.26 55.8,72.93 55.32,72.93 55.19,72.8 53.36,72.8
  IN3 w0.127: v2(42.92,82.1) 45.07,82.1 45.72,81.46 45.72,80.66 46.45,79.93 46.45,79.28 46.88,78.85 46.88,77.91 51.78,73 52.73,73 52.93,72.8 53.36,72.8
  BOTTOM w0.102: UV15.E3 v2(42.92,82.1)
  BOTTOM w0.127: v2(58.76,73.49) 58.34,73.07 UV1.T22
FB_A_D35: length 27.8
  TOP w0.102: v2(42.12,81.3) 41.57,81.3 41.17,81.7 UV7.H7
  IN3 w0.102: v2(57.92,73.55) 57.92,73.72 57.65,74 57.15,74 56.57,73.41 56.57,73.13 56.15,72.71 56.15,71.86 55.7,71.4 55.25,71.4 55.09,71.55 55.09,71.98 54.73,72.34
  IN3 w0.127: v2(42.12,81.3) 42.52,80.9 43.93,80.9 44.12,80.71 44.12,79.54 44.79,78.87 45.69,78.87 46.22,78.34 46.22,77.63 48.04,75.82 48.04,75.64 47.52,75.13 47.52,74.95 50.13,72.34 54.73,72.34
  BOTTOM w0.102: v2(42.12,81.3) 41.63,81.3 41.23,81.7 UV7.H7 ; v2(57.92,73.55) 57.61,73.86 UV1.R23
FB_A_D36: length 28.9
  TOP w0.102: UV7.G2 41.32,86.1 v2(41.32,86.1)
  IN3 w0.127: v2(56.3,75.92) 56.16,76.06 55.98,76.06 55.47,76.57 55.05,76.57 54.92,76.45 54.92,76.13 54.86,76.06 54.53,76.06 51.59,79 51.59,79.18 51.85,79.44 51.85,79.62 51.67,79.8 51.49,79.8 51,79.31 50.82,79.31 50.64,79.49 50.64,79.67 51.34,80.37 51.34,80.55 51.16,80.73 50.98,80.73 50.15,79.9 49.97,79.9 49.79,80.08 49.79,80.26 50.67,81.14 50.67,82.08 49.93,82.81 49.93,84.07 47.5,86.5 41.4,86.5 41.32,86.43 v2(41.32,86.1)
  BOTTOM w0.102: UV15.H8 v2(41.32,86.1)
  BOTTOM w0.127: UV1.N25 55.9,75.95 55.95,76 56.22,76 v2(56.3,75.92)
FB_A_D37: length 27.2
  TOP w0.102: v2(42.92,85.3) 42.52,85.7 UV7.F2
  IN3 w0.127: v2(55.5,75.92) 55.39,76.03 55.19,76.03 54.96,75.79 54.33,75.79 51.15,78.98 50.42,78.98 49.23,80.17 49.23,81.15 49.36,81.27 49.58,81.27 49.9,80.95 50.01,80.95 50.34,81.28 50.34,81.79 50.16,81.97 49.97,81.97 49.78,81.78 49.36,81.78 49.23,81.91 49.23,82.16 49.36,82.29 49.51,82.29 49.64,82.42 49.64,82.67 49.51,82.8 49.16,82.8 49.03,82.93 49.03,83.23 49.16,83.36 49.48,83.36 49.6,83.49 49.6,83.74 49.48,83.87 49.16,83.87 49.03,83.99 49.03,84.5 47.83,85.71 47.4,85.71 47.27,85.83 47.27,86.03 47.15,86.16 46.89,86.16 46.76,86.03 46.76,85.83 46.64,85.71 43.44,85.71 42.91,86.23 42.73,86.23 42.45,85.95 42.45,85.77 v2(42.92,85.3)
  BOTTOM w0.102: UV7.F2 v2(42.92,85.3)
  BOTTOM w0.127: v2(55.5,75.92) 55.12,75.54 UV1.N26
FB_A_D38: length 29
  TOP w0.102: UV7.E3 43.32,84.77 v2(42.92,84.38)
  IN3 w0.102: 54.54,74.67 55.05,74.67 55.14,74.76 56.74,74.76 v2(57.12,75.14)
  IN3 w0.127: v2(42.92,84.38) 46.99,84.38 47.26,84.11 47.44,84.11 47.79,84.45 47.97,84.45 48.15,84.27 48.15,84.09 47.55,83.5 47.55,83.02 48.57,82.01 48.57,79.18 48.93,78.82 48.93,78.64 48.75,78.46 48.75,78.36 48.98,78.13 49.14,78.13 49.65,78.64 49.83,78.64 50.01,78.46 50.01,78.28 49.47,77.74 49.47,77.64 49.71,77.4 49.84,77.4 50.37,77.92 50.55,77.92 50.73,77.74 50.73,77.56 50.22,77.06 50.22,76.89 50.41,76.7 50.58,76.7 51.09,77.2 51.27,77.2 51.54,76.93 51.54,76.75 51.2,76.41 51.2,76.23 51.42,76.01 52.01,76.01 52.94,75.08 54.13,75.08 54.54,74.67
  BOTTOM w0.102: UV15.F7 42.52,84.78 v2(42.92,84.38)
  BOTTOM w0.127: UV1.N23 57.5,75.52 v2(57.12,75.14)
FB_A_D39: length 28.8
  TOP w0.102: UV7.H3 v2(41.32,85.3)
  IN3 w0.102: v2(56.36,75.14) 55.98,75.52 55.05,75.52
  IN3 w0.127: v2(41.32,85.3) 41.84,84.78 48.28,84.78 48.7,84.37 48.7,83.67 48.57,83.54 48.06,83.54 47.94,83.42 47.94,83.16 48.06,83.03 48.57,83.03 48.7,82.91 48.7,82.45 48.9,82.24 48.9,80.04 50.47,78.47 50.65,78.47 50.83,78.65 51.01,78.65 51.19,78.47 51.19,78.29 51.01,78.11 51.01,77.93 51.19,77.75 51.37,77.75 51.55,77.93 51.73,77.93 51.91,77.75 51.91,77.57 51.73,77.39 51.73,77.21 51.91,77.03 52.09,77.03 52.27,77.21 52.45,77.21 52.63,77.03 52.63,76.85 52.22,76.45 52.22,76.27 52.4,76.09 52.58,76.09 52.99,76.49 53.16,76.49 53.34,76.31 53.34,76.13 52.95,75.74 52.95,75.56 53.16,75.34 53.34,75.34 53.75,75.75 53.9,75.75 54.13,75.52 55.05,75.52
  BOTTOM w0.102: UV7.H3 v2(41.32,85.3)
  BOTTOM w0.127: v2(56.36,75.14) 56.7,75.48 UV1.N24
FB_A_D40: length 23
  TOP w0.102: UV6.G2 41.53,71.23 41.4,71.35 41.4,71.55 41.48,71.63 v2(42.12,71.63)
  IN3 w0.102: v2(42.12,71.63) 42.51,71.24 44.76,71.24 44.92,71.4 44.92,72.78 45.03,72.9 ; 53.18,71.14 54.12,71.14 54.48,70.79 55.95,70.79 56.76,71.6 56.76,71.73 56.87,71.84 57.08,71.84 57.11,71.8 v2(57.11,71.77)
  IN3 w0.127: 53.18,71.14 53.16,71.16 49.66,71.16 48.34,72.47 48,72.47 47.88,72.6 47.88,72.94 47.75,73.07 46.95,73.07 46.82,73.19 46.82,73.78 46.69,73.91 46.44,73.91 46.31,73.78 46.31,73.19 46.18,73.07 45.21,73.07 45.03,72.9
  BOTTOM w0.102: v2(42.12,71.63) 41.32,71.63 UV14.H8
  BOTTOM w0.127: UV1.V23 57.5,71.39 v2(57.11,71.77)
FB_A_D41: length 24
  TOP w0.102: v2(42.92,70.02) 43.32,70.42 UV6.E3
  IN3 w0.102: v2(58.75,71.79) 58.35,71.39 57.57,71.39 57.37,71.19 56.92,71.19 56.12,70.38 54.15,70.38 53.84,70.07 ; v2(42.92,70.02) 43.09,70.19 46.7,70.19 46.86,70.03
  IN3 w0.127: 46.86,70.03 46.9,69.99 47.09,69.99 47.22,70.12 47.22,70.57 47.35,70.7 47.6,70.7 47.73,70.57 47.73,70.12 47.86,69.99 48.11,69.99 48.24,70.12 48.24,71.14 48.36,71.26 48.62,71.26 48.75,71.14 48.75,70.12 48.87,69.99 49.19,69.99 49.32,70.12 49.32,70.37 49.44,70.5 49.7,70.5 49.83,70.37 49.83,70.12 49.95,69.99 50.21,69.99 50.33,70.12 50.33,70.37 50.46,70.5 50.71,70.5 50.84,70.37 50.84,70.12 50.97,69.99 51.22,69.99 51.35,70.12 51.35,70.37 51.48,70.5 51.73,70.5 51.86,70.37 51.86,70.12 51.98,69.99 52.89,69.99 52.97,70.07 53.84,70.07
  BOTTOM w0.102: UV14.F7 v2(42.92,70.02)
  BOTTOM w0.127: UV1.V22 v2(58.75,71.79)
FB_A_D42: length 23
  TOP w0.102: v2(42.92,71.63) UV6.F2
  IN3 w0.102: 44.22,72.9 44.1,72.78 44.1,72.15 43.97,72.03 43.32,72.03 v2(42.92,71.63) ; 52.56,71.49 53.14,71.49 53.28,71.34 54.21,71.34 54.56,70.99 55.86,70.99 56.56,71.69 56.56,72.53 56.75,72.73 56.98,72.73 v2(57.12,72.58)
  IN3 w0.127: 52.56,71.49 49.79,71.49 47.89,73.4 47.28,73.4 47.15,73.52 47.15,74.14 47.02,74.26 46.11,74.26 45.98,74.14 45.98,73.52 45.85,73.4 45.6,73.4 45.47,73.52 45.47,74.41 45.35,74.54 44.98,74.54 44.85,74.41 44.85,73.18 44.57,72.9 44.22,72.9
  BOTTOM w0.102: UV6.F2 v2(42.92,71.63)
  BOTTOM w0.127: UV1.T23 57.5,72.96 v2(57.12,72.58)
FB_A_D43: length 25.1
  TOP w0.102: v2(41.92,69.6) 41.65,69.6 40.92,70.33 UV6.H3
  IN3 w0.102: 46.98,72.03 46.68,72.03 46.54,71.88 46.54,70.57 46.41,70.44 42.41,70.44 42.28,70.32 42.28,69.96 v2(41.92,69.6) ; 53.81,70.58 56.03,70.58 56.84,71.39 57.28,71.39 57.5,71.6 57.5,72.43 57.63,72.56 v2(57.91,72.56)
  IN3 w0.127: 46.98,72.03 47.25,72.03 47.38,71.9 47.38,71.16 47.51,71.03 47.76,71.03 47.89,71.16 47.89,71.88 48.02,72.01 48.34,72.01 49.52,70.83 51.87,70.83 52.38,70.32 53.55,70.32 53.81,70.58
  BOTTOM w0.102: UV6.H3 41.06,70.43 41.89,69.6 v2(41.92,69.6)
  BOTTOM w0.127: v2(57.91,72.56) 58.25,72.22 UV1.U22
FB_A_D44: length 22.8
  TOP w0.102: UV6.H7 40.92,67.23 v2(41.32,66.83)
  IN3 w0.102: 54.22,68.94 55.34,68.94 55.35,68.93 55.66,68.93 56.05,69.31 v2(56.31,69.31) ; 47.15,68.38 45.08,68.38 44.75,68.06 42.33,68.06 42.08,67.81 40.23,67.81 40.11,67.68 40.11,66.53 40.23,66.41 41.19,66.41 41.32,66.53 v2(41.32,66.83)
  IN3 w0.127: 47.15,68.38 48.28,68.38 48.41,68.25 48.41,67.53 48.53,67.4 52.68,67.4 54.22,68.94
  BOTTOM w0.102: v2(41.32,66.83) 40.92,67.23 UV6.H7
  BOTTOM w0.127: UV1.Y24 56.38,69.74 56.31,69.67 v2(56.31,69.31)
FB_A_D45: length 21
  TOP w0.102: UV6.F7 42.52,67.23 v2(42.92,67.63)
  IN3 w0.102: v2(42.92,67.63) 43.14,67.85 43.65,67.85 43.81,67.69 44.76,67.69 45.11,68.05 45.84,68.05 45.96,67.92 45.96,67.28 46.08,67.16 46.25,67.16 46.37,67.28 46.37,67.92 46.5,68.05 47.15,68.05 ; v2(57.1,69.34) 57.1,69.03 56.99,68.92 56.2,68.92 55.9,68.62
  IN3 w0.127: 47.15,68.05 47.95,68.05 48.08,67.92 48.08,67.68 47.95,67.56 47.77,67.56 47.64,67.43 47.64,67.2 47.77,67.07 52.82,67.07 54,68.25 54.35,68.25 54.48,68.13 54.48,67.94 54.6,67.81 55.02,67.81 55.3,68.09 55.7,68.09 55.9,68.29 55.9,68.62
  BOTTOM w0.102: UV14.E3 v2(42.92,67.63)
  BOTTOM w0.127: v2(57.1,69.34) 57.1,69.3 UV1.AA24
FB_A_D46: length 21.5
  TOP w0.102: UV6.H8 40.92,66.43 v2(41.32,66.03)
  IN3 w0.102: v2(41.32,66.03) 41.71,66.41 47.15,66.41
  IN3 w0.127: 47.15,66.41 56.06,66.41 58.37,68.72 58.37,69.77 v2(58.75,70.15)
  BOTTOM w0.102: UV14.G2 v2(41.32,66.03)
  BOTTOM w0.127: UV1.Y22 v2(58.75,70.15)
FB_A_D47: length 22.8
  TOP w0.102: UV6.F8 42.52,66.43 v2(42.92,66.83)
  IN3 w0.102: 47.15,67.72 46.92,67.72 46.79,67.59 46.79,67.3 46.54,67.05 46.54,66.79 46.41,66.67 45.83,66.67 45.7,66.79 45.7,67.68 45.57,67.81 45.33,67.81 45.21,67.68 45.21,67.24 45.08,67.12 44.82,67.12 44.7,67.24 44.7,67.3 44.57,67.43 43.48,67.43 43.3,67.25 42.76,67.25 42.36,67.65 42.2,67.65 42.1,67.54 42.1,67.39 42.48,67.01 42.48,66.95 42.61,66.83 v2(42.92,66.83)
  IN3 w0.127: 47.15,67.72 47.19,67.72 47.31,67.59 47.31,66.87 47.44,66.74 52.96,66.74 53.69,67.48 54.53,67.48 54.77,67.24 56.51,67.24 57.11,67.84 v2(57.11,68.55)
  BOTTOM w0.102: UV6.F8 v2(42.92,66.83)
  BOTTOM w0.127: v2(57.11,68.55) 57.46,68.9 UV1.AA23
FB_A_D48: length 13.1
  TOP w0.102: UV6.A7 46.52,67.23 v2(46.92,66.83)
  IN1 w0.102: v2(46.92,66.83) 46.92,67.35 46.82,67.45 46.48,67.45 46.35,67.58 46.35,67.91 46.48,68.04 48.64,68.04 50.32,66.37 51.1,66.37 51.2,66.26 51.2,65.99 51.3,65.89 51.51,65.89 51.61,65.99 51.61,66.26 51.71,66.37 51.91,66.37 52.01,66.26 52.01,65.99 52.11,65.89 52.32,65.89 52.42,65.99 52.42,66.26 52.52,66.37 52.77,66.37 v2(53.15,65.98)
  BOTTOM w0.102: UV6.A7 46.52,67.23 v2(46.92,66.83)
  BOTTOM w0.124: UV1.AD27 53.57,66.4 v2(53.15,65.98)
FB_A_D49: length 16.5
  TOP w0.102: UV6.D7 44.12,67.22 v2(44.52,66.82)
  IN1 w0.102: v2(55.49,67.68) 55.09,67.29 55.09,66.71 54.79,66.41 53.4,66.41 53.14,66.67 50.44,66.67 48.77,68.34 48.4,68.34 48.3,68.44 48.3,68.61 48.2,68.71 48,68.71 47.89,68.61 47.89,68.44 47.79,68.34 47.59,68.34 47.49,68.44 47.49,68.61 47.39,68.71 47.18,68.71 47.08,68.61 47.08,68.44 46.98,68.34 45.17,68.34 44.52,67.7 v2(44.52,66.82)
  BOTTOM w0.102: UV14.C3 v2(44.52,66.82)
  BOTTOM w0.127: v2(55.49,67.68) 55.9,68.1 UV1.AB25
FB_A_D50: length 14.4
  TOP w0.102: v2(45.32,66.82) 45.32,66.82 UV6.C8
  IN1 w0.102: v2(45.32,66.82) 46.38,66.82 46.78,66.43 47.24,66.43 47.34,66.53 47.34,67.63 47.44,67.73 47.72,67.73 47.82,67.63 47.82,67.29 47.92,67.19 48.12,67.19 48.22,67.29 48.22,67.63 48.33,67.73 48.52,67.73 50.67,65.58 53.43,65.58 v2(53.81,65.96)
  BOTTOM w0.102: v2(45.32,66.82) 44.92,66.43 UV6.C8
  BOTTOM w0.124: UV1.AD26 55.1,66.39 54.7,65.99 53.85,65.99 v2(53.81,65.96)
FB_A_D51: length 15.8
  TOP w0.102: UV6.B8 45.72,66.42 v2(46.12,66.02)
  IN1 w0.102: v2(46.12,66.02) 46.38,66.02 46.78,65.62 47.54,65.62 47.64,65.73 47.64,66.74 47.75,66.84 47.95,66.84 48.05,66.74 48.05,65.8 48.15,65.7 48.35,65.7 48.46,65.8 48.46,66.79 48.61,66.95 48.87,66.95 50.55,65.27 53.95,65.27 v2(55.51,66.84)
  BOTTOM w0.102: UV14.A2 v2(46.12,66.02)
  BOTTOM w0.127: v2(55.51,66.84) 55.9,67.23 UV1.AC25
FB_A_D52: length 15.6
  TOP w0.102: UV6.A3 v2(46.92,70.83)
  IN1 w0.102: v2(54.72,68.53) 54.57,68.37 54.09,68.37 53.99,68.27 53.99,68.24 53.89,68.14 53.69,68.14 53.58,68.24 53.58,68.27 53.48,68.37 53.28,68.37 53.18,68.27 53.18,68.24 53.08,68.14 52.87,68.14 52.77,68.24 52.77,68.27 52.67,68.37 52.47,68.37 52.36,68.27 52.36,68.24 52.26,68.14 52.06,68.14 51.96,68.24 51.96,68.27 51.86,68.37 51.65,68.37 51.55,68.27 51.55,68.24 51.45,68.14 51.25,68.14 51.15,68.24 51.15,68.27 51.04,68.37 50.82,68.37 49,70.19 48.65,70.19 48.55,70.29 48.55,70.83 48.45,70.93 48.25,70.93 48.14,70.83 48.14,70.29 48.04,70.19 47.84,70.19 47.74,70.29 47.74,70.85 47.64,70.95 47.43,70.95 47.33,70.85 47.33,70.29 47.23,70.19 46.59,70.19 46.49,70.29 46.49,70.73 46.59,70.83 v2(46.92,70.83)
  BOTTOM w0.102: UV6.A3 v2(46.92,70.83)
  BOTTOM w0.127: UV1.AA27 54.17,68.77 54.17,68.58 54.23,68.53 v2(54.72,68.53)
FB_A_D53: length 15.2
  TOP w0.102: v2(46.12,71.63) 46.52,71.23 UV6.A2
  IN1 w0.102: v2(46.12,71.63) 46.52,71.23 47.3,71.23 47.4,71.33 47.4,71.54 47.5,71.64 47.7,71.64 47.81,71.54 47.81,71.33 47.91,71.23 48.16,71.23 48.27,71.33 48.27,71.48 48.37,71.58 48.55,71.58 49.09,71.04 49.09,70.89 48.98,70.78 48.98,70.64 49.12,70.5 49.27,70.5 49.38,70.61 49.52,70.61 49.66,70.46 49.66,70.32 49.55,70.21 49.55,70.06 49.7,69.92 49.84,69.92 49.95,70.03 50.1,70.03 50.24,69.89 50.24,69.74 50.13,69.63 50.13,69.49 50.27,69.35 50.42,69.35 50.53,69.46 50.67,69.46 50.81,69.31 50.81,69.03 50.97,68.88 51.25,68.88 51.45,68.68 53.44,68.68 53.7,68.94 55.04,68.94 v2(55.49,68.49)
  BOTTOM w0.102: UV14.B8 v2(46.12,71.63)
  BOTTOM w0.127: UV1.AA26 55.1,68.87 v2(55.49,68.49)
FB_A_D54: length 16.6
  TOP w0.102: v2(44.52,70.83) 44.92,70.43 UV6.C3
  IN1 w0.102: v2(53.22,69.68) 53.02,69.48 52.01,69.48 51.82,69.67 51.68,69.67 51.57,69.56 51.43,69.56 51.28,69.71 51.28,69.85 51.39,69.95 51.39,70.1 51.25,70.24 51.1,70.24 51,70.14 50.85,70.14 50.71,70.28 50.71,70.42 50.81,70.53 50.81,70.67 50.67,70.82 50.53,70.82 50.42,70.71 50.28,70.71 50.13,70.86 50.13,71 50.24,71.1 50.24,71.25 48.59,72.9 45.25,72.9 44.9,72.55 44.9,71.21 v2(44.52,70.83)
  BOTTOM w0.102: UV14.D7 v2(44.52,70.83)
  BOTTOM w0.124: v2(53.22,69.68) 53.54,69.99 54.24,69.99 54.82,70.58 UV1.W26
FB_A_D55: length 17
  TOP w0.102: UV6.C2 v2(45.32,71.63)
  IN1 w0.102: v2(45.32,71.63) 45.24,71.7 45.24,71.91 45.36,72.03 47.3,72.03 47.4,72.13 47.4,72.48 47.51,72.58 47.71,72.58 47.81,72.48 47.81,72 47.91,71.9 48.13,71.9 48.23,72 48.23,72.43 48.33,72.53 48.52,72.53 49.07,71.99 49.07,71.84 48.96,71.74 48.96,71.6 49.11,71.45 49.25,71.45 49.36,71.56 49.5,71.56 49.64,71.41 49.64,71.27 49.54,71.16 49.54,71.02 51.58,68.98 53.18,68.98 54.05,69.84 55.37,69.84 55.51,69.71 v2(55.51,69.31)
  BOTTOM w0.102: UV6.C2 v2(45.32,71.63)
  BOTTOM w0.127: UV1.Y25 55.9,69.71 v2(55.51,69.31)
FB_A_D56: length 24.4
  TOP w0.102: UV7.A2 v2(46.12,85.3)
  IN1 w0.102: v2(54.05,74.57) 54.02,74.54 53.7,74.54 53.54,74.71 53.54,75.26 53.75,75.48 53.75,79.13 48.93,83.95 48.7,83.95 48.6,84.05 48.6,84.89 48.5,84.99 48.29,84.99 48.19,84.89 48.19,84.05 48.09,83.95 47.89,83.95 47.79,84.05 47.79,84.89 47.68,84.99 47.48,84.99 47.38,84.89 47.38,84.05 47.28,83.95 47.01,83.95 46.91,84.05 46.91,84.9 46.81,85.01 46.55,85.01 46.45,84.9 46.45,84.46 46.35,84.36 45.54,84.36 45.43,84.46 45.43,84.88 45.86,85.3 v2(46.12,85.3)
  BOTTOM w0.102: UV15.B8 45.72,85.7 v2(46.12,85.3)
  BOTTOM w0.127: v2(54.05,74.57) 54.39,74.57 UV1.R26
FB_A_D57: length 23.7
  TOP w0.102: UV7.A3 46.69,84.9 v2(47.09,85.3)
  IN1 w0.102: v2(47.09,85.3) 48.64,85.3 49.21,84.73 49.21,84.59 49.05,84.43 49.05,84.29 49.19,84.14 49.34,84.14 49.5,84.3 49.64,84.3 49.78,84.16 49.78,84.01 49.62,83.86 49.62,83.71 49.77,83.57 49.91,83.57 50.07,83.73 50.21,83.73 50.36,83.58 50.36,83.44 50.2,83.28 50.2,83.14 50.34,82.99 50.49,82.99 50.65,83.15 50.79,83.15 50.93,83.01 50.93,82.86 50.77,82.7 50.77,82.56 50.92,82.42 51.06,82.42 51.22,82.58 51.36,82.58 51.51,82.43 51.51,82.29 51.35,82.13 51.35,81.99 51.49,81.84 51.64,81.84 51.8,82 51.94,82 52.08,81.86 52.08,81.71 51.92,81.55 51.92,81.41 53.3,80.04 53.9,80.04 54.16,79.78 54.16,75.06 54.63,74.59 55.63,74.59 55.87,74.36 55.87,72.92 v2(55.5,72.55)
  BOTTOM w0.102: UV7.A3 46.69,84.9
  BOTTOM w0.124: 46.69,84.9 v2(47.09,85.3)
  BOTTOM w0.127: v2(55.5,72.55) 55.9,72.95 UV1.T25
FB_A_D58: length 22.8
  TOP w0.102: UV7.C2 44.92,85.71 v2(44.52,86.1)
  IN1 w0.102: v2(54.7,75.12) 54.93,75.35 54.93,79.44 53.92,80.45 53.92,80.6 54.02,80.7 54.02,80.84 53.87,80.98 53.73,80.98 53.59,80.84 53.33,80.58 53.19,80.58 53.04,80.73 53.04,80.87 53.51,81.34 53.51,81.48 53.37,81.63 53.23,81.63 52.75,81.16 52.61,81.16 52.47,81.3 52.47,81.44 52.94,81.92 52.94,82.06 52.79,82.2 52.65,82.2 52.48,82.03 52.34,82.03 48.66,85.72 44.91,85.72 v2(44.52,86.1)
  BOTTOM w0.102: v2(44.52,86.1) 44.92,85.71 UV7.C2
  BOTTOM w0.127: v2(54.7,75.12) 54.3,75.52 UV1.N27
FB_A_D59: length 23.2
  TOP w0.102: UV7.C3 v2(44.52,85.3)
  IN1 w0.102: v2(53.3,73.42) 53.56,73.69 53.56,73.89 53.25,74.2 53.25,76.56 53.15,76.66 52.92,76.66 52.82,76.76 52.82,76.96 52.92,77.06 53.15,77.06 53.25,77.17 53.25,77.37 53.15,77.47 52.92,77.47 52.82,77.57 52.82,77.78 52.92,77.88 53.15,77.88 53.25,77.98 53.25,78.18 53.15,78.28 52.92,78.28 52.82,78.38 52.82,78.59 52.92,78.69 53.15,78.69 53.25,78.79 53.25,79.2 48.8,83.65 46.65,83.65 46.21,84.09 45.13,84.09 45.03,84.19 45.03,84.46 44.93,84.56 44.73,84.56 44.63,84.46 44.63,84.26 44.52,84.15 44.25,84.15 44.15,84.26 44.15,84.94 v2(44.52,85.3)
  BOTTOM w0.102: UV15.D7 v2(44.52,85.3)
  BOTTOM w0.124: 53.59,73.71 v2(53.3,73.42)
  BOTTOM w0.127: UV1.R27 53.73,73.86 53.59,73.71
FB_A_D60: length 21.5
  TOP w0.102: UV7.B8 45.72,80.9 46.12,81.3 v2(46.12,81.3)
  IN1 w0.102: v2(46.12,81.3) 46.22,81.4 46.77,81.4 46.86,81.3 47.8,81.3 47.91,81.2 47.91,80.8 48.01,80.69 48.21,80.69 48.31,80.8 48.31,81.2 48.41,81.3 48.64,81.3 50.43,79.52 50.43,75.38 50.53,75.28 50.95,75.28 51.05,75.17 51.05,74.97 50.95,74.87 50.53,74.87 50.43,74.77 50.43,74.56 50.53,74.46 50.95,74.46 51.05,74.36 51.05,74.16 50.95,74.06 50.53,74.06 50.43,73.95 50.43,73.73 52.73,71.42 53.43,71.42 53.71,71.14 54.55,71.14 54.71,71.3 v2(54.71,71.75)
  BOTTOM w0.102: UV15.A2 46.52,80.9 v2(46.12,81.3)
  BOTTOM w0.124: UV1.V26 54.73,71.75 v2(54.71,71.75)
FB_A_D61: length 21.7
  TOP w0.102: v2(47.11,81.74) 47.07,81.7 UV7.A7
  IN1 w0.102: v2(47.11,81.74) 47.11,82.03 47.18,82.1 47.46,82.1 47.56,82 47.56,81.73 47.66,81.63 47.86,81.63 47.96,81.73 47.96,82 48.07,82.1 48.27,82.1 51.35,79.02 51.35,78.63 51.25,78.53 50.83,78.53 50.73,78.43 50.73,78.22 50.83,78.12 51.25,78.12 51.35,78.02 51.35,77.82 51.25,77.71 50.83,77.71 50.73,77.61 50.73,77.41 50.83,77.31 51.25,77.31 51.35,77.21 51.35,77 51.25,76.9 50.83,76.9 50.73,76.8 50.73,76.6 50.83,76.49 51.25,76.49 51.35,76.39 51.35,76.19 51.25,76.09 50.83,76.09 50.73,75.99 50.73,75.78 50.83,75.68 51.25,75.68 51.35,75.58 51.35,74.03 51.03,73.71 51.03,73.55 52.79,71.8 53.43,71.8 v2(53.56,71.93)
  BOTTOM w0.102: v2(47.11,81.74) 47.07,81.7 UV7.A7
  BOTTOM w0.124: UV1.V27 54.11,71.38 v2(53.56,71.93)
FB_A_D62: length 21.4
  TOP w0.102: UV7.C8 v2(45.32,80.5)
  IN1 w0.102: v2(45.32,80.5) 45.32,80.24 45.47,80.09 47.34,80.09 47.45,79.98 47.45,79.1 47.55,79 47.75,79 47.86,79.1 47.86,79.98 47.96,80.08 48.16,80.08 48.26,79.98 48.26,79.43 48.36,79.33 48.57,79.33 48.67,79.43 48.67,79.98 48.77,80.08 49,80.08 49.82,79.27 49.82,73.32 52.39,70.74 v2(52.55,70.74)
  BOTTOM w0.102: UV7.C8 v2(45.32,80.5)
  BOTTOM w0.124: v2(52.55,70.74) 53.06,70.23 53.95,70.23 UV1.W27
FB_A_D63: length 20.6
  TOP w0.102: UV7.D7 44.12,81.7 v2(44.52,81.3)
  IN1 w0.102: v2(53.3,70.75) 53.3,70.75 52.88,71.17 52.54,71.17 50.12,73.6 50.12,79.39 49.12,80.39 47.57,80.39 47.05,80.91 44.91,80.91 v2(44.52,81.3)
  BOTTOM w0.102: UV15.C3 v2(44.52,81.3)
  BOTTOM w0.124: v2(53.3,70.75) 53.57,71.02 55.46,71.02 UV1.W25
FB_A_DQM0: length 25
  TOP w0.102: v2(54.87,96.02) 54.68,95.83 54.25,95.83 54.13,95.95 54.13,96.18 53.92,96.38 UV9.E7
  IN3 w0.127: v2(54.87,96.02) 54.46,95.61 54.46,92.51 56.91,90.06 56.91,89.88 56.33,89.29 56.33,89.11 56.51,88.93 56.69,88.93 57.27,89.52 57.45,89.52 57.63,89.34 57.63,89.16 57.05,88.57 57.05,88.39 57.23,88.21 57.41,88.21 57.99,88.8 58.17,88.8 58.67,88.3 58.67,88.07 58.54,87.94 57.91,87.94 57.63,87.66 57.63,87.22 58.29,86.56 58.29,85.82 58.52,85.59 58.67,85.59 60.49,83.77 v2(60.49,83.39)
  BOTTOM w0.102: UV4.E7 55.96,96.38 55.86,96.28 55.86,95.95 55.76,95.85 55.56,95.85 55.38,96.02 v2(54.87,96.02)
  BOTTOM w0.127: UV1.D19 60.85,83.03 60.85,83.03 v2(60.49,83.39)
FB_A_DQM1: length 21.9
  TOP w0.102: v2(69.35,96.08) 69.05,96.38 UV5.E7
  IN1 w0.102: v2(65.44,82.59) 65,83.03 65,83.58 65.35,83.93 65.35,84.54 65,84.89 65,85.14 65.5,85.64 69.25,89.4 69.25,90.8 69.35,90.9 69.66,90.9 69.76,91 69.76,91.2 69.66,91.3 69.35,91.3 69.25,91.41 69.25,91.61 69.35,91.71 69.66,91.71 69.76,91.81 69.76,92.02 69.66,92.12 69.35,92.12 69.25,92.22 69.25,92.42 69.35,92.52 69.66,92.52 69.76,92.63 69.76,95.67 v2(69.35,96.08)
  BOTTOM w0.102: UV8.E7 69.65,96.38 v2(69.35,96.08)
  BOTTOM w0.127: v2(65.44,82.59) 65.42,82.61 65.39,82.61 UV1.D14
FB_A_DQM2: length 23.8
  TOP w0.102: v2(68.95,95.39) 70.76,95.39 UV5.D3
  IN3 w0.127: v2(62.93,83.45) 62.93,84.28 64.33,85.69 64.33,86.19 64.52,86.38 70.58,92.43 70.58,96.25 70.45,96.38 69.88,96.38 69.76,96.25 69.76,95.21 69.63,95.08 69.08,95.08 68.95,95.21 v2(68.95,95.39)
  BOTTOM w0.102: v2(62.93,83.45) 62.58,83.8 UV1.C17 ; UV8.D3 67.75,95.75 67.87,95.88 68.13,95.88 68.26,95.75 68.26,95.3 68.38,95.18 68.82,95.18 68.95,95.3 v2(68.95,95.39)
FB_A_DQM3: length 23.1
  TOP w0.102: UV9.D3 56.12,95.23 v2(54.87,95.23)
  IN1 w0.102: v2(58.01,84.22) 57.55,84.68 57.55,87.56 55.86,89.25 55.71,89.25 54.97,88.51 54.8,88.51 54.68,88.63 54.68,88.79 55.43,89.54 55.43,89.68 55.28,89.83 55.14,89.83 54.39,89.08 54.22,89.08 54.11,89.2 54.11,89.37 54.85,90.12 54.85,90.26 54.71,90.4 54.56,90.4 54.26,90.1 54.09,90.1 53.98,90.22 53.98,90.39 54.28,90.69 54.28,90.83 54.1,91.02 54.1,92.52 53.82,92.79 53.82,94.59 54.47,95.23 v2(54.87,95.23)
  BOTTOM w0.102: UV4.D3 53.84,95.58 54.18,95.23 v2(54.87,95.23)
  BOTTOM w0.127: UV1.C22 58.4,83.84 v2(58.01,84.22)
FB_A_DQM4: length 27.3
  TOP w0.102: UV7.E7 43.32,82.21 43.42,82.31 43.75,82.31 43.85,82.41 43.85,82.62 43.75,82.72 43.55,82.72 43.45,82.82 43.45,82.99 v2(43.63,83.18)
  IN3 w0.102: 52.56,73.33 52.86,73.33 53.18,73.02 55.05,73.02 55.17,73.14 55.68,73.14 55.94,73.4 55.94,73.71 56.3,74.08 v2(56.3,74.25) ; 47.05,81.25 46.26,82.03 46.1,82.03 45.98,81.91 45.77,81.91 45.63,82.06 45.63,82.2 45.88,82.45 45.88,82.63 45.68,82.83 45.5,82.83 45.14,82.48 42.99,82.48 42.87,82.6 42.87,82.8 42.99,82.92 43.5,82.92 43.63,83.05 v2(43.63,83.18)
  IN3 w0.127: 52.56,73.33 51.92,73.33 47.24,78.02 47.24,81.06 47.05,81.25
  BOTTOM w0.102: UV15.E7 43.32,84.25 43.52,84.05 43.75,84.05 43.87,83.93 43.87,83.42 v2(43.63,83.18)
  BOTTOM w0.127: v2(56.3,74.25) 56.7,74.65 UV1.P24
