# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_A_CLK1: length 86.4
  TOP w0.102: v2(40.6,68.85) 40.65,68.8 41.05,68.8 41.38,68.47 41.38,67.92 41.01,67.55 39.95,67.55 39.89,67.49 39.89,67.3 39.97,67.23 UV6.J7 ; UV7.J7 39.99,81.58 39.85,81.58 39.76,81.67 39.76,82.03 39.85,82.13 39.95,82.13 39.96,82.13 40.11,82.13 40.43,82.45 40.43,82.76 40.14,83.05 40.14,83.24 40.17,83.27 40.66,83.27 40.93,83 v2(40.93,83)
  IN1 w0.102: v2(43.79,75.62) 43.99,75.42 43.99,74.67 43.87,74.54 41.19,74.54 40.95,74.3 40.95,73.63 41.19,73.39 45.22,73.39 45.46,73.63 45.46,75.7 45.59,75.83 45.98,75.83 46.08,75.73 46.08,73.63 46.32,73.39 46.74,73.39 46.98,73.63 46.98,75.88 47.11,76.01 47.36,76.01 47.49,75.88 47.49,74.63 47.7,74.41 48.17,74.41 48.39,74.63 48.39,77.29 48.17,77.51 46.52,77.51 46.42,77.61 46.42,77.91 46.52,78.01 48.17,78.01 48.39,78.23 48.39,78.52 48.51,78.65 49.01,78.65 49.14,78.52 49.14,73.03 52.21,69.96 52.82,69.96 52.95,70.09 53.71,70.09 54.04,70.41 55.87,70.41 56.66,71.2 56.66,73.73 57.93,75.01 57.93,75.01 58.02,75.1 58.02,75.52 57.86,75.68 57.86,75.98 58.05,76.17 58.53,76.17 v2(58.77,75.93)
  IN3 w0.102: v2(40.93,83) 40.86,83.07 40.86,83.16 40.97,83.26 41.08,83.26 41.13,83.32 41.29,83.32 41.36,83.24 41.36,79.56 41.89,79.03 42.23,79.03 42.25,79.02 42.27,79.02 ; v2(40.6,68.85) 40.6,68.76 41.04,68.32 41.18,68.32 41.28,68.43 41.28,70.01 41.49,70.22 41.49,72.7 41.89,73.09 42.49,73.09
  IN3 w0.127: 42.49,73.09 42.54,73.15 43.22,73.15 44.08,74.01 44.08,75.29 43.79,75.58 v2(43.79,75.62) 44.01,75.84 44.01,77.94 43.6,78.35 43.24,78.35 42.57,79.02 42.27,79.02
  BOTTOM w0.102: v2(40.93,83) 40.93,83.11 41.17,83.35 41.3,83.35 41.52,83.57 41.52,84.05 41.12,84.45 40.92,84.45 40.57,84.8 40.57,85.02 40.49,85.09 40.31,85.09 UV15.J7 ; v2(40.6,68.85) 40.6,68.77 40.35,68.52 40.19,68.52 40.13,68.58 40.13,68.93 40.52,69.32 40.52,69.8 40.33,69.99 40.08,69.99 39.76,70.31 39.76,70.41 39.88,70.54 40.01,70.54 UV14.J7
  BOTTOM w0.112: UV1.N22 58.37,75.54 58.77,75.94 v2(58.77,75.93)
  BOTTOM w0.127: RV2717.1 43.79,75.22 v2(43.79,75.62)
FB_A_CLK#0: length 80.4
  TOP w0.102: v2(69.96,99.09) 69.86,99.19 69.86,99.51 69.6,99.77 69.03,99.77 68.75,99.5 68.59,99.5 68.35,99.74 68.21,99.74 67.75,100.19 UV5.K7 ; v2(54.52,98.77) 54.62,98.67 54.62,98.48 54.52,98.39 54.2,98.39 53.81,98.78 53.81,98.98 53.6,99.19 53.6,99.92 53.5,100.02 53.34,100.02 53.27,100.1 UV9.K7
  IN1 w0.102: v2(56.28,82.58) 56.56,82.86 57.4,82.86 57.65,83.11 58.17,83.11 58.99,83.94 60.2,83.94 60.82,84.55 60.82,86.09 61.51,86.78 61.51,90.32 61.3,90.54 60.5,90.54 60.37,90.66 60.37,90.92 60.5,91.05 62.38,91.05 62.5,90.92 62.5,89.25 62.74,89.01 63.24,89.01 63.48,89.25 63.48,90.37 63.59,90.47 65.23,90.47 65.47,90.71 65.47,91.13 65.23,91.37 63.59,91.37 63.48,91.47 63.48,91.7 63.24,91.94 59.33,91.94 59.2,92.07 59.2,92.33 59.33,92.45 63.24,92.45 63.48,92.69 63.48,93.11 63.24,93.35 60.87,93.35 60.77,93.45 60.77,93.76 60.87,93.86 61.61,93.86 61.85,94.1 61.85,95.07 61.61,95.31 59.3,95.31 59.18,95.44 59.18,95.94 59.3,96.07 62.24,96.07 v2(62.48,95.83)
  IN3 w0.102: 65.29,97.09 65.29,97.68 65.57,97.96 68.05,97.96 68.27,98.18 69.79,98.18 70.09,98.47 70.09,98.76 69.91,98.95 69.91,99.04 v2(69.96,99.09) ; 58.89,97.43 58.89,97.44 58.9,97.45 58.9,97.71 58.52,98.1 54.83,98.1 54.62,98.31 54.62,98.66 54.61,98.66 54.61,98.68 v2(54.52,98.77)
  IN3 w0.127: 58.89,97.43 58.89,96.59 59.49,95.99 62.31,95.99 v2(62.48,95.83) 62.59,95.94 64.59,95.94 65.29,96.64 65.29,97.09
  BOTTOM w0.102: UV4.K7 56.35,100.26 56.17,100.26 55.79,99.88 55.79,99.64 55.68,99.53 55.44,99.53 55.29,99.68 54.87,99.68 54.62,99.43 54.62,98.86 v2(54.52,98.77) ; UV8.K7 70.95,100.19 70.82,100.06 70.57,100.06 70.34,99.83 70.34,98.9 70.12,98.68 69.71,98.68 69.63,98.75 69.63,98.86 69.87,99.09 v2(69.96,99.09)
  BOTTOM w0.112: UV1.D25 55.9,83.01 56.28,82.63 v2(56.28,82.58)
  BOTTOM w0.127: RV2706.2 63.13,96.05 62.71,96.05 v2(62.48,95.83)
FB_A_CLK#1: length 86.1
  TOP w0.102: v2(40.93,83.65) 40.75,83.47 40.09,83.47 39.94,83.33 39.94,82.96 40.21,82.69 40.21,82.51 40.03,82.33 39.77,82.33 39.56,82.12 39.56,81.94 UV7.K7 ; UV6.K7 39.6,67.23 39.64,67.26 39.64,67.6 39.84,67.81 40.9,67.81 41.12,68.03 41.12,68.37 40.94,68.54 40.84,68.54 40.6,68.31 v2(40.6,68.22)
  IN1 w0.102: v2(58.75,76.75) 58.87,76.62 58.87,76.43 58.81,76.36 57.97,76.36 57.67,76.06 57.67,75.6 57.83,75.44 57.83,75.18 57.74,75.09 56.46,73.81 56.46,71.28 55.79,70.61 53.96,70.61 53.63,70.29 52.87,70.29 52.74,70.16 52.29,70.16 49.33,73.11 49.33,78.6 49.09,78.85 48.43,78.85 48.19,78.6 48.19,78.31 48.09,78.21 46.44,78.21 46.22,77.99 46.22,77.53 46.44,77.31 48.09,77.31 48.19,77.21 48.19,74.71 48.09,74.61 47.78,74.61 47.68,74.71 47.68,75.96 47.44,76.2 47.02,76.2 46.78,75.96 46.78,73.71 46.66,73.59 46.4,73.59 46.27,73.71 46.27,75.81 46.06,76.03 45.51,76.03 45.26,75.78 45.26,73.71 45.14,73.59 41.27,73.59 41.14,73.71 41.14,74.22 41.27,74.34 43.95,74.34 44.19,74.59 44.19,75.44 v2(44.37,75.62)
  IN3 w0.102: 42.61,72.88 42.61,72.88 42.58,72.85 41.99,72.85 41.74,72.6 41.74,70.12 41.52,69.91 41.52,68.33 41.28,68.08 40.74,68.08 v2(40.6,68.22) ; v2(40.93,83.65) 41.02,83.56 41.03,83.56 41.04,83.56 41.39,83.56 41.6,83.35 41.6,79.66 41.99,79.27 42.25,79.27 42.26,79.28 42.27,79.28
  IN3 w0.127: 42.61,72.88 43.33,72.88 44.34,73.9 44.34,75.59 v2(44.37,75.62) 44.28,75.72 44.28,78.05 43.71,78.62 43.35,78.62 42.68,79.28 42.27,79.28
  BOTTOM w0.102: v2(40.6,68.22) 40.57,68.25 40.15,68.25 39.92,68.48 39.92,69.01 40.32,69.4 40.32,69.71 40.24,69.78 40,69.78 39.36,70.43 UV14.K7 ; UV15.K7 39.49,84.73 39.49,84.63 39.62,84.51 39.96,84.51 40.02,84.57 40.5,84.57 40.83,84.24 41.04,84.24 41.31,83.97 41.31,83.65 41.21,83.55 41.03,83.55 v2(40.93,83.65)
  BOTTOM w0.112: v2(58.75,76.75) UV1.M22
  BOTTOM w0.127: v2(44.37,75.62) 44.19,75.44 44.19,75.01 RV2717.2
FB_A_CMD0: length 76.4
  TOP w0.102: UV9.K1 57.73,100.38 57.25,100.85 56.48,100.85 55.77,100.14 v2(55.5,100.14) ; v2(68.43,100.19) 68.56,100.19 69.13,100.76 72.17,100.76 UV5.K1
  TOP w0.124: v2(63.5,97.88) 63.3,97.68 RV2440.2
  IN1 w0.089: v2(63.5,97.88) 62.19,97.88 61.99,98.09 61.02,98.09 60.81,97.88 59.27,97.88 58.97,98.18 57.04,98.18 56.07,99.15 54.26,99.15 54.14,99.04 53.41,99.04 53.31,99.14 51.46,99.14 50.16,97.84 50.16,96.45 49.12,95.41 v2(49.12,94.76)
  IN3 w0.102: v2(68.43,100.19) 68.61,100.37 68.76,100.37 68.89,100.25 68.89,99.86 68.64,99.61 68.4,99.61 68,100.01 67.82,100.01 67.65,99.84 67.65,99.66 67.98,99.32 67.98,99.18 67.63,98.83 65.16,98.83 64.85,98.52 64.66,98.52 64.02,97.88 v2(63.5,97.88) 62.16,97.88 61.94,98.1 60.27,98.1 59.59,98.78 59.41,98.78 59.22,98.97 58.42,98.97 57.8,99.59 56.27,99.59 55.73,100.14 v2(55.5,100.14)
  BOTTOM w0.102: UV4.K1 52.07,100.78 53.36,100.78 53.6,100.54 55.1,100.54 v2(55.5,100.14) ; UV8.K1 66.15,100.11 66.28,99.97 66.47,99.97 66.62,100.12 66.62,100.51 66.97,100.85 67.77,100.85 v2(68.43,100.19)
  BOTTOM w0.124: UV1.C27 54.17,83.8 53.72,84.25 53.72,87.39 53.85,87.52 56.51,87.52 56.64,87.64 56.64,87.89 56.51,88.01 53.85,88.01 53.72,88.14 53.72,88.38 53.85,88.51 56.51,88.51 56.64,88.64 56.64,88.88 56.51,89.01 53.85,89.01 53.72,89.14 53.72,89.61 v1(52.96,90.36) 49.12,94.21 v2(49.12,94.76)
FB_A_CMD1: length 68.7
  TOP w0.102: v2(57.67,101.49) 57.75,101.41 57.75,101.01 57.65,100.92 57.48,100.92 57.27,101.12 UV9.L2
  IN1 w0.089: v2(65.49,100.54) 65.49,100.19 65.36,100.07 64.31,100.07 64.18,100.19 64.18,100.35 64.08,100.45 63.87,100.45 63.77,100.35 63.77,99.93 63.65,99.81 63.49,99.81 63.37,99.93 63.37,100.35 63.26,100.45 63.06,100.45 62.96,100.35 62.96,99.79 62.86,99.69 62.55,99.69 62.43,99.81 v2(62.43,100.6) 62.12,100.6 61.52,100 60.41,100 59.39,101.02 56.91,101.02 56.34,101.59 54.4,101.59 54.1,101.29 54.1,101.26 53.87,101.02 51.87,101.02 51.53,100.67 49.76,100.67 47.81,98.72 47.81,97.91 47.33,97.44 v2(46.82,97.44)
  IN3 w0.102: v2(57.67,101.49) 57.67,100.88 57.93,100.61 58.27,100.61 58.76,100.12 59.1,100.12 59.49,100.5 60.24,100.5 60.69,100.06 61.58,100.06 62.13,100.6 v2(62.43,100.6)
  BOTTOM w0.102: v2(65.49,100.54) 65.8,100.85 66.63,100.85 66.95,101.17 UV8.L2
  BOTTOM w0.124: UV1.C26 54.7,84.2 54.13,84.2 53.95,84.38 53.95,85.5 54.22,85.78 54.22,87.01 54.35,87.14 56.89,87.14 57.02,87.26 57.02,89.59 56.83,89.78 56.24,89.78 56.12,89.66 56.12,89.51 55.99,89.39 55.75,89.39 55.62,89.51 55.62,89.66 55.5,89.78 55.25,89.78 55.12,89.66 55.12,89.51 55,89.39 54.75,89.39 54.62,89.51 54.62,89.66 54.5,89.78 54.08,89.78 50.21,93.65 50.21,94.3 49.08,95.43 48.51,95.43 47.94,96 47.94,96.13 47.79,96.28 47.05,96.28 44.1,99.22 43.93,99.22 43.65,98.94 43.47,98.94 43.3,99.11 43.3,99.29 43.58,99.57 43.58,99.75 43.4,99.93 43.4,100.11 43.68,100.4 43.86,100.4 v1(44.32,99.94) v2(46.82,97.44)
FB_A_CMD2: length 70.6
  TOP w0.102: v2(71.38,101.59) 71.38,101.55 UV5.L2
  IN1 w0.089: v2(47.24,96.71) 47.24,96.91 48.19,97.86 48.19,98.45 50.1,100.37 51.6,100.37 51.96,100.72 59.26,100.72 60.36,99.62 61.75,99.62 v2(62.01,99.88)
  IN3 w0.102: v2(53.72,101.41) 53.89,101.59 56.07,101.59 56.46,101.19 56.46,101.05 56.33,100.92 56.33,100.75 56.45,100.63 56.62,100.63 56.75,100.76 56.89,100.76 57.25,100.41 58.17,100.41 58.67,99.9 59.21,99.9 59.48,100.17 60.1,100.17 60.72,99.56 61.68,99.56 v2(62.01,99.88) 64.57,99.88 64.63,99.94 65.43,99.94 66.67,101.19 68.38,101.19 68.76,101.56 69.33,101.56 69.85,102.09 71.38,102.09 71.49,101.97 71.49,101.71 v2(71.38,101.59)
  IN3 w0.127: v2(56.29,81.75) 55.68,81.75 55.1,82.33 55.1,83.49 54.14,84.45 54.14,86.92 44.2,96.86 44.2,97.04 44.63,97.48 45.55,98.4 45.73,98.4 45.97,98.16 45.97,97.98 45.07,97.08 45.07,96.9 45.28,96.69 45.46,96.69 46.13,97.36 46.31,97.36 46.49,97.18 46.49,97 45.92,96.42 45.92,96.24 46.26,95.9 46.44,95.9 v2(47.24,96.71)
  BOTTOM w0.102: UV4.L2 52.88,101.59 53.54,101.59 v2(53.72,101.41)
  BOTTOM w0.127: UV1.E24 56.67,82.15 56.29,81.76 v2(56.29,81.75)
FB_A_CMD3: length 73.1
  TOP w0.102: v2(68.92,101.18) 68.44,100.7 66.76,100.7 66.44,100.38 UV5.K9 ; v2(55.93,101.18) 55.93,101.03 55.44,100.54 53.66,100.54 53.5,100.7 52.25,100.7 51.93,100.38 UV9.K9
  TOP w0.124: RV2438.2 61.7,99.18 v2(62.43,99.18)
  IN1 w0.089: v2(62.43,99.18) 60.37,99.18 59.16,100.38 56.01,100.38 55.87,100.52 52.17,100.52 51.71,100.06 51.09,100.06 50.21,99.19 49.36,99.19 48.57,98.4 48.57,97.43 48.47,97.33 48.29,97.33 48.18,97.21 48.18,97.04 48.29,96.92 48.47,96.92 48.57,96.82 48.57,96.52 48.35,96.3 46.83,96.3 46.72,96.19 46.72,94.99 46.79,94.92 46.98,94.92 47.51,95.46 v2(47.51,95.85)
  IN3 w0.102: v2(55.93,101.18) 55.93,100.86 56.59,100.2 58.08,100.2 58.63,99.66 59.33,99.66 59.46,99.79 59.46,99.81 59.46,99.81 60,99.81 60.63,99.18 v2(62.43,99.18) 62.8,99.55 64.76,99.55 64.93,99.72 65.49,99.72 66.76,100.98 68.72,100.98 v2(68.92,101.18)
  IN3 w0.127: v2(57.1,81.72) 56.67,82.15 56.05,82.15 55.88,82.32 55.88,83.16 54.95,84.09 54.95,85.47 54.5,85.92 54.5,87.03 47.51,94.02 v2(47.51,95.85)
  BOTTOM w0.102: v2(55.93,101.18) 55.71,101.18 55.43,100.9 55.43,100.7 55.58,100.56 56.02,100.56 56.22,100.75 57.4,100.75 57.77,100.38 UV4.K9 ; v2(68.92,101.18) 69.4,100.7 71.93,100.7 72.25,100.38 UV8.K9
  BOTTOM w0.127: v2(57.1,81.72) 57.1,81.72 56.7,81.32 UV1.F24
FB_A_CMD4: length 126.9
  TOP w0.102: v2(35.26,84.4) 35.32,84.45 UV7.R3 ; UV5.R3 70.95,104.55 70.88,104.62 70.5,104.62 70.42,104.54 v2(70.42,104.34) ; v2(53.78,104.43) 53.72,104.38 UV9.R7 ; v2(35,69.85) 35,70.11 UV6.R3
  TOP w0.124: RPV15.1 RPV15.2 41.34,99.68 v2(41.82,99.2)
  IN1 w0.089: v2(62.64,105.97) 62.86,105.97 62.99,106.09 62.99,106.33 62.86,106.46 61.01,106.46 60.8,106.67 60.08,106.67 59.6,107.15 49.34,107.15 48.39,106.2 48.39,106.06 48.63,105.82 48.63,105.65 48.52,105.53 48.35,105.53 48.11,105.77 47.96,105.77 47.82,105.63 47.82,105.48 48.09,105.21 48.09,105.05 47.97,104.93 47.8,104.93 47.53,105.2 47.39,105.2 47.24,105.05 47.24,104.91 47.42,104.74 47.42,104.57 47.3,104.45 47.13,104.45 46.96,104.62 46.81,104.62 42.48,100.29 42.48,99.87 v2(41.82,99.2) 38.28,95.67 37.45,94.55 35.96,93.06 35.67,91.82 32.55,88.7 32.55,77.66 33.44,76.76 33.44,76.24 33.84,75.85 v2(33.84,75.18)
  IN3 w0.102: v2(35,69.85) 35.11,69.75 35.11,68.7 34.98,68.57 34.66,68.57 34.54,68.7 34.54,70.79 34.72,70.97 34.72,72.33 34.47,72.57 34.47,73.16 34.35,73.28 33.65,73.28 33.52,73.41 33.52,73.66 33.65,73.79 34.35,73.79 34.47,73.92 34.47,74.17 33.84,74.81 v2(33.84,75.18) 33.84,75.85 33.48,76.21 33.48,76.67 32.95,77.2 32.95,80.6 33.97,81.61 34.24,81.61 34.97,82.34 34.97,84.1 v2(35.26,84.4) ; v2(53.78,104.43) 54.03,104.69 56.02,104.69 58.05,106.71 59.54,106.71 59.54,106.71 60.81,106.71 61.12,106.4 61.99,106.4 62.29,106.1 62.51,106.1 v2(62.64,105.97) 63.2,105.97 63.94,105.22 64.23,105.22 64.36,105.35 64.36,105.78 64.48,105.91 64.74,105.91 64.86,105.78 64.86,105.35 64.99,105.22 65.28,105.22 65.53,104.98 66.97,104.98 67.15,104.81 69.95,104.81 v2(70.42,104.34)
  BOTTOM w0.102: UV6.R3 35,70.11 v2(35,69.85) ; UV5.R3 70.95,104.64 70.85,104.73 70.48,104.73 70.42,104.67 v2(70.42,104.34) ; v2(53.78,104.43) 53.54,104.38 UV9.R7 ; UV7.R3 35.32,84.45 v2(35.26,84.4)
  BOTTOM w0.124: UV1.D27 53.9,83 52.96,83.94 52.96,89.27 44.04,98.19 42.83,98.19 v1(42.44,98.58) v2(41.82,99.2)
FB_A_CMD5: length 118.3
  TOP w0.102: UV5.R8 67.38,104.81 67.38,105.47 v2(67.54,105.64) ; UV6.R8 35.23,66.43 v2(34.84,66.81) ; UV7.R8 35.22,80.9 v2(34.82,81.3) ; v2(56.87,104.88) 57.27,104.48 UV9.R2
  TOP w0.124: v2(42.74,99.55) 42.23,99.55 41.84,99.94 RPV15.3 RPV15.4
  IN1 w0.089: v2(67.54,105.64) 67.19,105.29 63.73,105.29 63.49,105.53 62.22,105.53 v2(61.78,105.97) 61.68,106.07 60.97,106.07 60.67,106.37 59.95,106.37 59.48,106.85 50.68,106.85 50.52,106.69 50.39,106.69 50.24,106.85 50.07,106.85 49.95,106.73 49.95,106.56 50.08,106.43 50.08,106.25 49.92,106.1 49.75,106.1 49.3,106.54 49.16,106.54 49.02,106.39 49.02,106.25 49.1,106.16 49.1,106.02 48.94,105.86 48.94,105.46 47.62,104.15 46.77,104.15 45.27,102.65 45.27,102.42 45.38,102.3 45.38,101.91 45.08,101.6 44.94,101.6 44.66,101.87 44.5,101.87 44.38,101.75 44.38,101.59 44.65,101.32 44.65,101.17 44.5,101.03 44.36,101.03 44.09,101.3 43.92,101.3 43.8,101.18 43.8,101.01 44.06,100.75 44.06,100.59 43.95,100.47 43.79,100.47 43.52,100.73 43.36,100.73 43.24,100.62 43.24,100.45 43.49,100.19 43.49,100.01 43.03,99.55 v2(42.74,99.55) 38.64,95.45 38.64,95.31 36.77,93.44 36.77,92.5 32.85,88.57 32.85,77.78 33.9,76.74 v2(33.9,76.39) 34.24,76.05 34.24,72.99 34.85,72.38 34.85,70.54 35.38,70.01 35.38,68.84 34.84,68.3 v2(34.84,66.81)
  IN3 w0.102: v2(61.78,105.97) 61.68,106.07 60.99,106.07 60.68,106.38 58.18,106.38 56.87,105.07 v2(56.87,104.88) ; v2(34.82,81.3) 34.89,81.38 34.89,81.58 34.75,81.72 34.63,81.72 34.35,81.43 34.35,81.27 34.47,81.14 34.47,80.99 34.38,80.89 34.22,80.89 34.03,81.08 33.9,81.08 33.28,80.46 33.28,79.58 33.41,79.45 33.75,79.45 33.88,79.33 33.88,79.07 33.75,78.94 33.41,78.94 33.28,78.82 33.28,78.56 33.41,78.44 33.77,78.44 33.9,78.31 33.9,78.06 33.77,77.93 33.41,77.93 33.28,77.8 33.28,77.34 33.54,77.08 33.71,77.08 33.81,76.98 33.81,76.48 v2(33.9,76.39)
  BOTTOM w0.102: UV7.R8 35.22,80.9 v2(34.82,81.3) ; v2(34.84,66.81) 35.23,66.43 UV6.R8 ; UV5.R8 67.38,104.81 67.38,105.47 v2(67.54,105.64) ; v2(56.87,104.88) 57.27,104.48 UV9.R2
  BOTTOM w0.124: UV1.D26 54.71,83.39 54.05,83.39 53.34,84.09 53.34,89.42 v1(44.65,98.11) 44.2,98.56 43.12,98.56 42.74,98.94 v2(42.74,99.55)
FB_A_CMD6: length 123
  TOP w0.102: v2(36.58,86.1) 36.92,85.76 UV7.N2 ; v2(52.07,103.12) 52.41,102.78 UV9.N8 ; v2(36.52,71.68) 36.52,71.54 36.84,71.23 UV6.N2 ; v2(72.15,103.18) 72.07,103.26 71.63,103.26 71.54,103.17 71.54,102.98 UV5.N2
  TOP w0.124: RPV13.4 RPV13.3 44.63,98.6 43.84,97.81 v2(43.84,97.34)
  IN1 w0.089: v2(36.24,76.39) 36.13,76.5 36.13,78.09 35.31,78.91 35.31,81.67 35.12,81.86 35.12,83.57 35.65,84.09 35.65,85.37 35.07,85.94 35.07,86.62 35.19,86.73 35.19,87.24 35.92,87.98 35.92,89.06 39.44,92.57 40.12,92.57 41.79,94.24 41.79,94.89 42.92,96.03 42.92,96.42 v2(43.84,97.34) 44,97.34 44.13,97.21 44.13,96.96 44.25,96.83 44.46,96.83 44.59,96.96 44.59,97.55 44.46,97.68 44.18,97.68 44.06,97.8 44.06,97.97 44.18,98.09 44.46,98.09 44.59,98.21 44.59,98.52 49.56,103.49 49.91,103.49 50.93,104.51 51.56,104.51 51.67,104.63 52.24,104.63 52.81,104.05 54.08,104.05 54.22,104.19 54.22,104.51 54.4,104.69 56,104.69 56.32,104.38 56.32,103.88 56.62,103.57 58.01,103.57 58.64,104.21 59.23,104.21 59.54,103.89 59.94,103.89 60.02,103.82 60.02,103.51 60.19,103.34 60.75,103.34 61.09,103.69 61.3,103.69 v2(61.52,103.46)
  IN3 w0.102: v2(72.15,103.18) 70.55,103.75 67.43,103.75 67.32,103.64 65.16,103.64 65.08,103.56 64.58,103.56 64.57,103.55 62.12,103.55 62.03,103.46 v2(61.52,103.46) 61.39,103.46 61.19,103.26 59.06,103.26 58.91,103.11 56.53,103.11 56.13,103.5 54.82,103.5 54.67,103.65 53.19,103.65 53.04,103.5 52.45,103.5 v2(52.07,103.12) ; v2(36.52,71.68) 36.23,71.68 35.43,70.89 35.43,70.73 35.54,70.62 35.7,70.62 36.37,71.29 36.69,71.29 36.88,71.09 37.03,71.09 37.13,71.2 37.13,71.34 36.95,71.52 36.95,73.21 36.82,73.34 36.44,73.34 36.32,73.46 36.32,73.91 36.61,74.2 36.61,74.51 36.24,74.88 36.24,75.33 36.33,75.43 36.33,76.3 v2(36.24,76.39) 36.24,76.65 36.15,76.74 36.15,77.98 36.33,78.17 36.33,78.68 36.71,79.06 36.71,79.74 36.59,79.86 36.59,81.65 36.19,82.04 36.19,83.91 36,84.11 36,84.93 36.19,85.13 36.19,85.72 v2(36.58,86.1)
  BOTTOM w0.102: UV9.N8 52.41,102.78 v2(52.07,103.12) ; UV6.N2 36.92,71.28 v2(36.52,71.68) ; v2(72.15,103.18) 71.64,103.18 71.56,103.09 71.56,102.97 UV5.N2 ; UV7.N2 36.92,85.76 v2(36.58,86.1)
  BOTTOM w0.124: v2(43.84,97.34) 44.35,97.34 v1(45.23,96.47) 52.58,89.11 52.58,83.38 54.08,81.88 54.74,81.88 54.86,81.76 55.72,81.76 55.9,81.58 UV1.F25
FB_A_CMD7: length 117.8
  TOP w0.102: UV9.N7 53.46,102.78 v2(53.71,103.03) ; v2(36.55,70.07) 36.91,70.43 UV6.N3 ; v2(70.53,102.47) 70.48,102.42 70.48,102.32 70.55,102.25 70.78,102.25 70.83,102.3 71.16,102.3 71.22,102.37 71.22,102.65 71.09,102.78 UV5.N3 ; UV7.N3 36.92,84.86 v2(36.59,84.53)
  TOP w0.124: v2(44.47,95.52) 44.79,95.52 45.27,96 RPV16.2 RPV16.1
  IN1 w0.089: v2(63.19,102.74) 62.74,102.74 62.67,102.67 59.99,102.67 59.55,103.12 56.32,103.12 56,103.43 54.13,103.43 54.03,103.53 51.66,103.53 51.47,103.34 50.87,103.34 50.35,102.82 49.75,102.82 45.2,98.27 45.2,96.7 44.97,96.47 44.97,96.33 45.2,96.09 45.2,95.92 45.08,95.81 44.91,95.81 44.53,96.18 44.35,96.18 44.17,96 44.17,95.82 v2(44.47,95.52) 43.92,94.97 43.92,94.36 43.47,93.9 42.6,93.9 36.8,88.1 36.8,87.65 36.35,87.21 36.35,86.71 36.16,86.52 36.16,84.14 36.26,84.04 36.26,82.17 36.46,81.98 36.46,79.64 36.58,79.51 36.58,78.63 37.37,77.84 37.37,77.02 36.97,76.61 36.97,75.42 37.4,74.99 v2(37.4,74.7) 37.01,74.7 36.89,74.57 36.89,73.71 37.01,73.59 37.66,73.59 37.78,73.47 37.78,73.3 37.66,73.18 37.01,73.18 36.91,73.08 36.91,72.88 37.01,72.78 37.29,72.78 37.39,72.67 37.39,72.47 37.29,72.37 37.01,72.37 36.91,72.27 36.91,72.06 37.01,71.96 37.72,71.96 37.84,71.84 37.84,71.67 37.72,71.56 37.01,71.56 36.91,71.45 36.91,71.25 37.01,71.15 37.4,71.15 37.52,71.03 37.52,70.86 37.4,70.74 37.01,70.74 36.91,70.64 36.91,70.43 v2(36.55,70.07)
  IN3 w0.102: v2(37.4,74.7) 37.4,74.9 36.99,75.31 36.99,76.94 37.32,77.27 37.32,77.62 36.99,77.95 36.99,78.58 37.12,78.7 37.12,79.91 37,80.03 37,81.82 36.6,82.21 36.6,84.51 v2(36.59,84.53) ; v2(53.71,103.03) 53.78,103.1 55.96,103.1 56.36,102.7 59.27,102.7 59.37,102.59 61.46,102.59 61.57,102.71 62.09,102.71 62.13,102.67 62.6,102.67 62.67,102.74 v2(63.19,102.74) 64.52,102.74 64.71,102.55 68.44,102.55 68.82,102.93 71.24,102.93 71.37,102.8 71.37,102.6 71.24,102.47 v2(70.53,102.47)
  BOTTOM w0.102: v2(36.55,70.07) 36.91,70.43 UV6.N3 ; UV5.N3 70.95,102.41 70.81,102.27 70.73,102.27 v2(70.53,102.47) ; v2(53.71,103.03) 53.46,102.78 UV9.N7 ; v2(36.59,84.53) 36.92,84.86 UV7.N3
  BOTTOM w0.124: UV1.F26 54.84,81.3 54.49,81.66 53.77,81.66 52.21,83.22 52.21,88.95 v1(46.29,94.87) 45.63,95.52 v2(44.47,95.52)
FB_A_CMD8: length 142.5
  TOP w0.102: UV6.T8 34.04,66.9 34.04,67.89 34.11,67.95 v2(34.11,69.16) ; UV5.T8 66.95,105.6 ; 34.11,83.05 34.17,83.11 34.22,83.11 34.35,82.99 34.35,82.1 34.19,81.94 34.19,81.23 UV7.T8 ; UV9.T8 52.47,105.59
  TOP w0.124: v2(38.16,97.92) 37.72,97.92 37.2,97.4 RPV10.3 RPV10.4 ; v2(55.34,105.54) 54.6,105.97 52.74,105.97 52.47,105.7 52.47,105.59 ; 34.11,83.05 v2(33.87,82.81) ; v2(69.27,105.46) 68.68,106.06 67.41,106.06 66.95,105.6
  IN1 w0.089: v2(62.26,107.7) 61.42,107.7 60.02,108.07 48.96,108.07 39.37,98.48 v2(38.16,97.92) 37.91,97.92 35.37,95.38 35.37,95.24 35.85,94.76 35.85,94.59 35.73,94.47 35.57,94.47 35.08,94.95 34.94,94.95 34.73,94.74 34.73,94.54 35.3,93.97 35.3,93.76 31.63,90.09 31.63,77.04 32.19,76.48 32.19,75.5 v2(32.31,75.38)
  IN3 w0.102: v2(34.11,69.16) 33.56,69.7 32.54,69.7 32.31,69.93 32.31,71.01 32.18,71.14 31.93,71.14 31.81,71.26 31.81,71.52 31.93,71.64 32.18,71.64 32.31,71.77 v2(32.31,75.38) 32.25,75.44 32.25,76.44 31.96,76.73 31.96,81.05 33.72,82.81 v2(33.87,82.81) ; v2(69.27,105.46) 67.8,106.94 64.56,106.94 64.3,107.2 63.12,107.2 v2(62.26,107.7) 57.5,107.7 v2(55.34,105.54)
  IN3 w0.127: v2(57.1,80.91) 55.79,80.91 54.64,82.06 54.64,83.1 53.41,84.32 53.41,85.72 48.61,90.52 47.57,92.52 44.98,95.1 44.06,95.1 41.59,95.9 v2(38.16,97.92)
  BOTTOM w0.102: UV15.T8 34.11,85.7 ; v2(69.27,105.46) 70.1,105.46 70.29,105.66 71.27,105.66 UV8.T8 ; v2(55.34,105.54) 55.37,105.5 56.95,105.5 UV4.T8 ; v2(57.1,80.91) 57.49,81.3 UV1.F23 ; UV14.T8 33.92,71.23
  BOTTOM w0.124: 33.92,71.23 33.89,71.23 33.6,70.93 33.6,69.66 v2(34.11,69.16) ; v2(33.87,82.81) 33.75,82.92 33.75,85.48 33.98,85.7 34.11,85.7
FB_A_CMD9: length 111.8
  TOP w0.102: v2(68.1,103.15) 67.75,102.79 UV5.N7 ; UV6.N7 37.29,67.23 37.43,67.37 37.43,67.45 v2(37.23,67.65) ; v2(36.98,82.37) 37.27,82.08 37.27,81.83 37.14,81.7 UV7.N7 ; v2(55.8,102.72) 55.8,102.43 55.88,102.35 56.5,102.35 56.63,102.47 56.63,102.66 56.51,102.78 UV9.N3
  TOP w0.124: v2(44.49,94.68) 45.77,95.97 RPV16.3 RPV16.4
  IN1 w0.089: v2(68.1,103.15) 67.24,102.28 64.82,102.28 64.44,101.91 62.95,101.91 62.89,101.85 62.27,101.85 v2(61.86,102.26) 59.97,102.26 59.42,102.81 56.31,102.81 55.94,103.18 54.41,103.18 53.87,102.64 51.93,102.64 51.81,102.52 49.88,102.52 45.5,98.14 45.5,95.17 45.38,95.04 44.62,95.04 44.49,94.91 v2(44.49,94.68) 44.27,94.46 44.27,94.27 43.6,93.6 42.74,93.6 37.18,88.03 37.18,86.36 37.06,86.24 37.06,84.46 36.52,83.92 36.52,82.24 36.89,81.87 36.89,78.75 37.67,77.97 37.67,76.89 37.41,76.63 v2(37.41,75.55)
  IN3 w0.102: v2(36.98,82.37) 37.2,82.15 37.2,80.11 37.32,79.99 37.32,78.93 37.54,78.71 37.54,78.44 37.32,78.22 37.32,78.09 37.5,77.91 37.78,77.91 37.87,77.81 37.87,77.08 37.74,76.94 37.47,76.94 37.32,76.8 37.32,76.33 37.71,75.94 37.71,75.85 v2(37.41,75.55) 37.86,75.09 37.86,74.95 37.95,74.86 37.95,73.22 38.18,73 38.18,71.11 37.15,70.08 37.15,69.73 36.71,69.29 36.71,68.17 v2(37.23,67.65) ; v2(55.8,102.72) 56.02,102.5 59.1,102.5 59.33,102.26 v2(61.86,102.26)
  IN3 w0.127: v2(44.49,94.68) 44.49,93.71 52.75,85.45 52.75,83.98 53.49,83.25 53.49,82.39 55.06,80.81 55.06,79.94 55.35,79.65 57.79,79.65 57.92,79.78 v2(57.92,80.09)
  BOTTOM w0.102: UV9.N3 56.47,102.46 56.34,102.33 56.18,102.33 v2(55.8,102.72) ; v2(57.92,80.09) 58.33,80.5 UV1.G22 ; UV6.N7 36.92,67.08 37.05,66.95 37.33,66.95 37.39,67.02 37.39,67.35 37.44,67.4 37.44,67.62 37.38,67.69 37.28,67.69 v2(37.23,67.65) ; v2(36.98,82.37) 37.27,82.37 37.35,82.29 37.35,81.67 37.23,81.55 37.03,81.55 36.92,81.66 UV7.N7 ; v2(68.1,103.15) 67.75,102.79 UV5.N7
FB_A_CMD10: length 114.6
  TOP w0.102: UV5.P7 67.68,103.58 v2(67.27,103.17) ; UV9.P3 55.96,104.09 v2(55.87,104.09) ; UV7.P7 35.61,82.21 v2(35.61,82.3) ; UV6.P7 36.33,67.44 v2(36.33,67.88)
  TOP w0.124: RPV13.1 RPV13.2 44.13,98.7 v2(42.98,97.56)
  IN1 w0.089: v2(67.27,103.17) 67.27,102.8 67.14,102.67 63.83,102.67 63.28,103.22 62.87,103.22 v2(61.74,104.35) 61.59,104.5 59.87,104.5 59.6,104.77 59.6,105 59.2,105.4 59.05,105.4 58.92,105.27 58.79,105.27 58.67,105.4 58.67,105.5 58.54,105.63 58.34,105.63 58.21,105.5 58.21,105.28 58.09,105.16 57.92,105.16 57.8,105.28 57.8,105.53 57.7,105.63 57.5,105.63 57.4,105.53 57.4,105.29 57.28,105.17 57.11,105.17 56.99,105.29 56.99,105.53 56.89,105.63 56.69,105.63 56.58,105.53 56.58,105.22 56.47,105.1 56.3,105.1 56.18,105.22 56.18,105.55 56.1,105.63 55.87,105.63 55.75,105.5 55.75,105.26 55.62,105.13 50.69,105.13 49.66,104.1 49.3,104.1 42.98,97.78 v2(42.98,97.56) 42.25,96.83 42.25,96.22 41.91,95.88 41.08,95.88 40.82,95.62 40.82,94.82 34.56,88.56 34.56,87.44 34.54,87.41 34.54,87.08 34.54,87.08 34.54,86.76 34.54,86.76 34.54,83.82 34.54,83.81 34.54,83.5 34.54,81.97 34.07,81.5 34.07,79.01 35.3,77.78 35.3,77.5 35.4,77.4 v2(35.4,76.42) 36.13,75.37 36.13,70.16 v2(36.33,67.88)
  IN3 w0.102: v2(55.87,104.09) 56.19,104.09 56.38,103.9 56.38,103.83 56.64,103.56 56.9,103.56 57.03,103.69 57.28,103.69 57.46,103.51 57.95,103.51 58.63,104.19 59.49,104.19 59.82,104.53 61.57,104.53 v2(61.74,104.35) ; v2(35.4,76.42) 35.49,76.51 35.49,77.3 35.31,77.48 35.31,78.08 35.63,78.4 35.63,78.53 35.74,78.65 35.74,79.15 35.71,79.18 35.71,79.36 35.74,79.39 35.74,79.62 35.87,79.74 36.06,79.74 36.18,79.87 36.18,80.72 36.01,80.89 36.01,81.15 36.18,81.32 36.18,81.48 35.82,81.84 35.62,81.84 35.49,81.71 35.33,81.71 35.22,81.83 35.22,81.99 35.53,82.3 v2(35.61,82.3)
  IN3 w0.127: v2(42.98,97.56) 42.98,96.83 43.87,95.94 44.65,95.94 53.77,86.81 53.77,84.43 54.87,83.33 54.87,82.2 55.75,81.31 57.53,81.31 v2(57.94,80.9)
  BOTTOM w0.102: UV5.P7 67.68,103.58 v2(67.27,103.17) ; v2(36.33,67.88) 36.33,67.44 UV6.P7 ; UV9.P3 55.96,104.09 v2(55.87,104.09) ; UV1.G23 57.54,80.5 v2(57.94,80.9) ; v2(35.61,82.3) 35.61,82.21 UV7.P7
FB_A_CMD11: length 119.4
  TOP w0.102: UV6.J3 40.12,68.71 v2(39.54,68.13) ; UV9.J3 56.25,99.36 54.04,99.36 v2(53.98,99.42) ; UV7.J3 40.12,84.71 40.25,84.58 40.58,84.58 40.67,84.49 41.07,84.49 41.18,84.37 41.18,84.21 41.07,84.1 40.37,84.1 v2(40.28,84.19) ; v2(70.04,100.16) 70.04,100.15 70.51,100.15 70.61,100.06 70.61,99.93 70.51,99.83 70.45,99.83 70.32,99.7 70.32,99.21 70.45,99.08 70.82,99.08 70.95,99.21 UV5.J3
  TOP w0.124: RPV9.4 RPV9.3 46.85,92.64 v2(47.07,92.43)
  IN1 w0.089: v2(43.43,76.35) 42.79,76.98 42.79,79.01 42.52,79.29 42.52,81.51 41.6,82.43 41.6,84.51 41.73,84.64 41.73,87.09 42.45,87.81 44.19,87.81 46.5,90.12 46.5,91.86 v2(47.07,92.43) 47.36,92.72 47.36,92.86 47.2,93.01 47.2,93.18 47.32,93.3 47.49,93.3 47.8,92.99 47.97,92.99 48.09,93.11 48.09,93.28 47.78,93.59 47.78,93.76 47.9,93.87 48.07,93.87 48.54,93.4 48.76,93.4 50.89,95.53 50.89,96.94 51.13,97.18 51.65,97.18 52.44,97.97 53.14,97.97 53.27,98.1 55.75,98.1 56.67,97.18 58.89,97.18 58.97,97.1 61.21,97.1 v2(61.53,96.78)
  IN3 w0.102: v2(39.54,68.13) 40.22,68.81 40.22,69.01 40.52,69.31 40.52,69.62 41.28,70.38 41.28,72.79 41.9,73.41 42.23,73.41 43.17,74.35 43.17,76.1 v2(43.43,76.35) 42.79,76.98 42.79,77.72 41.15,79.36 41.15,81.53 40.47,82.21 40.47,83.65 40.34,83.78 39.93,83.78 39.81,83.9 39.81,84.19 39.94,84.32 40.15,84.32 v2(40.28,84.19) ; v2(70.04,100.16) 69.36,99.47 69.16,99.47 68.87,99.18 68.56,99.18 67.8,98.42 65.38,98.42 64.76,97.8 64.76,97.45 64.2,96.89 61.64,96.89 v2(61.53,96.78) 61.16,97.15 60.21,97.15 58.81,98.54 56.64,98.54 55.96,99.23 54.52,99.23 54.39,99.35 54.39,99.83 54.29,99.94 53.97,99.94 53.84,99.81 53.84,99.56 v2(53.98,99.42)
  IN3 w0.127: v2(47.07,92.43) 47.07,91.6 53.08,85.59 53.08,84.12 54.41,82.79 54.41,81.96 55.72,80.65 55.72,80.64 56.27,80.09 v2(56.31,80.09)
  BOTTOM w0.102: UV15.J3 40.34,81.92 40.34,84.13 v2(40.28,84.19) ; v2(39.54,68.13) 39.54,68.13 39.54,67.66 39.64,67.57 39.77,67.57 39.87,67.66 39.87,67.73 39.99,67.85 40.49,67.85 40.61,67.73 40.61,67.35 40.49,67.23 UV14.J3 ; UV8.J3 69.47,99.58 v2(70.04,100.16) ; UV4.J3 53.47,99.58 53.59,99.45 53.59,99.12 53.69,99.03 53.69,98.63 53.8,98.52 53.96,98.52 54.07,98.63 54.07,99.33 v2(53.98,99.42)
  BOTTOM w0.127: UV1.G24 56.7,80.47 56.32,80.09 v2(56.31,80.09)
FB_A_CMD12: length 130.2
  TOP w0.102: v2(34.1,69.89) 34.52,70.31 UV6.T3 ; UV5.T3 70.53,105.18 v2(70.45,105.26) ; UV7.T3 34.52,84.94 v2(34.15,85.31) ; v2(52.85,105.51) 52.85,105.47 53.15,105.18 UV9.T7
  TOP w0.124: RPV17.1 RPV17.2 38.22,99.85 v2(38.53,99.54)
  IN1 w0.089: v2(34.1,69.89) 32.89,71.1 32.89,71.5 33.65,72.26 33.65,72.44 33.49,72.61 33.31,72.61 32.6,71.9 32.42,71.9 32.24,72.08 32.24,72.26 32.87,72.89 32.87,73.03 32.66,73.25 32.51,73.25 32.08,72.82 31.94,72.82 31.72,73.03 31.72,73.18 32.15,73.61 32.15,73.75 31.93,73.97 31.93,75.04 v2(31.47,75.5) 31.02,75.96 31.02,90.34 33.33,92.65 33.33,94.34 v2(38.53,99.54) 38.87,99.88 39.62,99.88 48.42,108.68 62.09,108.68 v2(62.22,108.54)
  IN3 w0.102: v2(31.47,75.5) 31.3,75.68 31.3,82.22 34.15,85.07 v2(34.15,85.31) ; v2(70.45,105.26) 70.45,105.94 68.79,107.6 64.85,107.6 63.91,108.54 v2(62.22,108.54) 56.08,108.54 53.06,105.51 v2(52.85,105.51)
  BOTTOM w0.102: v2(34.1,69.89) 34.52,70.31 UV6.T3 ; v2(52.85,105.51) 53.19,105.18 UV9.T7 ; UV5.T3 70.53,105.18 v2(70.45,105.26) ; v2(34.15,85.31) 34.52,84.94 UV7.T3
  BOTTOM w0.124: v2(38.53,99.54) 38.55,99.56 39.81,99.56 v1(40.06,99.31) 44.27,95.1 45.52,95.1 51.83,88.8 51.83,83.06 53.65,81.24 54.24,81.24 UV1.F27
FB_A_CMD13: length 116.3
  TOP w0.102: v2(57.58,103.97) 57.59,103.96 57.59,103.1 UV9.N2 ; v2(66.49,103.18) 66.89,102.78 UV5.N8 ; v2(36.52,66.02) 36.92,66.42 UV6.N8 ; v2(35.72,80.59) 35.74,80.58 36.59,80.58 UV7.N8
  TOP w0.124: RPV8.4 RPV8.3 41.38,97.4 v2(41.85,96.93)
  IN1 w0.089: v2(66.49,103.18) 66.49,103.5 66.36,103.62 64.76,103.62 64.64,103.5 64.64,103.24 64.51,103.12 64.32,103.12 64.19,103.24 64.19,103.92 64.06,104.05 63.85,104.05 63.73,103.93 63.73,103.65 63.6,103.52 63.41,103.52 63.29,103.65 63.29,104.24 63.16,104.37 v2(62.93,104.37) 62.49,104.81 60.22,104.81 59.1,105.93 51.06,105.93 49.53,104.41 49.18,104.41 42.01,97.24 42.01,97.09 v2(41.85,96.93) 41.7,96.93 40.51,95.74 40.51,94.93 34.26,88.69 34.26,87.56 33.77,87.07 33.77,83.47 34.28,82.96 34.28,82.15 33.77,81.63 33.77,78.88 34.99,77.66 34.99,76.07 v2(35.49,75.58) 35.65,75.41 35.65,74.29 35.48,73.59 35.23,72.51 35.23,71.48 35.69,69.82 35.98,67.58 v2(36.52,66.02)
  IN3 w0.102: v2(35.49,75.58) 35.49,75.52 35.34,75.38 35.04,75.38 34.98,75.43 34.98,75.75 35.17,75.94 35.17,76.05 34.98,76.25 34.98,76.59 35.16,76.77 35.16,77.16 34.98,77.34 34.98,77.57 34.89,77.66 34.89,77.88 34.98,77.97 34.98,78.39 34.89,78.48 34.89,78.77 34.97,78.85 35.05,78.85 35.23,78.67 35.41,78.67 35.54,78.79 35.54,78.92 35.41,79.05 35.28,79.05 35.19,79.14 35.19,79.3 35.31,79.43 35.49,79.43 35.54,79.48 35.54,79.63 35.23,79.94 35.23,80.09 35.34,80.19 35.49,80.19 35.68,80 35.85,80 35.98,80.13 35.98,80.47 35.85,80.59 v2(35.72,80.59) ; v2(57.58,103.97) 57.58,103.8 57.66,103.72 57.86,103.72 58.62,104.48 59.2,104.48 59.58,104.86 62.45,104.86 v2(62.93,104.37)
  BOTTOM w0.102: v2(36.52,66.02) 36.84,66.35 36.84,66.35 UV6.N8 ; v2(66.49,103.18) 66.63,103.18 66.95,102.86 UV5.N8 ; UV7.N8 36.59,80.58 35.74,80.58 v2(35.72,80.59) ; UV9.N2 57.59,103.1 57.59,103.96 v2(57.58,103.97)
  BOTTOM w0.124: UV1.G25 55.54,80.86 53.5,80.86 51.45,82.91 51.45,87.72 47.82,91.35 47.82,92.27 46.37,93.71 44.76,93.71 43.94,94.54 43.94,94.79 v1(42.53,96.19) 41.85,96.88 v2(41.85,96.93)
FB_A_CMD14: length 133.1
  TOP w0.102: v2(34.44,67.72) 34.52,67.64 UV6.T7 ; v2(68.41,105.6) 67.99,105.18 UV5.T7 ; UV7.T7 34.55,81.73 34.55,84.08 v2(34.15,84.48) ; UV9.T3 56.24,104.95 54.2,104.95 53.68,105.48 v2(53.68,105.51)
  TOP w0.124: v2(39.88,98.41) 39.88,99.17 39.31,99.73 38.93,99.73 38.72,99.94 RPV17.3 RPV17.4
  IN1 w0.089: v2(34.44,67.72) 34.03,68.13 34.03,68.44 34.49,68.9 34.49,72.04 32.44,74.08 32.44,74.92 32.76,75.24 32.76,76.32 v2(32.7,76.38) 32.7,76.65 31.94,77.4 31.94,89.96 36.19,94.22 36.19,95.77 37.88,97.46 38.28,97.46 38.49,97.54 39.56,98.09 v2(39.88,98.41) 39.88,98.55 40.21,98.88 40.49,98.88 40.63,99.03 40.63,99.31 40.78,99.45 41.06,99.45 41.21,99.6 41.21,99.88 41.36,100.03 41.64,100.03 41.78,100.18 41.78,100.46 49.09,107.76 59.99,107.76 v2(61.33,107.28)
  IN3 w0.102: v2(34.15,84.48) 34.15,84.41 34.54,84.03 34.54,82.9 33.94,82.29 33.67,82.29 32.29,80.91 32.29,76.93 32.7,76.52 v2(32.7,76.38) ; v2(68.41,105.6) 68.41,105.86 67.66,106.61 67.3,106.61 67.17,106.48 67.17,106.16 67.05,106.04 66.79,106.04 66.66,106.16 66.66,106.48 66.54,106.61 64.32,106.61 64.06,106.87 62.74,106.87 62.32,107.28 v2(61.33,107.28) 61.23,107.28 61.14,107.37 57.77,107.37 55.53,105.13 53.9,105.13 53.68,105.36 v2(53.68,105.51)
  BOTTOM w0.102: UV7.T7 34.75,81.93 34.75,83.92 34.19,84.48 v2(34.15,84.48) ; v2(34.44,67.72) 34.52,67.64 UV6.T7 ; v2(53.68,105.51) 54.04,105.15 56.44,105.15 UV9.T3 ; UV5.T7 67.99,105.18 v2(68.41,105.6)
  BOTTOM w0.124: v2(39.88,98.41) 39.88,97.52 v1(40.25,97.15) 42.22,95.18 42.22,94.89 43.28,93.83 44.12,93.83 44.61,93.34 46.09,93.34 46.61,92.82 46.61,92.02 51.07,87.56 51.07,82.75 53.34,80.48 54.28,80.48 UV1.G27
FB_A_CMD15: length 111.3
  TOP w0.102: UV6.K3 39.47,70.43 39.92,69.98 39.92,69.28 v2(39.54,68.9) ; v2(39.56,83.53) 39.87,83.84 39.87,84.35 UV7.K3 ; v2(69.27,100.16) 69.27,100.43 69.39,100.55 70.77,100.55 UV5.K3 ; UV9.K3 56.39,100.38 55.61,99.6 55.18,99.6 v2(54.64,100.14)
  TOP w0.124: RPV9.1 RPV9.2 46.35,92.76 v2(46.19,92.6)
  IN1 w0.089: v2(62.22,97.37) 62.12,97.27 61.46,97.27 61.34,97.4 59.37,97.4 58.79,97.97 56.16,97.97 55.83,98.3 53.64,98.3 53.1,98.84 51.97,98.84 51.68,98.54 51.68,98.16 51.49,97.97 51.12,97.97 50.58,97.43 50.58,95.65 49.14,94.21 47.8,94.21 v2(46.19,92.6) 46.19,90.25 44.14,88.2 42.41,88.2 41.68,87.47 41.35,87.47 40.86,86.99 40.86,85.07 41.4,84.54 41.4,82.34 41.73,82.01 41.73,79.38 42.49,78.62 42.49,76.37 v2(42.6,76.25)
  IN3 w0.102: v2(39.56,83.53) 39.93,83.53 40.27,83.2 40.27,82.12 40.93,81.46 40.93,79.3 41.19,79.04 41.19,78.83 42.42,77.59 42.42,76.43 v2(42.6,76.25) 42.84,76.01 42.84,74.49 42.13,73.78 41.92,73.78 41.51,73.37 41.51,73.31 41.08,72.87 41.08,70.46 39.54,68.93 v2(39.54,68.9) ; v2(69.27,100.16) 69.37,100.05 69.37,99.83 69.27,99.72 69.04,99.72 68.7,99.38 68.47,99.38 67.71,98.62 65.3,98.62 64.86,98.19 64.81,98.19 63.99,97.37 v2(62.22,97.37) 62.11,97.26 61.51,97.26 61.25,97.53 60.33,97.53 59.35,98.51 59.13,98.51 58.88,98.76 56.72,98.76 56.49,98.99 56.49,99.09 55.92,99.66 55.29,99.66 54.81,100.14 v2(54.64,100.14)
  BOTTOM w0.102: v2(54.64,100.14) 54.33,99.83 53.82,99.83 UV4.K3 ; v2(39.54,68.9) 39.27,68.9 39.14,68.78 39.14,67.4 UV14.K3 ; UV15.K3 39.32,81.79 40.09,82.56 40.09,83 v2(39.56,83.53) ; UV8.K3 67.75,100.23 68.2,99.78 68.9,99.78 v2(69.27,100.16)
  BOTTOM w0.124: v2(46.19,92.6) 46.19,91.91 v1(48.05,90.05) 50.69,87.41 50.69,82.59 53.18,80.1 54.7,80.1 UV1.G26
FB_A_CMD16: length 80.3
  TOP w0.102: UV7.K1 38.92,86.1 38.92,84.82 39.16,84.58 39.16,83.07 v2(39.56,82.68) ; v2(39.5,69.74) 38.84,70.4 38.84,71.21 39.18,71.55 39.57,71.55 39.72,71.7 39.72,71.89 39.59,72.03 UV6.K1
  TOP w0.124: RV2439.2 42.49,77.03 42.09,76.64 42.09,75.64 v2(42.24,75.49)
  IN1 w0.089: v2(42.45,88.69) 41.95,88.19 41.64,88.19 40.56,87.11 40.56,84.87 40.66,84.76 40.66,84.03 40.55,83.92 40.55,82.1 41.52,81.13 41.52,79.2 42.1,78.63 42.1,75.64 v2(42.24,75.49)
  IN3 w0.102: v2(39.56,82.68) 39.56,82.45 40.1,81.9 40.1,80.38 40.73,79.75 40.73,78.95 40.92,78.76 40.92,78.58 42.09,77.41 42.09,75.94 42.24,75.78 v2(42.24,75.49) 42.24,74.58 41.18,73.51 41.18,73.32 40.87,73.02 40.87,70.58 40.47,70.17 40.33,70.17 40.15,70.35 39.98,70.35 39.86,70.24 39.86,70.07 40.04,69.89 40.04,69.71 39.72,69.4 39.59,69.4 39.5,69.49 v2(39.5,69.74)
  IN3 w0.127: v2(57.09,76.78) 56.68,77.19 55.25,77.19 54.73,77.72 54.11,77.72 52.69,79.13 52.69,80.38 51.5,81.57 51.5,82.43 50.77,83.16 50.77,84.49 47.38,87.88 41.35,87.88 41.15,88.08 39.06,88.08 38.93,88.21 38.93,89.59 39.06,89.72 39.62,89.72 39.74,89.59 39.74,88.81 39.87,88.69 v2(42.45,88.69)
  BOTTOM w0.102: v2(39.5,69.74) 39.5,69.61 38.94,69.05 38.94,66 UV14.K1 ; v2(39.56,82.68) 39.56,82.41 38.84,81.69 38.84,80.58 UV15.K1
  BOTTOM w0.127: v2(57.09,76.78) 57.09,76.75 56.7,76.36 UV1.M24
FB_A_CMD17: length 70.3
  IN1 w0.089: v2(40.25,89.21) 40.25,88.96 39.03,87.74 39.03,86.65 38.68,86.3 38.68,84.39 38.44,84.15 38.4,84.15 38.11,83.85 38.11,81.83 38.68,81.26 38.68,78.78 39.12,78.34 39.12,74.68 38.98,74.54 v2(38.98,74.1) 38.98,73.33 38.9,73.25 38.9,67.09 38.6,66.79 v2(38.11,66.79)
  IN3 w0.102: v2(38.98,74.1) 39,74.1 39.19,74.29 39.19,78.82 39.58,79.2 39.58,79.41 39.09,79.9 39.09,80.46 39.04,80.51 v2(38.21,80.51)
  IN3 w0.127: v2(40.25,89.21) 40.25,89.95 40.13,90.07 37.08,90.07 36.95,89.95 36.95,89.23 37.08,89.1 38.47,89.1 38.6,88.97 38.6,88.57 38.47,88.45 37.2,88.45 37.08,88.32 37.08,87.88 37.2,87.75 41.01,87.75 41.21,87.55 47.17,87.55 50.44,84.28 50.44,83.02 51.17,82.29 51.17,81.43 52.36,80.24 52.36,78.99 54.18,77.17 54.18,77.04 54.44,76.79 55.73,76.79 56.2,76.32 57.02,76.32 57.13,76.21 v2(57.13,75.97)
  BOTTOM w0.102: v2(38.21,80.51) 38.48,80.51 38.59,80.62 38.59,80.83 UV15.L2 ; v2(38.11,66.79) 38.15,66.79 UV14.L2
  BOTTOM w0.127: UV1.M23 v2(57.13,75.97)
FB_A_CMD18: length 74.4
  TOP w0.102: UV7.L2 38.11,85.29 38.11,84.62 v2(38.23,84.49) ; v2(39.69,72.68) 39.31,72.68 38.84,72.21 38.84,71.54 38.52,71.23 UV6.L2
  IN1 w0.089: v2(41.29,89.82) 41.29,89.57 39.33,87.61 39.33,86.57 38.97,86.22 38.97,79.63 39.66,78.94 v2(39.66,76.59) 39.66,76.02 40.04,75.64 40.04,75.05 39.94,74.95 39.53,74.95 39.43,74.85 39.43,74.65 39.53,74.54 39.94,74.54 40.04,74.44 40.04,74.24 39.94,74.14 39.53,74.14 39.43,74.04 39.43,73.83 39.53,73.73 40.25,73.73 40.38,73.6 40.38,72.13 40.25,72 39.82,72 39.69,72.13 v2(39.69,72.68)
  IN3 w0.102: v2(39.66,76.59) 39.66,77.61 39.52,77.75 39.52,78.69 39.79,78.96 39.79,79.5 39.29,80 39.29,80.93 38.11,82.1 38.11,83.19 38.04,83.26 38.04,84.3 v2(38.23,84.49)
  IN3 w0.127: v2(41.29,89.82) 41.59,89.82 41.71,89.7 41.71,89.23 41.84,89.11 42.79,89.11 42.92,89.23 42.92,89.91 42.46,90.37 42.46,91.11 42.4,91.18 42.04,91.18 41.92,91.3 41.92,91.7 42.04,91.83 43.01,91.83 43.13,91.7 43.13,90.82 43.59,90.36 43.59,88.34 43.72,88.21 43.97,88.21 44.1,88.34 44.1,90.23 44.23,90.36 44.48,90.36 44.61,90.23 44.61,88.34 44.74,88.21 44.99,88.21 45.12,88.34 45.12,89.9 45.24,90.03 45.5,90.03 45.62,89.9 45.62,88.34 45.75,88.21 46.01,88.21 46.13,88.34 46.13,89.23 46.26,89.35 46.51,89.35 46.64,89.23 46.64,88.54 46.77,88.41 47.32,88.41 51.1,84.63 51.1,83.3 51.83,82.57 51.83,81.7 53.02,80.52 53.02,79.31 54.3,78.03 55.68,78.03 56.12,77.6 v2(56.3,77.6)
  BOTTOM w0.127: UV1.K24 56.7,78 v2(56.3,77.6)
FB_A_CMD19: length 75.4
  TOP w0.102: UV6.K9 39.32,65.92 39,66.25 39,68.73 v2(38.51,69.21) ; UV7.K9 39.32,80.4 38.94,80.78 38.94,81.96 39.14,82.16 39.14,82.59 38.99,82.74 38.8,82.74 38.52,82.46 v2(38.52,82.24)
  TOP w0.124: RV2437.2 40.13,76.94 40.13,76 v2(40.44,75.68)
  IN1 w0.089: v2(42.13,89.88) 42.03,89.88 39.63,87.48 39.63,86.46 39.18,86 39.18,82.3 39.31,82.16 39.31,79.86 40.22,78.95 40.22,75.9 v2(40.44,75.68)
  IN3 w0.102: v2(38.51,69.21) 38.72,69.41 38.72,70.16 39.04,70.49 39.04,71.07 39.69,71.72 39.69,71.92 40.14,72.37 40.14,73.93 40.44,74.23 v2(40.44,75.68) 40.21,75.92 40.21,77.85 39.89,78.17 39.89,78.71 39.89,78.72 39.91,78.72 40.04,78.84 40.04,79.54 39.49,80.09 39.49,81.01 38.52,81.99 v2(38.52,82.24)
  IN3 w0.127: v2(57.08,77.6) 56.67,78.01 56.06,78.01 55.79,78.29 54.55,78.29 53.35,79.49 53.35,80.65 52.16,81.84 52.16,82.7 51.43,83.44 51.43,84.9 45.98,90.36 44.95,90.36 44.56,90.75 43.67,90.75 43.46,90.95 43.46,92.03 43.34,92.16 41.8,92.16 41.59,91.94 41.59,90.43 v2(42.13,89.88)
  BOTTOM w0.102: v2(38.52,82.24) 38.66,82.24 39.16,82.74 39.16,84.51 39,84.67 39,85.92 39.32,86.24 UV15.K9 ; UV14.K9 39.32,71.74 39,71.41 39,69.69 v2(38.51,69.21)
  BOTTOM w0.127: v2(57.08,77.6) UV1.K23
FB_A_CMD20: length 143.9
  TOP w0.102: v2(54.52,105.54) 54.9,105.15 55.99,105.15 56.34,105.5 56.95,105.5 UV9.T2 ; 71.27,105.78 71.75,105.31 UV5.T2 ; UV7.T2 34.11,85.7 ; v2(34.16,83.66) 34.14,83.66 34.11,83.69 ; UV6.T2 33.92,71.23
  TOP w0.124: v2(38.44,98.57) 38.28,98.73 37.85,98.73 RV2447.2 ; 34.11,83.69 33.47,84.32 33.47,85.41 33.77,85.7 34.11,85.7 ; v2(33.34,69.28) 33.34,70.67 33.9,71.23 33.92,71.23 ; 71.27,105.78 70.73,106.33 v2(69.21,106.33)
  IN1 w0.089: v2(61.43,108.12) 61.18,108.37 48.81,108.37 39.17,98.73 38.6,98.73 v2(38.44,98.57) 38.13,98.57 34.32,94.76 34.32,94.44 34.85,93.91 34.85,93.74 34.71,93.6 34.56,93.6 34.34,93.82 34.2,93.82 34.05,93.68 34.05,93.53 34.28,93.31 34.28,93.17 31.33,90.22 31.33,76.77 31.74,76.35 v2(31.74,76.32)
  IN3 w0.102: v2(33.34,69.28) 32.49,69.28 31.45,70.32 31.45,71.89 31.39,71.95 31.39,72.91 31.89,73.42 31.89,76.17 v2(31.74,76.32) 31.74,76.35 31.63,76.47 31.63,81.7 33.58,83.66 v2(34.16,83.66) ; v2(69.21,106.33) 68.27,107.27 64.71,107.27 63.86,108.12 v2(61.43,108.12) 57.04,108.12 54.52,105.6 v2(54.52,105.54)
  BOTTOM w0.102: UV8.T2 66.95,105.78 ; UV14.T2 34.39,66.43 33.92,66.9 33.92,68.71 ; v2(34.16,83.66) 34.54,83.27 34.54,82.19 34.19,81.84 34.19,81.23 UV15.T2 ; UV4.T2 52.47,105.59 ; 54.48,105.59 54.52,105.56 v2(54.52,105.54)
  BOTTOM w0.124: 33.92,68.71 v2(33.34,69.28) ; UV1.M27 53.2,76.34 48.04,81.49 48.04,86.31 45.71,88.64 44.99,88.64 38.88,94.75 v1(38.88,96.89) 38.88,97.53 v2(38.44,98.57) ; 54.48,105.59 53.85,106.22 52.76,106.22 52.47,105.93 52.47,105.59 ; v2(69.21,106.33) 67.47,106.33 66.95,105.8 66.95,105.78
FB_A_CMD21: length 135.2
  TOP w0.102: UV6.R2 34.89,70.8 34.07,70.8 v2(34.03,70.76) ; UV7.R2 35.32,85.67 v2(34.92,85.27) ; UV9.R8 52.56,104.38 v2(52.93,104.75) ; v2(71.37,104.86) 71.75,104.47 UV5.R2
  TOP w0.124: RPV10.1 RPV10.2 37.21,96.9 37.37,97.06 v2(38.35,97.06)
  IN1 w0.089: v2(33.27,75.76) 33.14,75.89 33.14,76.64 32.24,77.53 32.24,89.71 33.9,91.37 34.16,91.37 34.35,91.17 34.53,91.17 34.69,91.33 34.69,91.51 34.38,91.83 34.38,91.97 36.76,94.36 36.76,95.17 36.49,95.44 36.49,95.62 36.69,95.82 36.87,95.82 37.13,95.56 37.28,95.56 37.42,95.7 37.42,95.85 37.14,96.12 37.14,96.29 37.26,96.41 37.43,96.41 37.86,95.98 38.02,95.98 38.14,96.1 38.14,96.27 37.9,96.51 37.9,96.61 v2(38.35,97.06) 39.88,97.84 42.09,100.05 42.09,100.33 49.22,107.46 59.73,107.46 61.21,106.88 62.07,106.88 v2(62.08,106.87)
  IN3 w0.102: v2(34.92,85.27) 34.75,84.89 34.75,82.66 34.06,81.96 33.81,81.96 32.62,80.78 32.62,77.06 33.15,76.53 33.15,75.88 v2(33.27,75.76) 33.27,75.49 32.7,74.92 32.7,74.03 33.09,73.64 33.09,70.92 33.22,70.79 33.51,70.79 33.63,70.92 33.63,72.19 33.76,72.32 34.22,72.32 34.42,72.12 34.42,71.15 v2(34.03,70.76) ; v2(52.93,104.75) 53.09,104.9 55.77,104.9 57.91,107.04 60.24,107.04 60.95,107.04 61.13,106.87 v2(62.08,106.87) 62.5,106.45 63.97,106.45 64.14,106.28 65.33,106.28 66.42,105.19 67.06,105.19 67.23,105.01 70.11,105.01 70.24,104.88 71.34,104.88 v2(71.37,104.86)
  BOTTOM w0.102: UV9.R8 52.56,104.38 v2(52.93,104.75) ; v2(71.37,104.86) 71.75,104.47 UV5.R2 ; v2(34.92,85.27) 35.32,85.67 UV7.R2 ; v2(34.03,70.76) 34.07,70.8 34.89,70.8 UV6.R2
  BOTTOM w0.124: UV1.M26 54.71,75.95 53.05,75.95 47.66,81.34 47.66,86.15 45.56,88.26 44.83,88.26 v1(38.92,94.17) 38.42,94.67 38.43,94.67 v2(38.35,97.06)
FB_A_CMD22: length 126.5
  TOP w0.102: v2(35.74,66.79) 35.75,66.79 UV6.P8 ; UV9.P2 57.17,103.58 v2(56.78,103.98) ; v2(66.55,104.07) 66.55,104.06 66.95,103.67 UV5.P8 ; UV7.P8 36.12,81 v2(35.72,81.4)
  TOP w0.124: RPV18.1 RPV18.2 38.58,93.98 38.58,94.24 v2(39.32,94.98)
  IN1 w0.089: v2(35.24,74.35) 35.05,74.16 35.05,73.02 34.92,72.89 34.67,72.89 34.55,73.02 34.55,74.42 34.65,74.52 34.73,74.52 34.85,74.64 34.85,74.81 34.73,74.92 34.65,74.92 34.55,75.03 34.55,75.23 34.65,75.33 34.89,75.33 35.01,75.45 35.01,75.62 34.89,75.74 34.65,75.74 34.55,75.84 34.55,76.01 34.69,76.15 34.69,76.38 34.56,76.51 34.41,76.51 34.3,76.62 34.3,76.78 34.41,76.9 34.56,76.9 34.69,77.03 34.69,77.53 33.46,78.76 33.46,81.76 33.73,82.02 33.73,82.34 33.46,82.6 33.46,87.2 33.95,87.69 33.95,88.81 39.74,94.6 39.74,94.86 39.63,94.98 v2(39.32,94.98) 49.05,104.71 49.4,104.71 50.93,106.24 59.22,106.24 60.23,105.23 63.01,105.23 v2(63.78,104.45) 64.24,104.45 64.34,104.55 64.34,104.87 64.46,104.99 64.63,104.99 64.75,104.87 64.75,104.19 64.87,104.07 65.03,104.07 65.15,104.19 65.15,104.96 65.27,105.08 65.44,105.08 65.56,104.96 65.56,104.64 65.69,104.51 65.92,104.51 66.03,104.61 66.03,104.92 66.13,105.02 66.33,105.02 66.43,104.92 66.43,104.61 66.53,104.51 67.49,104.51 67.62,104.39 67.62,104.2 67.49,104.07 v2(66.55,104.07)
  IN3 w0.102: v2(56.78,103.98) 56.78,104.13 56.91,104.27 57.09,104.27 57.17,104.35 57.87,104.35 58.1,104.58 58.1,105.02 58.36,105.29 59.26,105.29 59.36,105.19 63.05,105.19 v2(63.78,104.45) ; v2(35.72,81.4) 35.72,81.13 35.34,80.75 35.34,80.49 34.98,80.12 34.55,80.12 34.42,80 34.42,78.68 34.56,78.54 34.56,77.52 34.65,77.43 34.65,74.94 v2(35.24,74.35) 35.24,73.86 35.22,73.84 35.22,70.65 35.74,70.12 v2(35.74,66.79)
  BOTTOM w0.102: UV6.P8 35.75,66.79 v2(35.74,66.79) ; UV5.P8 66.95,103.67 66.55,104.06 v2(66.55,104.07) ; v2(56.78,103.98) 57.17,103.58 UV9.P2 ; v2(35.72,81.4) 36.12,81 UV7.P8
  BOTTOM w0.124: v2(39.32,94.98) 39.32,94.85 v1(40.54,93.62) 45.15,89.02 45.87,89.02 48.42,86.47 48.42,81.65 53.29,76.78 55.46,76.78 UV1.M25
FB_A_CMD23: length 126.8
  TOP w0.102: UV7.R7 35.23,81.79 35.23,82.79 v2(35.57,83.13) ; UV9.R3 56.38,104.47 55.38,104.47 v2(55.05,104.13) ; UV6.R7 35.36,67.27 v2(35.36,67.75) ; UV5.R7 v2(68.26,104.38)
  TOP w0.124: v2(39.56,95.8) 39.52,95.75 39.49,95.75 38.16,94.42 38.16,94.26 RPV18.3 RPV18.4
  IN1 w0.089: v2(61.02,105.66) 60.89,105.53 60.36,105.53 59.35,106.54 50.8,106.54 49.28,105.02 48.92,105.02 47.75,103.84 46.89,103.84 45.69,102.63 45.69,101.78 42,98.09 41.85,98.09 v2(39.56,95.8) 38.74,94.97 38.74,94.83 39.05,94.51 39.05,94.35 38.94,94.23 38.77,94.23 38.45,94.54 38.31,94.54 38.15,94.38 38.15,94.24 38.46,93.93 38.46,93.75 38.3,93.59 38.12,93.59 37.82,93.89 37.66,93.89 37.54,93.77 37.54,93.6 37.85,93.29 37.85,93.14 37.71,93 37.57,93 37.37,93.2 37.2,93.2 37.08,93.08 37.08,92.91 37.28,92.71 37.28,92.57 33.65,88.94 33.65,88.7 33.52,88.57 33.28,88.57 33.16,88.45 33.16,88.22 33.26,88.12 33.53,88.12 33.65,88 33.65,87.83 33.53,87.71 33.26,87.71 33.16,87.61 33.16,78.63 33.35,78.43 33.35,78.31 33.16,78.11 33.16,77.95 33.27,77.84 33.47,77.84 33.59,77.97 33.82,77.97 34.23,77.56 v2(34.23,77.26)
  IN3 w0.102: v2(55.05,104.13) 55.38,104.47 56.21,104.47 56.35,104.61 56.54,104.61 56.68,104.47 57,104.47 57.25,104.72 57.25,105 57.75,105.5 58.1,105.5 58.12,105.53 59.23,105.53 59.36,105.66 59.36,105.93 59.48,106.05 59.74,106.05 59.86,105.93 59.86,105.66 59.99,105.53 60.89,105.53 v2(61.02,105.66) 61.14,105.53 63.17,105.53 63.81,104.89 65.27,104.89 65.4,104.77 66.86,104.77 67.25,104.38 v2(68.26,104.38) ; v2(35.36,67.75) 35.38,67.77 35.38,70.04 34.93,70.49 34.93,72.42 34.8,72.55 34.8,74.31 34.32,74.79 34.32,76.65 34.23,76.74 v2(34.23,77.26) 34.23,78.42 34.19,78.46 34.19,79.66 34.07,79.78 33.74,79.78 33.61,79.91 33.61,80.32 33.88,80.59 34.37,80.59 34.7,80.92 35.21,80.92 35.34,81.05 35.34,81.42 35.04,81.72 34.91,81.84 34.91,82 35.04,82.13 35.05,82.13 35.17,82.25 35.17,83.81 35.33,83.96 35.44,83.96 35.57,83.83 v2(35.57,83.13)
  BOTTOM w0.102: UV9.R3 56.38,104.47 55.38,104.47 v2(55.05,104.13) ; UV5.R7 v2(68.26,104.38) ; v2(35.36,67.75) 35.36,67.27 UV6.R7 ; v2(35.57,83.13) 35.23,82.79 35.23,81.79 UV7.R7
  BOTTOM w0.124: UV1.K26 54.71,77.63 52.98,77.63 48.8,81.81 48.8,86.62 45.58,89.84 44.86,89.84 42.73,91.97 42.73,93.05 v1(42.4,93.39) 39.98,95.8 v2(39.56,95.8)
FB_A_CMD24: length 123.1
  TOP w0.102: v2(36.57,85.33) 36.15,84.9 UV7.P3 ; UV5.P3 70.73,103.36 v2(70.29,103.36) ; v2(36.53,70.91) 36.12,70.5 UV6.P3 ; v2(52.9,103.12) 53.27,103.49 UV9.P7
  TOP w0.124: v2(43.36,94.37) 43.32,94.41 RPV11.3 RPV11.4
  IN1 w0.089: v2(36.66,75.05) 36.66,76.7 36.44,76.92 36.44,78.29 35.62,79.11 35.62,79.75 36.11,80.24 36.11,81.86 35.99,81.97 35.99,83.44 35.86,83.57 35.86,85.44 35.28,86.03 35.28,86.38 35.5,86.61 35.5,87.13 36.23,87.85 36.23,88.93 39.57,92.27 40.25,92.27 42.09,94.11 42.09,94.77 42.22,94.89 42.47,94.89 42.54,94.83 42.54,94.35 42.68,94.21 43.2,94.21 v2(43.36,94.37) 43.62,94.63 43.62,95.88 44.25,96.51 44.58,96.51 44.89,96.83 44.89,98.4 49.62,103.13 49.98,103.13 51.03,104.18 51.51,104.18 51.75,104.42 52.15,104.42 52.74,103.84 54.6,103.84 54.73,103.71 56.2,103.71 56.54,103.37 58.09,103.37 58.63,103.91 59.08,103.91 59.57,103.42 59.67,103.42 60.06,103.04 62.29,103.04 v2(62.35,103.1)
  IN3 w0.102: v2(36.58,85.33) 36.58,85.08 36.2,84.71 36.2,84.19 36.4,84 36.4,82.13 36.79,81.73 36.79,79.94 36.91,79.82 36.91,78.92 36.66,78.67 36.66,78.03 36.48,77.85 36.48,76.95 36.66,76.76 v2(36.66,75.05) 36.94,74.77 36.94,73.83 37.13,73.64 37.53,73.64 37.65,73.52 37.65,73.21 37.59,73.14 37.28,73.14 37.15,73.02 37.15,72.4 37.28,72.27 37.85,72.27 37.97,72.15 37.97,71.99 37.85,71.87 37.33,71.87 37.2,71.74 37.2,71.56 37.33,71.43 37.76,71.43 37.89,71.3 37.89,71.11 37.72,70.94 37.57,70.94 37.44,71.07 37.29,71.07 37.15,70.93 37.15,70.79 37.29,70.65 37.29,70.51 37.06,70.29 36.89,70.29 36.7,70.48 36.34,70.48 36.21,70.6 36.21,70.78 36.34,70.91 v2(36.53,70.91) ; v2(70.29,103.36) 70.06,103.13 69.95,103.13 69.84,103.24 69.84,103.43 69.73,103.55 69.48,103.55 69.35,103.42 69.35,103.23 69.25,103.13 69.04,103.13 68.94,103.23 68.94,103.45 68.84,103.55 68.64,103.55 68.49,103.4 68.49,102.89 68.36,102.76 65.1,102.76 64.65,103.22 62.47,103.22 v2(62.35,103.1) 62.29,103.04 61.43,103.04 61.32,102.92 59.05,102.92 59.03,102.9 56.44,102.9 56.05,103.3 54.67,103.3 54.56,103.41 53.38,103.41 53.09,103.12 v2(52.9,103.12)
  IN3 w0.127: v2(43.36,94.37) 43.36,94.37 52.42,85.31 52.42,83.85 53.16,83.11 53.16,82.25 54.8,80.6 54.8,79.72 55.3,79.22 57.13,79.22 v2(57.92,78.43)
  BOTTOM w0.102: UV5.P3 70.73,103.36 v2(70.29,103.36) ; UV6.P3 36.12,70.5 v2(36.53,70.91) ; UV7.P3 36.15,84.9 v2(36.57,85.33) ; v2(52.9,103.12) 53.27,103.49 UV9.P7
  BOTTOM w0.127: v2(57.92,78.43) 57.92,78.44 UV1.K22
FB_A_CMD25: length 122.3
  TOP w0.102: v2(38.27,67.66) 38.52,67.42 UV6.L7 ; UV9.L3 55.9,101.74 55.39,101.74 55.14,101.5 v2(55.14,101.21) ; v2(69.71,101.4) 69.55,101.56 68.63,101.56 68.25,101.18 UV5.L7 ; v2(38.49,83.01) 38.18,83.01 37.95,82.79 37.95,82.27 UV7.L7
  TOP w0.124: v2(44.89,92.07) 44.89,91.69 45.53,91.05 RPV12.2 RPV12.1
  IN1 w0.089: v2(63.7,98.76) 60.36,98.76 59.11,100 56.06,100 55.82,99.76 54.49,99.76 54.11,100.13 53.56,100.13 53.03,99.6 52.01,99.6 51.86,99.75 51.2,99.75 49.73,98.28 49.33,98.28 48.91,97.86 48.91,96.43 44.89,92.41 v2(44.89,92.07) 45.4,92.07 45.48,91.98 45.48,91.71 45.3,91.53 44.93,91.53 44.85,91.45 44.85,91.07 43.17,89.4 41.98,89.4 39.95,87.37 39.95,86.32 40.1,86.16 40.1,85.15 39.57,84.61 39.57,84.06 39.94,83.69 39.94,82.36 39.69,82.11 39.69,80.18 41.2,78.67 41.2,78.41 41.1,78.31 40.65,78.31 40.53,78.19 40.53,78.02 40.65,77.9 41.37,77.9 41.49,77.78 41.49,77.62 41.37,77.5 40.65,77.5 40.53,77.38 40.53,77.21 40.65,77.09 41.36,77.09 41.49,76.96 41.49,76.51 41.36,76.38 v2(41.2,76.38)
  IN3 w0.102: v2(55.14,101.21) 55.14,100.88 55.24,100.78 55.72,100.78 56.5,100 58,100 58.55,99.46 59.89,99.46 60.58,98.76 v2(63.7,98.76) 63.7,99.09 63.83,99.22 64.92,99.22 65.13,99.43 65.33,99.43 65.51,99.25 65.78,99.25 65.95,99.42 65.95,99.83 66.21,100.09 66.33,100.09 66.47,99.95 66.63,99.95 66.76,100.08 66.76,100.31 66.65,100.41 66.65,100.59 66.84,100.78 69.94,100.78 70.07,100.91 70.07,101.27 69.94,101.4 v2(69.71,101.4) ; v2(38.27,67.66) 38.09,67.84 38.09,68.63 38.26,68.8 38.7,68.8 38.92,69.02 38.92,70.05 39.24,70.37 39.24,70.98 39.89,71.63 39.89,71.84 40.44,72.39 40.44,73.22 40.48,73.26 40.48,73.74 40.77,74.04 40.77,75.17 40.86,75.25 40.86,76.04 v2(41.2,76.38) 41.2,77.32 40.24,78.29 40.24,79.63 39.7,80.17 39.7,81.09 39.51,81.28 39.51,81.42 39.67,81.57 39.67,81.74 39.55,81.86 39.39,81.86 39.23,81.7 39.09,81.7 38.94,81.85 38.94,81.99 39.09,82.14 39.09,82.28 38.92,82.45 38.92,83.29 38.79,83.42 38.62,83.42 38.49,83.29 v2(38.49,83.01)
  IN3 w0.127: v2(57.1,78.42) 56.63,78.89 55.27,78.89 54.54,79.62 54.54,80.4 52.83,82.11 52.83,82.98 52.09,83.71 52.09,85.17 45.2,92.07 v2(44.89,92.07)
  BOTTOM w0.102: v2(69.71,101.4) 69.55,101.56 68.64,101.56 68.26,101.18 UV5.L7 ; UV7.L7 37.95,82.27 37.95,82.79 38.18,83.01 v2(38.49,83.01) ; v2(38.27,67.66) 38.52,67.42 UV6.L7 ; UV9.L3 55.9,101.74 55.39,101.74 55.14,101.5 v2(55.14,101.21)
  BOTTOM w0.127: v2(57.1,78.42) UV1.J23
