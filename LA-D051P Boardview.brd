# Allegro board LA-D051P Boardview.brd (continued)
## Copper pours and planes (outline as drawn) (continued)
+5VS on BOTTOM (solid shape): 12.12,69.97 12.12,63.05 14.09,61.08 14.09,58.41 14.53,57.97 14.53,57.2 14.22,56.89 13.07,56.89 12.57,57.4 12.57,60.8 10.72,62.65 10.72,69.14 10.34,69.52 8.25,69.52 7.93,69.84 7.93,70.54 8.25,70.86 11.23,70.86
+5VS on IN1 (solid shape): 167.13,8.63 167.13,6.91 166.93,6.72 164.39,6.72 164.08,7.04 164.08,8.44 164.39,8.75 167,8.75
+5VS on IN1 (solid shape): 198.18,78.22 198.18,77.33 197.92,77.08 196.65,77.08 195.95,77.78 195.95,78.29 196.14,78.48 197.92,78.48
+5VS on IN1 (solid shape): outline of 112 points within 185.86,14.79 193.54,21.96
+5VS on IN3 (solid shape): 9.07,70.29 9.07,69.52 8.95,69.4 6.72,69.4 6.6,69.52 6.6,70.29 6.72,70.41 8.95,70.41
+5VS on IN3 (solid shape): 13.26,102.67 13.26,101.85 12.95,101.53 11.49,101.53 11.04,101.97 11.04,102.42 11.49,102.86 13.07,102.86
+5VS on VCC: 160.25,7.42 157.26,10.41 106.4,10.41 102.91,13.9 30.71,13.9 20.06,24.54 20.06,48.17 12.95,55.28 12.95,57.48 13.62,58.16 14.75,58.16 22.79,50.11 22.79,27.13 33.35,16.56 103.77,16.56 107.65,12.69 159.02,12.69 161.11,10.6 166.55,10.6 166.55,7.91 166.07,7.42 ; 1 cut-out
+5VS_KBL on TOP (solid shape): 121.06,17.99 121.06,16.72 120.96,16.63 119.75,16.63 119.63,16.76 119.63,17.9 120.01,18.28 120.77,18.28
+5VS_KBL on TOP (solid shape): 118.74,24.31 118.74,22.85 119.12,22.47 119.69,22.47 119.88,22.28 119.88,19.42 119.56,19.1 119.06,19.1 118.8,19.36 118.8,20.95 117.91,21.84 116.71,21.84 116.64,21.9 116.64,24.12 117.06,24.53 118.52,24.53
+17.4V_BATT+ on BOTTOM (solid shape): 25.01,28.82 25.01,25.07 26.03,24.06 26.03,22.47 25.9,22.34 24.31,22.34 24.31,21.64 25.9,21.64 26.03,21.52 26.03,19.93 25.77,19.68 22.79,19.68 22.15,19.04 21.46,19.04 21.39,19.1 21.39,23.3 20.19,24.5 20.19,26.6 20.76,26.6 20.76,27.99 20.19,27.99 20.19,29.26 20.57,29.65 24.19,29.65
+17.4V_BATT++ on TOP (solid shape): 19.81,29.14 19.81,25.58 19.49,25.26 15.42,25.26 15.04,25.65 13.52,25.65 13.14,26.03 13.14,29.01 13.84,29.71 19.23,29.71
+17.4V_BATT++ on BOTTOM (solid shape): 20,29.26 20,25.65 19.61,25.26 15.42,25.26 15.04,25.65 13.58,25.65 13.07,26.15 13.07,29.07 13.71,29.71 19.55,29.71
+19V_ADPIN on TOP (solid shape): outline of 98 points within 13.58,104.61 22.73,120.83
+19V_VIN on TOP (solid shape): 30.73,112.58 30.73,109.34 30.47,109.08 30.47,108.32 30.35,108.2 29.39,108.2 29.08,108.51 29.08,112.58 29.27,112.77 30.54,112.77
+19V_VIN on TOP (solid shape): 35.05,58.98 35.05,52.76 34.66,52.38 33.01,52.38 32.57,52.82 32.57,54.09 32.51,54.09 32.51,59.81 32.38,59.94 32.38,60.38 32.57,60.57 33.46,60.57
+19V_VIN on TOP (solid shape): 21.9,41.46 21.9,40.25 21.27,39.62 21.27,36.88 21.52,36.63 23.36,36.63 23.5,36.49 23.5,35.15 23.42,35.08 19.39,35.08 18.73,35.74 18.73,40.89 19.55,41.71 21.65,41.71
+19V_VIN on TOP (solid shape): 24.95,109.91 24.95,106.61 24.76,106.42 23.74,106.42 23.68,106.48 23.68,107.5 23.49,107.69 21.84,107.69 21.65,107.5 21.65,107.18 21.52,107.05 19.74,107.05 19.42,107.37 19.42,109.78 20,110.35 24.5,110.35
+19V_VIN on BOTTOM (solid shape): 34.73,59.43 34.73,57.46 34.6,57.33 33.52,57.33 33.27,57.59 33.27,59.87 34.28,59.87
+19V_VIN on BOTTOM (solid shape): 23.62,39.36 23.62,35.93 23.49,35.81 20.95,35.81 20,36.76 20,39.49 20.25,39.74 23.23,39.74
+19V_VIN on BOTTOM (solid shape): 25.65,109.53 29.46,109.53 29.77,109.21 29.77,108.45 29.52,108.2 26.16,108.2 25.39,107.43 22.54,107.43 21.58,108.39 21.58,109.97 21.96,110.35 24.82,110.35
+19VB on TOP (solid shape): 12.65,78.94 12.74,78.86 12.85,78.81 12.92,78.79 13.01,78.78 13.24,78.54 13.24,75.45 11.99,74.2 8.24,74.2 8.16,74.28 8.16,75.91 9.6,77.35 9.6,79.12 9.8,79.32 12.27,79.32
+19VB on TOP (solid shape): outline of 570 points within 29.08,17.52 90.8,38.89
+19VB on BOTTOM (solid shape): 16.55,77.7 16.55,76.02 16.09,75.56 12.02,75.56 11.95,75.62 11.95,77.85 12.19,78.09 16.16,78.09
+19VB on BOTTOM (solid shape): 59.05,21.14 59.05,18.85 57.46,17.26 54.41,17.26 54.1,17.58 54.1,20.76 54.54,21.2 58.98,21.2
+19VB on BOTTOM (solid shape): 70.67,38.22 70.67,36.38 70.29,36 68.64,36 68.51,36.12 68.51,38.35 68.7,38.54 70.35,38.54
+19VB on BOTTOM (solid shape): 46.17,118.89 46.17,118.16 45.65,118.16 45.65,116.13 46.17,116.13 46.17,115.45 45.9,115.18 41.63,115.18 41.44,115.37 41.44,118.36 42.2,119.12 45.95,119.12
+19VB on BOTTOM (solid shape): 171.44,52.89 171.44,52.25 170.87,52.25 170.87,50.85 171.44,50.85 171.44,50.43 171.13,50.11 168.22,50.11 168.11,50.22 168.11,51.9 167.82,52.19 167.82,52.51 168.46,53.14 171.19,53.14
+19VB on BOTTOM (solid shape): 93.59,30.47 93.59,24.76 93.05,24.22 91.97,24.22 91.97,24.79 90.58,24.79 90.58,24.22 89.5,24.22 89.15,24.57 88.64,24.57 88.39,24.82 88.39,25.65 90.29,27.55 90.29,30.41 90.35,30.47 90.35,30.79 90.61,31.04 93.02,31.04
+19VB on BOTTOM (solid shape): 42.6,34.34 45.9,34.34 45.9,31.61 45.78,31.49 41.78,31.49 39.81,29.52 32.06,29.52 31.68,29.14 31.68,26.98 31.3,26.6 26.09,26.6 25.58,27.11 25.58,29.9 23.81,31.68 23.81,32.44 24.31,32.95 24.38,32.95 24.69,33.27 25.77,33.27 26.47,32.57 30.28,32.57 30.66,32.95 36.95,32.95 38.03,34.03 38.03,34.54 38.09,34.6 39.62,34.6 39.62,35.23 38.09,35.23 38.09,36.19 38.41,36.5 40.44,36.5
+19VB on BOTTOM: 17.99,71.78 21,71.78 21.29,71.49 21.29,62.77 20.01,61.48 17.96,61.48 17.28,62.17 17.28,69.6 17.72,70.04 17.72,71.52
+19VB_1.35V on BOTTOM (solid shape): 89.34,24.06 92.32,24.06 92.51,23.87 92.51,22.09 92.39,21.96 92.39,18.41 91.75,17.77 89.02,17.77 89.02,20.31 88.32,21.01 88.32,21.52 89.59,21.52 89.59,19.8 89.78,19.61 90.48,19.61 90.8,19.93 90.8,21.33 90.42,21.71 89.78,21.71 89.59,21.52 88.32,21.52 88.32,22.6 88.39,22.66 88.39,24.25 89.15,24.25
+19VB_+1VALWP on TOP (solid shape): 176.46,51.87 176.46,50.79 176.27,50.6 173.98,50.6 173.86,50.73 173.86,51.87 174.11,52.12 176.21,52.12
+19VB_+1VALWP on BOTTOM (solid shape): 178.94,51.87 178.94,50.66 178.87,50.6 172.71,50.6 172.46,50.35 171.82,50.35 171.63,50.54 171.63,53.52 171.96,53.85 176.96,53.85
+19VB_VGA on TOP (solid shape): 72.89,51.55 72.89,48 71.68,46.79 71.68,39.78 71.01,39.1 70.19,39.1 70.19,39.6 69.64,39.6 69.64,39.11 69.39,39.11 69.39,39.6 68.84,39.6 68.84,39.17 68.76,39.09 67.06,39.09 66.6,39.55 66.29,39.55 66.16,39.68 66.16,40.63 66.54,41.01 68.45,41.01 68.89,41.46 68.89,43.92 69.28,43.92 69.29,43.87 69.3,43.81 69.32,43.76 69.35,43.72 69.39,43.68 69.43,43.64 69.47,43.61 69.52,43.59 69.57,43.57 69.63,43.56 69.68,43.56 69.73,43.57 69.79,43.59 69.83,43.61 69.88,43.64 69.92,43.68 69.95,43.72 69.98,43.76 70,43.81 70.02,43.87 70.02,43.92 70.02,43.97 70.01,44.03 69.99,44.08 69.97,44.13 69.94,44.17 69.9,44.21 69.86,44.24 69.81,44.27 69.76,44.29 69.71,44.3 69.65,44.3 69.6,44.3 69.55,44.29 69.5,44.27 69.45,44.24 69.41,44.21 69.37,44.17 69.34,44.13 69.31,44.08 69.29,44.03 69.28,43.97 69.28,43.92 68.89,43.92 68.89,48.12 69.14,48.38 69.14,49.78 68.76,50.16 66.86,50.16 66.41,50.6 66.41,53.01 66.8,53.39 71.05,53.39
+19VB_VGA on BOTTOM (solid shape): 70.41,52.76 70.41,50.16 70.1,49.84 68.95,49.84 68.51,50.28 66.99,50.28 66.03,51.24 62.1,51.24 62.03,51.3 62.03,51.68 62.1,51.74 62.99,51.74 63.05,51.81 63.05,53.52 63.37,53.84 69.34,53.84
+19VB_VGA on BOTTOM (solid shape): 70.03,40.69 70.03,39.11 69.72,38.79 68.26,38.79 68.13,38.66 68.13,36.38 67.87,36.12 66.1,36.12 65.65,36.57 61.72,36.57 61.27,37.01 61.27,39.11 65.14,39.11 65.14,38.28 65.4,38.03 66.67,38.03 66.86,38.22 66.86,39.36 66.67,39.55 65.59,39.55 65.14,39.11 61.27,39.11 61.27,39.81 61.65,40.19 65.91,40.19 66.8,41.08 69.65,41.08
+VCC_CORE on TOP (solid shape): 133.72,86.22 133.72,85.91 133.53,85.72 130.55,85.72 130.42,85.84 130.42,86.16 130.74,86.48 130.74,86.8 130.8,86.86 133.09,86.86
+VCC_CORE on TOP (solid shape): outline of 320 points within 123.06,87.56 135.31,93.02
+VCC_CORE on TOP (solid shape): outline of 1538 points within 118.55,96.45 144.39,118.04
+VCC_CORE on BOTTOM (solid shape): outline of 250 points within 128.76,85.73 134.06,88.64
+VCC_CORE on BOTTOM (solid shape): outline of 2399 points within 118.61,96.38 144.84,118.9
+VCC_CORE on IN1 (solid shape): outline of 589 points within 122.93,87.49 133.98,92.96
+VCC_CORE on IN1 (solid shape): outline of 744 points within 118.29,112.58 144.77,117.72
+VCC_CORE on IN2 (solid shape): outline of 683 points within 118.1,112.26 143.12,117.72
+VCC_CORE on IN2 (solid shape): outline of 1420 points within 122.17,85.72 134.61,96.96
+VCC_CORE on IN3 (solid shape): 129.46,97.42 129.78,97.12 130.1,97.42 130.1,97.47 131.29,97.47 131.29,97.42 131.61,97.12 131.93,97.42 131.93,97.47 133.12,97.47 133.12,97.42 133.23,97.19 133.48,97.12 133.56,97.1 133.6,97.02 133.66,96.83 133.82,96.72 133.85,96.71 133.85,96.57 133.75,96.47 133.33,96.47 132.72,96.47 132.69,96.47 132.09,96.47 132.06,96.47 131.45,96.47 131.42,96.47 130.82,96.47 130.79,96.47 130.25,96.47 130.22,96.47 129.67,96.47 129.65,96.47 129.1,96.47 129.07,96.47 128.53,96.47 128.5,96.47 127.96,96.47 127.6,96.47 127.31,96.77 127.31,96.88 127.66,97.23 127.7,97.25 127.73,97.23 128.06,97.16 128.27,97.43 128.27,97.47 129.46,97.47
+VCC_CORE on VCC: 118.46,88.38 117.15,89.7 117.15,96.17 116.62,96.7 108.24,96.7 107.5,97.44 107.5,108.6 108.05,109.15 116.3,109.15 117.21,110.06 117.21,116.6 118.46,117.85 121.55,117.85 122.25,117.15 144.58,117.15 144.58,112.56 143.79,111.76 136.96,111.76 135.25,110.05 135.25,89.53 122,89.53 120.86,88.38
+VCC_GT on TOP (solid shape): outline of 5138 points within 92.58,85.21 129.98,104.26
+VCC_GT on BOTTOM (solid shape): outline of 1880 points within 92.83,88.57 127.25,103.38
+VCC_GT on IN1 (solid shape): 97.85,102.61 97.85,100.32 96.7,99.18 96.2,99.18 94.74,97.72 93.4,97.72 92.77,98.35 92.77,101.46 94.54,103.24 97.21,103.24
+VCC_GT on IN1 (solid shape): outline of 1872 points within 107.05,88.45 130.04,98.42
+VCC_GT on IN2 (solid shape): outline of 2341 points within 91.56,86.67 123.31,103.43
+VCC_GT on IN3 (solid shape): 97.97,102.23 97.97,100.51 95.05,97.59 93.08,97.59 92.39,98.29 92.39,101.4 94.42,103.43 96.77,103.43
+VCC_GT on IN3 (solid shape): outline of 653 points within 97.08,94.61 112.71,98.48
+VCC_GT on VCC: 93.95,91.05 93.15,91.85 93.15,102.63 93.57,103.05 106.99,103.05 106.99,97.23 108.03,96.19 116.41,96.19 116.64,95.96 116.64,91.05
+VCC_SA on TOP (solid shape): outline of 120 points within 135.44,87.3 139.06,100.38
+VCC_SA on BOTTOM (solid shape): 138.62,87.67 138.63,87.64 138.63,87.61 138.6,87.45 138.64,87.3 138.65,87.29 138.65,87.18 138.59,87.13 137.12,87.13 136.92,87.33 136.9,87.4 136.87,87.45 136.87,87.66 136.87,87.68 136.94,87.77 136.97,87.86 136.97,87.87 138.42,87.87
+VCC_SA on BOTTOM (solid shape): outline of 150 points within 134.61,96.26 139.06,99.15
+VCC_SA on BOTTOM (solid shape): outline of 279 points within 157.35,113.02 167.38,121.47
+VCC_SA on IN1 (solid shape): outline of 493 points within 134.3,86.48 139.31,99.21
+VCC_SA on IN2 (solid shape): outline of 394 points within 134.8,87.24 138.3,96.96
+VCC_SA on VCC: 135.76,109.84 137.17,111.26 144,111.26 145.09,112.34 145.09,117.36 145.58,117.85 165.37,117.85 166.43,116.79 166.43,111.43 153.88,111.43 151.69,109.25 151.69,105.89 145.6,99.79 145.6,98.46 144.92,97.78 140.73,97.78 138.99,96.05 138.99,91.37 137.15,89.53 135.76,89.53
+VDD_TOUCH on TOP (solid shape): 10.22,99.31 10.22,98.61 10.6,98.23 10.6,95.11 10.47,94.99 8.44,94.99 8.18,94.73 7.8,94.73 7.68,94.86 7.68,98.29 7.23,98.73 7.23,99.31 7.36,99.43 8.95,99.43 9.07,99.56 9.96,99.56
GND on TOP (solid shape): 147.25,117.53 147.25,116.2 145.85,116.2 145.85,117.53 145.98,117.66 147.12,117.66
GND on TOP (solid shape): 8.82,101.08 8.82,99.81 8.69,99.69 7.49,99.69 7.3,99.88 7.3,101.08 7.36,101.15 8.76,101.15
GND on TOP (solid shape): 11.94,88.27 11.94,87.31 11.34,86.71 10.19,86.71 10.13,86.77 10.13,88.25 10.21,88.33 11.87,88.33
GND on TOP (solid shape): 21.65,75.75 21.65,75.3 21.46,75.11 18.92,75.11 18.85,75.18 18.85,75.87 18.92,75.94 21.46,75.94
GND on TOP (solid shape): 44.32,51.49 44.32,47.04 44.06,46.79 41.78,46.79 41.52,47.04 41.52,51.17 42.03,51.68 44.13,51.68
GND on TOP (solid shape): 67.05,60.82 67.05,60 66.99,59.94 58.1,59.94 58.03,60 58.03,61.08 58.13,61.18 66.7,61.18
GND on TOP (solid shape): 76.45,43.62 76.45,42.09 76.32,41.96 74.8,41.96 74.61,42.16 74.61,43.68 74.73,43.81 76.26,43.81
GND on TOP (solid shape): 86.67,14.28 86.67,12.88 86.29,12.5 84.51,12.5 84.26,12.75 84.26,14.34 84.45,14.53 86.42,14.53
GND on TOP (solid shape): 176.78,87.18 176.78,86.54 176.59,86.35 173.48,86.35 173.28,86.54 173.28,87.75 174.24,88.7 175.25,88.7
GND on TOP (solid shape): 177.09,49.9 177.09,47.81 176.84,47.55 174.3,47.55 173.86,48 173.86,50.28 173.98,50.41 176.59,50.41
GND on TOP (solid shape): 131.76,116.2 131.76,114.74 130.74,113.72 128.14,113.72 128.07,113.78 128.07,116.58 131.37,116.58
GND on TOP (solid shape): 100.32,118.8 100.32,117.21 100.2,117.09 99.18,117.09 99.05,117.21 99.05,118.74 99.18,118.86 100.26,118.86
GND on TOP (solid shape): 161.85,50.47 161.85,45.01 161.41,44.57 160.9,44.57 160.65,44.82 160.65,46.35 161.09,46.79 161.09,50.47 161.16,50.54 161.79,50.54
GND on TOP (solid shape): 163.38,18.64 163.38,15.93 163.53,15.78 163.53,15.1 163.38,14.95 162.48,14.95 161.59,15.84 161.59,18.36 161.99,18.75 163.26,18.75
GND on TOP (solid shape): 189.75,69.32 189.75,64.85 189.49,64.59 188.88,64.59 188.78,64.68 188.78,65.84 188.5,66.12 188.5,69.22 188.71,69.43 189.65,69.43
GND on TOP (solid shape): 28.76,109.91 28.76,106.48 28.57,106.29 26.03,106.29 25.14,107.18 25.14,110.04 25.27,110.16 28.5,110.16
GND on TOP (solid shape): 74.8,81.91 74.8,80.89 74.53,80.63 71.69,80.63 71.56,80.76 71.56,81.33 71.62,81.4 71.62,81.92 71.74,82.04 74.66,82.04
GND on TOP (solid shape): 146.45,65.06 146.45,63.15 146.61,62.98 146.61,57.78 146.11,57.27 143.12,57.27 141.53,58.86 141.53,65.08 141.92,65.46 146.05,65.46
GND on TOP (solid shape): 45.65,62.28 45.65,61.19 45.48,61.03 43.83,61.03 43.62,61.24 43.62,62.41 45.52,62.41
GND on TOP (solid shape): 150.93,117.15 152.46,117.15 152.52,117.09 152.52,115.69 152.46,115.62 149.85,115.62 149.22,116.26 149.22,117.21 149.6,117.59 150.49,117.59
GND on TOP (solid shape): 182.81,41.9 182.81,39.87 182.56,39.62 180.84,39.62 180.21,40.25 176.46,40.25 176.14,39.93 175.25,39.93 175.13,40.06 175.13,42.09 175.44,42.41 182.3,42.41
GND on TOP (solid shape): 48.32,14.85 48.32,11.74 48.13,11.55 44.7,11.55 44.44,11.8 44.44,14.72 44.57,14.85 46.03,14.85 46.22,15.04 46.22,15.61 46.28,15.68 47.49,15.68
GND on TOP (solid shape): 74.13,76.14 74.13,75.01 74.73,74.41 74.73,74.19 74.03,73.49 73.26,73.49 72.71,74.04 72.71,76.09 72.92,76.3 73.97,76.3
GND on TOP (solid shape): 52.51,27.3 52.51,24.63 52.19,24.31 50.67,24.31 47.85,21.49 44.84,21.49 44.25,22.08 44.25,24.31 45.21,25.26 45.21,27.23 45.52,27.55 52.25,27.55
GND on TOP (solid shape): 77.4,102.23 77.4,96.89 77.15,96.64 76.13,96.64 76.07,96.7 76.07,98.99 75.69,99.37 75.69,99.88 75.91,100.1 75.91,100.99 76,101.08 76,101.78 76.57,102.35 77.27,102.35
GND on TOP (solid shape): 153.17,99.53 154.02,99.53 154.32,99.22 154.32,97.65 154.19,97.52 154.09,97.52 154.04,97.47 153.96,97.47 153.8,97.31 152.83,97.31 152.69,97.17 152.03,97.17 151.96,97.24 151.96,99.78 152.24,100.06 152.64,100.06
GND on TOP (solid shape): 92.83,108.64 92.83,107.56 93.02,107.37 93.02,106.93 92.77,106.67 92.07,106.67 91.88,106.86 91.88,107.81 91.56,108.13 91.24,108.13 91.18,108.2 91.18,108.7 91.24,108.77 92.7,108.77
GND on TOP (solid shape): 177.41,16.37 177.41,12.31 176.9,11.8 175.44,11.8 175.06,12.18 175.06,14.21 174.17,15.1 173.35,15.1 173.28,15.17 173.28,15.8 173.41,15.93 174.81,15.93 175.57,16.69 177.09,16.69
GND on TOP (solid shape): 91.56,115.62 91.56,113.15 92.32,112.39 92.32,111.56 92.26,111.5 88.7,111.5 88.26,111.05 87.24,111.05 87.18,111.12 87.18,114.48 86.99,114.67 86.35,114.67 85.97,115.05 85.97,115.62 86.1,115.75 91.43,115.75
GND on TOP (solid shape): 178.3,78.1 178.3,77.21 178.36,77.14 179.95,77.14 180.14,77.33 180.9,77.33 181.03,77.21 181.03,75.87 180.84,75.68 180.27,75.68 179.7,76.25 175.63,76.25 175.57,76.32 175.57,77.08 175.63,77.14 177.98,77.14 178.05,77.21 178.05,78.1 178.11,78.16 178.24,78.16
GND on TOP (solid shape): 56.72,65.45 56.72,64.75 56.82,64.65 57.19,64.65 57.28,64.56 57.28,64.28 57.11,64.12 57.11,63.45 57.05,63.39 55.76,63.39 55.7,63.45 55.7,64.06 55.97,64.33 55.97,65.4 56.07,65.5 56.67,65.5
GND on TOP (solid shape): 58.7,28.38 58.7,27.92 58.82,27.8 60.06,27.8 60.76,27.11 62.35,27.11 62.48,27.23 62.99,27.23 63.24,26.98 63.24,26.47 62.99,26.22 58.98,26.22 58.6,25.84 56.64,25.84 56.32,26.15 56.32,28.38 56.53,28.58 58.49,28.58
GND on TOP (solid shape): 61.97,75.05 62.54,75.05 62.54,74.54 61.27,74.54 61.08,74.35 61.08,73.65 61.33,73.4 62.48,73.4 62.6,73.27 62.6,72.7 61.33,72.7 61.21,72.83 59.49,72.83 59.37,72.95 59.37,73.59 59.87,74.1 59.87,74.86 60,74.98 60.76,74.98 61.21,75.43 61.59,75.43
GND on TOP (solid shape): 59.58,16.93 60.24,16.93 60.34,16.83 60.34,16.59 60.19,16.44 59.53,16.44 59.2,16.11 59.2,15.71 59.3,15.61 62.22,15.61 62.35,15.49 62.35,14.66 61.91,14.22 60.45,14.22 59.81,14.85 56.76,14.85 56.64,14.98 56.64,16.76 56.81,16.93 57.46,16.93 58.11,17.58 58.92,17.58
GND on TOP (solid shape): 90.99,65.33 90.99,58.35 90.93,58.28 87.94,58.28 87.81,58.41 87.81,58.92 88,59.11 89.97,59.11 90.1,59.24 90.1,61.65 89.97,61.78 89.21,61.78 89.15,61.84 89.15,61.97 89.21,62.03 89.97,62.03 90.1,62.16 90.1,63.43 90.29,63.62 90.29,65.27 90.48,65.46 90.86,65.46
GND on TOP (solid shape): 66.67,79.77 66.67,79.43 66.79,79.3 68.46,79.3 68.5,79.31 68.65,79.46 72.26,79.46 72.38,79.33 72.38,78.6 72.03,78.25 69.26,78.25 68.84,77.83 68.55,77.83 67.83,78.54 67.28,78.54 66.71,77.97 66.36,77.97 65.33,79.01 65.33,79.5 65.65,79.82 66.62,79.82
GND on TOP (solid shape): 110.61,118.42 110.61,117.09 110.13,116.61 107.59,116.61 107.05,116.07 107.05,113.02 106.48,112.45 103.88,112.45 103.63,112.7 103.63,113.66 104.01,114.04 104.01,115.62 103.63,116.01 103.63,118.61 103.94,118.93 110.1,118.93
GND on TOP (solid shape): 177.22,104.83 177.73,104.83 177.86,104.7 177.86,103.31 177.76,103.2 177.3,103.2 177.22,103.13 177.22,102.54 177.07,102.39 177.07,101.32 176.84,101.1 175.91,101.1 175.73,101.27 174.81,101.27 174.61,101.07 173.62,101.07 173.59,101.1 173.59,103.31 173.82,103.53 173.84,103.53 173.84,105.01 174.05,105.21 176.84,105.21
GND on TOP (solid shape): 110.23,92.45 109.91,92.45 109.78,92.32 109.78,91.94 109.66,91.81 109.4,91.81 109.28,91.94 109.28,92.26 109.09,92.45 108.64,92.45 108.45,92.26 108.45,91.88 108.39,91.81 108.07,91.81 107.97,91.91 107.97,92.29 107.82,92.45 106.1,92.45 105.97,92.32 105.97,91.94 105.85,91.81 105.66,91.81 105.53,91.94 105.53,93.02 105.59,93.08 110.23,93.08
GND on TOP (solid shape): 106.67,94.99 106.67,94.67 106.86,94.48 107.82,94.48 107.94,94.61 107.94,94.99 108.07,95.11 108.32,95.11 108.45,94.99 108.45,94.61 108.58,94.48 109.09,94.48 109.21,94.61 109.21,94.99 109.34,95.11 109.66,95.11 109.72,95.05 109.72,94.61 109.85,94.48 110.23,94.48 110.23,93.84 110.17,93.78 105.59,93.78 105.59,94.48 106.04,94.48 106.17,94.61 106.17,94.99 106.29,95.11 106.55,95.11
GND on TOP (solid shape): 68.89,49.58 68.89,48.51 68.64,48.25 68.64,45.33 68.38,45.08 65.97,45.08 65.72,44.82 65.72,43.68 65.97,43.43 66.8,43.43 67.37,42.85 68.38,42.85 68.51,42.73 68.51,41.52 68.26,41.27 63.75,41.27 62.99,42.03 62.99,43.93 62.48,44.44 61.33,44.44 61.08,44.7 61.08,46.03 61.4,46.35 61.59,46.35 63.11,47.87 63.11,49.78 63.18,49.84 68.64,49.84
GND on TOP (solid shape): 139.47,96.61 139.52,96.53 139.6,96.47 139.69,96.38 139.69,95.94 139.44,95.69 139.44,95.5 140.2,94.73 140.58,94.73 140.77,94.92 140.77,95.11 140.9,95.24 141.15,95.24 141.28,95.11 141.28,94.86 140.71,94.29 140.71,93.33 140.56,93.17 140.24,93.17 139.95,93.46 139.5,93.46 139.38,93.34 138.11,93.34 137.98,93.46 137.98,94.67 138.55,95.24 138.55,96.89 138.61,96.96 139.12,96.96
GND on TOP (solid shape): 136.33,96 136.39,95.94 136.9,95.94 136.94,95.9 136.94,95.53 136.84,95.43 136.39,95.43 136.33,95.37 136.33,94.73 136.39,94.67 136.52,94.67 136.54,94.64 136.8,94.64 136.94,94.51 136.94,94.26 136.84,94.16 136.45,94.16 136.33,94.03 136.33,93.4 136.39,93.34 136.77,93.34 136.9,93.21 136.9,93.08 136.77,92.96 136.52,92.96 136.33,92.76 136.33,92.38 135.69,92.38 135.69,93.08 135.5,93.27 131.82,93.27 131.5,93.59 131.5,96 131.82,96.32 135.5,96.32 135.69,96.51 135.69,97.08 136.33,97.08
GND on TOP (solid shape): 197.41,19.99 197.41,18.98 197.67,18.72 198.3,18.72 198.43,18.6 198.43,18.4 198.43,18.4 198.43,15.62 198.43,15.55 198.3,15.42 197.98,15.42 197.95,15.44 197.94,15.45 197.77,15.66 197.52,15.73 197.48,15.73 196.78,16.44 196.78,16.95 196.53,17.2 194.42,17.2 194.38,17.21 194.37,17.25 194.37,17.96 194.62,18.22 194.62,19.99 194.75,20.12 197.29,20.12
GND on TOP (solid shape): 211.1,58.24 211.63,58.02 211.84,57.5 211.84,54.8 211.63,54.27 211.1,54.05 201.67,54.05 201.49,54.03 201.32,53.97 200.27,53.97 200.27,58.24
GND on TOP (solid shape): 70.2,76.2 70.2,71.53 69.84,71.17 69.84,70.22 69.54,69.92 66.16,69.92 66.16,69.9 65.84,69.59 65.84,68.63 66.54,67.94 66.54,65.46 66.03,64.95 64.45,64.95 64.32,65.08 64.32,66.92 64.45,67.05 65.59,67.05 65.78,67.24 65.78,67.87 65.53,68.13 65.21,68.13 65.08,68.25 65.08,69.71 64.88,69.92 62.43,69.92 61.25,71.09 60.59,71.09 60.51,71.17 60.51,71.68 60.57,71.75 61.38,71.75 62.27,70.86 62.82,70.86 63.36,71.39 63.67,71.39 64.25,70.81 64.84,70.81 65.44,71.41 65.71,71.41 66.35,70.77 66.89,70.77 67.13,71.01 67.13,71.37 67.3,71.54 67.56,71.54 68.26,70.84 68.76,70.84 69.02,71.11 69.02,71.43 69.41,71.82 69.41,76.15 69.6,76.34 70.05,76.34
GND on TOP (solid shape): 31.79,119.03 31.79,118.59 31.81,116.51 31.78,116.11 31.74,115.87 31.65,115.65 31.09,115.04 30.28,114.81 28.02,114.81 27.81,114.8 27.59,114.81 25.28,114.81 24.29,115.19 23.81,116.13 23.8,118.76 23.81,119.02 23.83,119.28 23.81,122.48 31.81,122.48
GND on TOP (solid shape): 119.69,95.5 120.45,95.5 120.58,95.37 120.58,94.92 120.71,94.8 121.09,94.8 121.21,94.67 121.21,94.48 121.09,94.35 119.94,94.35 119.82,94.23 119.82,92.96 119.88,92.89 120.58,92.89 120.58,92.38 120.71,92.26 121.09,92.26 121.15,92.19 121.15,91.94 121.09,91.88 119.94,91.88 119.82,91.75 119.82,91.49 119.75,91.43 118.17,91.43 118.04,91.56 118.04,92.7 118.23,92.89 118.48,92.89 118.61,92.76 118.61,92.38 118.74,92.26 119.06,92.26 119.18,92.38 119.18,92.45 119.19,92.46 119.25,92.62 119.21,92.78 119.21,92.79 119.21,93.13 119.18,93.16 119.18,94.8 119.12,94.86 118.74,94.86 118.67,94.92 118.67,95.43 118.61,95.5 118.17,95.5 118.17,96.13 119.06,96.13
GND on TOP (solid shape): 141.98,92.7 141.98,92.45 141.6,92.07 141.6,91.62 141.47,91.49 141.15,91.49 140.71,91.05 140.71,90.67 141.28,90.1 141.28,89.84 141.03,89.59 140.14,89.59 139.95,89.4 139.95,88.26 140.07,88.13 140.71,88.13 140.84,88.26 140.84,88.51 140.9,88.57 141.22,88.57 141.28,88.51 141.28,88.26 141.41,88.13 141.92,88.13 141.98,88.07 141.98,87.43 141.92,87.37 141.47,87.37 141.41,87.43 141.41,87.75 141.28,87.88 140.9,87.88 140.71,87.68 140.71,87.37 140.65,87.3 140.01,87.3 139.5,86.8 139.5,86.48 139.44,86.41 139.12,86.41 139.06,86.48 139.06,87.05 139.31,87.3 139.31,87.56 139.06,87.81 138.99,87.81 138.93,87.88 138.93,89.27 138.61,89.59 136.45,89.59 136.39,89.65 136.39,90.73 136.58,90.92 139.82,90.92 140.01,91.11 140.01,91.94 140.07,92 140.84,92 141.03,92.19 141.15,92.19 141.53,92.57 141.53,92.7 141.66,92.83 141.85,92.83
GND on TOP (solid shape): 88.42,104.61 92.1,104.61 92.26,104.45 92.26,103.43 92.16,103.33 90.79,103.33 90.7,103.24 84.51,103.24 84.26,102.99 83.88,102.99 83.75,103.12 83.75,104.83 83.81,104.89 83.81,105.11 85.52,105.11 85.52,105.06 85.53,105 85.55,104.95 85.57,104.9 85.6,104.85 85.64,104.81 85.68,104.77 85.72,104.74 85.77,104.72 85.83,104.71 85.88,104.7 85.94,104.7 85.99,104.71 86.04,104.72 86.09,104.74 86.14,104.77 86.18,104.81 86.22,104.85 86.25,104.9 86.27,104.95 86.29,105 86.29,105.06 86.29,105.11 86.29,105.17 86.27,105.22 86.25,105.27 86.22,105.32 86.18,105.36 86.14,105.39 86.09,105.42 86.04,105.45 85.99,105.46 85.94,105.47 85.88,105.47 85.83,105.46 85.77,105.45 85.72,105.42 85.68,105.39 85.64,105.36 85.6,105.32 85.57,105.27 85.55,105.22 85.53,105.17 85.52,105.11 83.81,105.11 83.81,106.48 83.88,106.54 86.48,106.54
GND on TOP (solid shape): 202.37,99.24 202.5,98.59 203.1,98.29 212.15,98.29 212.15,93.95 211.93,93.42 211.4,93.2 204.55,93.2 203.81,92.58 204.29,91.74 204.29,90.99 203.19,90.99 202.69,91.49 201.35,91.49 200.72,92.13 200.72,99.24
GND on TOP (solid shape): 122.71,93.55 122.71,93.17 122.87,93.02 123.44,93.02 123.48,93.06 124.1,93.06 124.14,93.02 124.52,93.02 124.52,92.38 123.75,92.38 123.56,92.19 123.56,91.62 123.44,91.49 123.12,91.49 122.93,91.3 122.93,90.92 123.12,90.73 123.44,90.73 123.56,90.61 123.56,90.35 123.44,90.22 123.06,90.22 122.93,90.1 122.93,89.65 123.12,89.46 123.44,89.46 123.56,89.34 123.56,88.95 123.69,88.83 123.69,88.19 123.95,87.94 124.71,87.94 125.32,88.55 125.69,88.55 125.69,88.6 125.72,88.64 125.72,88.95 125.85,89.08 126.23,89.08 126.36,89.21 126.36,89.65 126.99,89.65 126.99,88.76 126.55,88.32 126.55,87.62 126.49,87.56 125.79,87.56 125.75,87.52 125.69,87.52 125.37,87.2 120.54,87.2 120.44,87.3 120.44,90.26 120.71,90.53 120.71,90.99 120.81,91.09 121.12,91.09 121.15,91.11 121.21,91.11 121.34,91.24 121.34,91.56 121.91,91.56 122.29,91.94 122.29,92 122.32,92.03 122.32,93.55 122.39,93.63 122.64,93.63
GND on TOP (solid shape): 201.13,41.55 201.19,41.52 201.22,41.46 201.22,41.4 201.18,41.37 200.96,40.54 201.67,40.04 203.96,40.04 203.96,40.04 211.1,40.04 211.63,39.82 211.84,39.3 211.84,38.66 200.68,38.66 200.3,38.28 200.02,38.28 197.4,35.67 195.88,35.67 195.31,35.09 188.86,35.09 188.73,35.22 188.73,36.07 189.51,36.85 194.2,36.85 195.45,38.09 198.74,38.09 199.83,39.18 199.83,41.33 200.08,41.58 201.1,41.58
GND on TOP (solid shape): 97.58,4.25 101.38,6.98 104.5,3.5 103.86,1.49 102.19,0.21 102.04,0.21 102.03,0.2 100.5,0.2 99.99,0.25 99.5,0.39 98.56,1.06 97.89,2 97.75,2.49 97.7,3 97.7,3.5 97.68,3.83 97.61,4.15 97.61,4.15
GND on TOP (solid shape): 187.7,47.81 187.7,46.98 188.21,46.47 188.21,43.92 188.16,43.84 188.07,43.83 187.64,43.71 187.66,43.27 187.68,43.21 187.66,43.14 187.64,42.7 188.07,42.58 188.16,42.58 188.21,42.49 188.21,40.88 188.02,40.69 186.56,40.69 186.49,40.76 186.49,40.95 185.86,41.58 185.86,45.33 185.87,45.36 185.91,45.38 186.25,45.73 185.91,46.09 185.87,46.1 185.86,46.14 185.86,46.71 185.89,46.72 186.09,47.04 185.89,47.36 185.86,47.38 185.86,47.52 185.94,47.52 185.95,47.49 186.45,47.34 186.57,47.84 186.57,47.94 186.66,48 187.51,48
GND on TOP (solid shape): outline of 145 points within 130.61,86.73 134.74,90.86
GND on TOP (solid shape): outline of 256 points within 200.39,70.68 214.15,79.81
GND on TOP (solid shape): outline of 383 points within 36.19,113.18 82.29,122.55
GND on TOP (solid shape): outline of 118 points within 12.05,0.25 214.15,20.86
GND on TOP (solid shape): outline of 1001 points within 101.34,110.04 180.4,122.55
GND on TOP (solid shape): outline of 1205 points within 0.25,30.77 212.15,122.6
GND on BOTTOM (solid shape): 147.25,117.53 147.25,116.2 145.85,116.2 145.85,117.53 145.98,117.66 147.12,117.66
GND on BOTTOM (solid shape): 29.52,43.17 29.52,42.03 29.39,41.9 27.55,41.9 27.43,42.03 27.43,43.17 27.55,43.3 29.39,43.3
GND on BOTTOM (solid shape): 35.93,19.3 35.93,18.09 35.81,17.96 27.23,17.96 27.17,18.03 27.17,19.3 27.36,19.49 35.74,19.49
GND on BOTTOM (solid shape): 44.32,51.59 44.32,43.46 44,43.14 42.09,43.14 41.78,43.46 41.78,51.52 42.09,51.84 44.06,51.84
GND on BOTTOM (solid shape): 67.81,18.41 67.81,17.58 67.62,17.39 66.54,17.39 66.41,17.52 66.41,18.41 66.54,18.53 67.68,18.53
GND on BOTTOM (solid shape): 75.94,9.77 75.94,8.56 75.88,8.5 74.48,8.5 74.42,8.56 74.42,9.77 74.54,9.9 75.81,9.9
GND on BOTTOM (solid shape): 87.31,11.36 87.31,11.17 87.18,11.04 86.35,11.04 85.97,11.42 85.97,12.37 86.04,12.44 86.23,12.44
GND on BOTTOM (solid shape): 100.32,118.93 100.32,117.21 100.13,117.02 99.12,117.02 98.93,117.21 98.93,118.86 99.12,119.05 100.2,119.05
GND on BOTTOM (solid shape): 192.21,53.27 192.21,51.74 191.83,51.36 187.51,51.36 187.19,51.68 187.19,53.46 187.45,53.71 191.76,53.71
GND on BOTTOM (solid shape): 69.21,73.85 69.21,73.6 69.09,73.48 68.86,73.48 63.72,78.62 63.72,78.9 63.84,79.02 64.04,79.02
GND on BOTTOM (solid shape): 80.83,25.26 80.83,24.5 80.19,23.87 79.56,23.87 79.37,24.06 79.37,25.9 80.19,25.9
GND on BOTTOM (solid shape): 94.04,20.76 94.04,19.1 93.78,18.85 92.64,18.85 92.58,18.91 92.58,20.95 92.96,21.33 93.47,21.33
GND on BOTTOM (solid shape): 96.7,19.36 96.64,19.3 94.93,19.3 94.54,19.68 94.54,26.15 94.67,26.28 96.7,26.28
GND on BOTTOM (solid shape): 45.65,62.28 45.65,61.16 45.51,61.02 43.99,61.02 43.81,61.2 43.81,62.35 43.87,62.41 45.52,62.41
GND on BOTTOM (solid shape): 62.29,70.79 62.29,70.59 62.13,70.42 61.91,70.42 60.83,71.51 60.79,71.55 60.79,71.87 60.91,71.99 61.1,71.99
GND on BOTTOM (solid shape): 81.84,32.19 81.84,30.15 81.72,30.03 80.64,30.03 80.45,29.84 79.56,29.84 79.43,29.96 79.43,31.93 79.75,32.25 81.78,32.25
GND on BOTTOM (solid shape): 85.4,12.37 85.4,10.41 85.27,10.28 85.08,10.28 84.89,10.47 84.89,11.17 85.15,11.42 85.15,12.37 85.21,12.44 85.34,12.44
GND on BOTTOM (solid shape): 92.58,108.7 92.58,107.75 93.02,107.31 93.02,106.86 92.77,106.61 92,106.61 91.81,106.8 91.81,108.77 91.88,108.83 92.45,108.83
GND on BOTTOM (solid shape): 148.39,115.18 148.39,113.59 147.44,113.59 147.44,114.8 147.19,115.05 146.49,115.05 146.42,115.12 146.42,115.24 146.49,115.31 148.27,115.31
GND on BOTTOM (solid shape): 64.28,70.82 64.28,70.58 64.08,70.38 63.9,70.38 60.71,73.57 60.21,73.57 60.15,73.63 60.15,74.08 60.29,74.22 60.87,74.22
GND on BOTTOM (solid shape): 70.03,118.36 70.03,116.07 69.78,115.82 64.7,115.82 63.98,116.54 63.98,118.57 64.33,118.93 69.46,118.93
GND on BOTTOM (solid shape): 131.76,116.26 131.76,114.61 130.74,113.59 128.26,113.59 128.07,113.78 128.07,116.58 131.44,116.58
GND on BOTTOM (solid shape): 61.65,10.47 61.65,7.87 61.33,7.55 60.83,7.55 60.45,7.93 60.45,9.01 59.81,9.64 59.81,10.53 59.87,10.6 61.52,10.6
GND on BOTTOM (solid shape): 66.25,70.75 66.25,70.51 65.65,69.91 65.3,69.91 65.13,70.08 65.13,70.25 65.5,70.62 65.5,70.77 60.71,75.57 60.71,75.85 60.83,75.97 61.03,75.97
GND on BOTTOM (solid shape): 68.19,30.73 68.19,29.84 68.07,29.71 66.86,29.71 66.73,29.58 66.73,28.44 66.54,28.25 65.59,28.25 65.27,28.57 65.27,30.73 65.4,30.85 68.07,30.85
GND on BOTTOM (solid shape): 78.16,18.11 78.16,16.43 78.05,16.31 72.95,16.31 72.64,16.63 71.24,16.63 71.05,16.82 71.05,18.03 71.18,18.15 78.12,18.15
GND on BOTTOM (solid shape): 78.73,29.71 78.73,28.36 78.53,28.16 74.02,28.16 73.84,28.34 73.84,28.63 73.65,28.82 72.13,28.82 71.94,29.01 71.94,30.22 72.13,30.41 78.03,30.41
GND on BOTTOM (solid shape): 152.52,117.09 152.52,115.74 152.4,115.62 149.86,115.62 148.9,116.58 148.9,117.05 149.03,117.18 152.43,117.18
GND on BOTTOM (solid shape): 171.63,108.45 171.63,108.07 172.21,107.5 172.21,106.73 172.01,106.54 170.24,106.54 169.92,106.86 169.92,108.39 170.05,108.51 171.57,108.51
GND on BOTTOM (solid shape): 65.86,79.41 65.86,79.27 69.21,75.91 69.21,75.6 69.04,75.43 68.88,75.43 65.29,79.02 65.29,79.43 65.43,79.56 65.7,79.56
GND on BOTTOM (solid shape): 86.42,9.77 86.42,7.17 86.23,6.98 84.64,6.98 84.26,7.36 84.26,8.44 84.83,9.01 84.83,10.09 84.89,10.15 86.04,10.15
GND on BOTTOM (solid shape): 62.71,79.13 62.71,78.91 62.63,78.83 62.63,78.46 69.21,71.88 69.21,71.6 69.08,71.47 68.9,71.47 61.72,78.65 61.72,78.92 62.03,79.23 62.61,79.23
GND on BOTTOM (solid shape): 86.29,16.76 86.29,15.93 86.04,15.68 85.97,15.68 85.85,15.55 85.85,14.72 85.78,14.66 85.65,14.66 85.59,14.72 85.59,15.68 85.78,15.87 85.78,16.76 85.91,16.88 86.16,16.88
GND on BOTTOM (solid shape): 179.38,48.44 179.13,48.44 179.13,49.78 177.41,49.78 177.41,48.44 176.59,47.62 173.73,47.62 173.54,47.81 173.54,48.95 172.97,49.52 172.97,50.16 173.16,50.35 179.38,50.35
GND on BOTTOM (solid shape): 69.02,79.37 69.02,79.12 68.92,79.02 68.87,79 68.83,78.98 68.61,78.98 68.52,78.9 68.52,78.57 69.21,77.89 69.21,77.56 69.11,77.46 68.89,77.46 67.81,78.54 67.77,78.58 67.77,78.94 68.29,79.46 68.93,79.46
GND on BOTTOM (solid shape): 77.24,102.83 77.24,96.8 77.08,96.64 76.19,96.64 76.07,96.77 76.07,99.05 76,99.11 75.72,99.39 75.72,99.8 75.93,100.01 75.93,101.08 76,101.15 76,101.44 76,103.5 76.13,103.62 76.45,103.62
GND on BOTTOM (solid shape): 68.25,70.82 68.25,70.58 68.07,70.41 67.93,70.41 61.38,76.96 61.37,76.96 61.18,77.16 60.95,77.16 60.57,76.78 60.41,76.78 60.25,76.94 60.25,77.27 60.91,77.93 61.13,77.93
GND on BOTTOM (solid shape): 88.82,28.26 88.82,26.81 88.37,26.35 85.93,26.35 85.92,26.36 85.39,26.36 84.51,27.23 84.51,28.06 84.64,28.19 85.02,28.19 85.15,28.06 85.15,27.42 85.53,27.04 86.69,27.04 87.35,27.7 87.35,28.03 87.45,28.13 87.89,28.13 88.18,28.41 88.67,28.41
GND on BOTTOM (solid shape): 52.57,27.3 52.57,22.91 51,21.34 43.64,21.34 43.55,21.43 43.55,22.29 43.61,22.34 44.19,22.34 44.32,22.47 44.32,23.8 44.51,23.99 46.54,23.99 46.98,24.44 46.98,27.36 47.17,27.55 52.32,27.55
GND on BOTTOM (solid shape): 60.25,28.19 60.25,27.42 60.51,27.17 61.91,27.17 62.29,27.55 63.56,27.55 63.94,27.17 64.89,27.17 64.95,27.11 64.95,26.92 64.89,26.85 63.87,26.85 63.43,26.41 60.95,26.41 60.89,26.34 58.92,26.34 58.48,25.9 56.7,25.9 56.38,26.22 56.38,28.38 56.66,28.66 59.78,28.66
GND on BOTTOM (solid shape): 88.07,24.18 88.07,21.26 87.81,21.01 86.42,21.01 86.23,20.82 86.23,20.12 86.73,19.61 87.37,19.61 87.5,19.49 87.5,17.64 87.12,17.26 85.85,17.26 85.65,17.45 85.65,18.66 85.46,18.85 84.58,18.85 84.45,18.98 84.45,19.87 84.61,20.03 85.15,20.03 85.53,20.41 85.53,21.77 87.12,23.36 87.12,23.87 87.5,24.25 88,24.25
GND on BOTTOM (solid shape): 21.2,22.98 21.2,19.17 21.14,19.1 21.39,18.85 22.35,18.85 22.98,19.49 25.71,19.49 25.9,19.3 25.9,17.01 25.71,16.82 24.82,16.82 23.87,17.77 20.31,17.77 20.12,17.96 20.07,18.29 19.74,18.34 19.61,18.47 19.61,23.04 19.74,23.17 21.01,23.17
GND on BOTTOM (solid shape): 60.31,16.77 60.31,16.51 60.21,16.42 59.5,16.42 59.23,16.15 59.23,15.81 59.62,15.42 61.08,15.42 61.46,15.8 62.54,15.8 62.92,15.42 64.07,15.42 64.11,15.38 64.11,15.13 64.08,15.1 62.92,15.1 62.48,14.66 59.37,14.66 59.24,14.79 57.78,14.79 57.52,14.53 56.89,14.53 56.7,14.72 56.7,16.88 56.83,17.01 57.59,17.01 58.16,17.58 59.49,17.58
GND on BOTTOM (solid shape): 110.61,118.61 110.61,117.59 109.59,116.58 106.23,116.58 106.04,116.39 106.04,113.66 106.55,113.66 106.61,113.59 106.61,111.94 106.42,111.75 104.58,111.75 103.69,112.64 103.69,113.66 103.75,113.72 104.01,113.72 104.07,113.66 104.07,113.02 104.26,112.83 105.28,112.83 105.4,112.96 105.4,113.72 105.15,113.97 104.32,113.97 104.2,114.1 104.2,116.96 103.69,117.47 103.69,118.93 103.82,119.05 110.17,119.05
GND on BOTTOM (solid shape): 70.48,49.52 70.48,48.25 69.84,47.62 69.84,46.47 69.08,45.71 69.08,44.06 68.89,43.87 67.43,43.87 67.11,43.55 67.11,43.11 67.37,42.85 68.89,42.85 69.59,42.16 69.97,42.16 70.03,42.09 70.03,41.27 66.48,41.27 66.1,41.65 66.1,43.04 66.8,43.74 66.8,44.95 66.67,45.08 65.33,45.08 65.02,44.76 65.02,44.06 64.83,43.87 61.33,43.87 61.08,44.12 61.08,46.09 61.27,46.28 62.35,46.28 62.99,46.92 62.99,47.3 63.24,47.55 66.03,47.55 66.41,47.93 66.41,49.39 66.67,49.65 70.35,49.65
GND on BOTTOM (solid shape): 107.3,122.55 107.47,122.47 107.77,121.77 108.3,121.55 108.32,121.55 108.32,121.02 96.89,121.02 95.54,122.37 95.52,122.48 95.62,122.55
GND on BOTTOM (solid shape): 147.06,38.57 147.27,38.35 148.23,38.35 148.41,38.53 148.41,38.65 148.43,38.67 148.43,40.28 150.04,40.28 150.04,38.41 150.25,38.2 151.09,38.2 151.43,38.54 151.43,40.28 151.83,40.28 151.83,38.41 152.01,38.23 152.99,38.23 153.24,38.48 153.24,40.28 153.63,40.28 153.63,38.31 153.72,38.21 154.77,38.21 155.06,38.51 155.06,40.28 155.45,40.28 155.45,38.49 155.6,38.34 156.63,38.34 156.85,38.55 156.85,40.28 157.25,40.28 157.25,37.74 156.65,37.14 147.43,37.14 147.05,37.52 147.05,38.07 146.63,38.49 146.63,40.28 147.06,40.28
GND on BOTTOM (solid shape): 211.1,58.24 211.63,58.02 211.84,57.5 211.84,54.8 211.63,54.27 211.1,54.05 201.67,54.05 201.49,54.03 201.32,53.97 200.27,53.97 200.27,57.8 200.72,58.24
GND on BOTTOM (solid shape): 85.53,104.7 86.16,104.7 86.29,104.83 86.29,105.34 86.48,105.53 86.86,105.53 86.99,105.4 87.75,105.4 88.89,104.26 90.8,104.26 90.99,104.07 90.99,103.43 90.73,103.18 86.29,103.18 85.85,102.73 85.85,99.62 85.91,99.56 86.29,99.56 86.42,99.43 86.42,97.72 86.23,97.53 83.88,97.53 83.81,97.59 83.81,98.61 83.5,98.92 83.5,99.56 83.56,99.62 83.75,99.62 84.58,98.8 84.96,98.8 85.21,99.05 85.21,99.69 85.02,99.88 84.13,99.88 84,100 84,102.99 83.75,103.24 83.75,105.46 83.94,105.66 84.58,105.66
GND on BOTTOM (solid shape): 104.07,92.45 103.63,92.45 103.5,92.32 103.5,91.94 103.37,91.81 103.12,91.81 103.05,91.88 103.05,92.32 102.93,92.45 102.42,92.45 102.29,92.32 102.29,91.94 102.16,91.81 101.91,91.81 101.85,91.88 101.85,92.32 101.72,92.45 101.21,92.45 101.09,92.32 101.09,91.94 100.96,91.81 100.7,91.81 100.64,91.88 100.64,92.26 100.45,92.45 100.01,92.45 99.88,92.32 99.88,91.94 99.75,91.81 99.5,91.81 99.43,91.88 99.43,92.26 99.24,92.45 97.59,92.45 97.47,92.32 97.47,91.94 97.34,91.81 97.08,91.81 97.02,91.88 97.02,92.26 96.83,92.45 96.32,92.45 96.2,92.32 96.2,91.94 96.07,91.81 95.88,91.81 95.75,91.94 95.75,92.96 95.88,93.08 104.07,93.08
GND on BOTTOM (solid shape): 83.82,122.55 83.92,122.48 83.89,122.37 82.54,121.02 71.68,121.02 70.48,119.82 70.48,112.2 68.83,110.54 54.98,110.54 51.81,113.72 51.81,118.61 50.29,120.13 50.29,120.55 53.8,120.55 54.69,120.91 55.27,122.33 55.8,122.55
GND on BOTTOM (solid shape): 202.37,99.24 202.5,98.59 203.1,98.29 212.15,98.29 212.15,93.95 211.93,93.42 211.4,93.2 204.55,93.2 203.81,92.58 204.29,91.74 204.29,90.99 203.19,90.99 202.69,91.49 201.35,91.49 200.72,92.13 200.72,99.24
GND on BOTTOM (solid shape): 136.83,38.52 137.07,38.28 138.1,38.28 138.26,38.45 138.26,40.18 138.36,40.28 139.83,40.28 139.83,38.27 139.98,38.13 140.88,38.13 141.26,38.51 141.26,40.28 141.64,40.28 141.64,38.34 141.8,38.18 142.78,38.18 143.06,38.46 143.06,40.28 143.45,40.28 143.45,38.32 143.63,38.14 144.4,38.14 144.83,38.57 144.83,40.28 145.22,40.28 145.22,37.4 144.96,37.14 136.6,37.14 136.31,37.43 136.31,37.72 136.41,37.82 136.41,38.03 138.7,38.03 138.71,37.97 138.72,37.92 138.74,37.87 138.76,37.83 138.8,37.79 138.84,37.75 138.88,37.72 138.93,37.7 138.98,37.68 139.03,37.67 139.09,37.67 139.14,37.68 139.19,37.7 139.24,37.72 139.28,37.75 139.32,37.79 139.35,37.83 139.38,37.87 139.4,37.92 139.41,37.97 139.42,38.03 139.41,38.08 139.4,38.13 139.38,38.18 139.35,38.23 139.32,38.27 139.28,38.31 139.24,38.34 139.19,38.36 139.14,38.38 139.09,38.38 139.03,38.38 138.98,38.38 138.93,38.36 138.88,38.34 138.84,38.31 138.8,38.27 138.76,38.23 138.74,38.18 138.72,38.13 138.71,38.08 138.7,38.03 136.41,38.03 136.41,40.22 136.46,40.28 136.83,40.28
GND on BOTTOM (solid shape): outline of 98 points within 136.07,45.69 158.77,50.98
GND on BOTTOM (solid shape): outline of 98 points within 148.56,31.69 170.68,37.06
GND on BOTTOM (solid shape): 199.76,122.58 202.13,116.43 195.65,115.25 195.65,115.31 195.59,115.31 195.6,115.4 195.6,115.5 195.6,119.8 196.42,121.78 198.4,122.6 199.76,122.6
GND on BOTTOM (solid shape): 201.12,41.55 201.21,41.48 200.96,40.54 201.67,40.04 211.1,40.04 211.52,39.91 211.79,39.57 211.83,39.44 211.85,39.3 211.85,37.89 210.27,37.89 210.26,37.89 201.35,37.89 200.02,36.55 200.02,35.04 200.45,34.61 200.45,29.65 200.09,29.29 200.09,25.83 199.88,25.61 198.63,25.61 197.87,26.37 197.87,27.94 197.8,28.01 196.81,28.01 196.58,28.24 196.58,29.51 196.88,29.81 197.48,29.81 197.7,30.04 197.7,31.76 197.55,31.91 196.68,31.91 196.58,32.02 196.58,32.82 196.7,32.95 198.47,32.95 198.77,33.25 198.77,33.76 198.44,34.09 197.72,34.09 197.72,34.14 197.36,34.46 197.01,34.14 197,34.09 195.04,34.09 194.6,34.54 189.88,34.54 188.15,36.27 188.15,38.41 188.65,38.92 191.58,38.92 192.09,38.41 192.09,36.89 192.6,36.38 195.71,36.38 196.17,35.92 197.43,35.92 197.73,36.22 197.73,37.04 199.84,39.15 199.84,39.67 200.15,39.98 200.15,41.39 200.31,41.55
GND on BOTTOM (solid shape): 101.38,6.98 104.5,3.5 103.86,1.49 102.19,0.21 102.04,0.21 102.03,0.2 100.5,0.2 99.99,0.25 99.5,0.39 98.56,1.06 97.89,2 97.75,2.49 97.7,3 97.7,3.5 97.68,3.83 97.61,4.15 97.59,4.2 97.58,4.25
GND on BOTTOM (solid shape): outline of 184 points within 17.96,77.21 24.82,84.7
GND on BOTTOM (solid shape): outline of 247 points within 10.65,113.93 38.92,122.55
GND on BOTTOM (solid shape): outline of 247 points within 166.97,114.86 178.15,122.55
GND on BOTTOM (solid shape): outline of 256 points within 200.39,70.68 214.15,79.81
GND on BOTTOM (solid shape): outline of 100 points within 96.51,46.98 117.6,51.55
GND on BOTTOM (solid shape): outline of 100 points within 108.83,33.96 130.3,37.39
GND on BOTTOM (solid shape): outline of 125 points within 95.56,37.65 118.17,41.2
GND on BOTTOM (solid shape): outline of 118 points within 12.05,0.25 214.15,20.86
GND on BOTTOM (solid shape): outline of 232 points within 108.01,24.5 130.3,28.25
GND on BOTTOM (solid shape): outline of 730 points within 148.72,24.18 170.89,27.59
GND on BOTTOM (solid shape): outline of 980 points within 57.33,59.74 63.51,68.33
GND on BOTTOM (solid shape): outline of 1152 points within 0.25,30.77 212.15,122.55
GND on BOTTOM (solid shape): outline of 3784 points within 70.59,63.76 76.89,82.48
GND on IN1 (solid shape): 44.82,51.43 44.82,47.24 44.25,46.66 41.97,46.66 41.71,46.92 41.71,51.68 41.9,51.87 44.38,51.87
GND on IN1 (solid shape): 85.78,104.7 86.16,104.7 86.23,104.77 88.32,104.77 88.83,104.26 90.73,104.26 90.99,104 90.99,103.37 90.86,103.24 87.12,103.24 86.42,102.54 86.42,98.42 86.29,98.29 84.07,98.29 83.75,98.61 83.75,104.64 83.88,104.77 85.72,104.77
GND on IN1 (solid shape): 68.7,49.39 68.7,45.27 68.51,45.08 65.97,45.08 65.65,44.76 65.65,43.81 66.03,43.43 66.73,43.43 67.3,42.85 68.32,42.85 68.51,42.66 68.51,41.52 68.26,41.27 63.75,41.27 62.99,42.03 62.99,43.93 62.48,44.44 61.4,44.44 61.02,44.82 61.02,45.97 61.33,46.28 61.52,46.28 65.08,49.84 68.26,49.84
GND on IN1 (solid shape): 211.1,58.24 211.63,58.02 211.84,57.5 211.84,54.8 211.63,54.27 211.1,54.05 201.67,54.05 201.49,54.03 201.32,53.97 200.27,53.97 200.27,58.24
GND on IN1 (solid shape): 31.79,119.03 31.79,118.59 31.81,116.51 31.78,116.11 31.74,115.87 31.65,115.65 31.09,115.04 30.28,114.81 28.02,114.81 27.81,114.8 27.59,114.81 25.28,114.81 24.29,115.19 23.81,116.13 23.8,118.76 23.81,119.02 23.83,119.28 23.81,122.48 31.81,122.48
GND on IN1 (solid shape): 202.37,99.24 202.5,98.59 203.1,98.29 212.15,98.29 212.15,93.95 211.93,93.42 211.4,93.2 204.55,93.2 203.81,92.58 204.29,91.74 204.29,90.99 203.19,90.99 202.69,91.49 201.35,91.49 200.72,92.13 200.72,99.24
GND on IN1 (solid shape): outline of 256 points within 200.39,70.68 214.15,79.81
GND on IN1 (solid shape): outline of 333 points within 190.13,26.47 211.85,41.44
GND on IN1 (solid shape): outline of 107 points within 12.05,0.25 214.15,20.86
GND on IN1 (solid shape): outline of 1201 points within 0.25,30.77 212.15,122.55
GND on IN2 (solid shape): 44.57,51.62 44.57,47.04 44.13,46.6 41.9,46.6 41.59,46.92 41.59,51.55 41.84,51.81 44.38,51.81
GND on IN2 (solid shape): 68.64,49.52 68.64,45.27 68.45,45.08 65.97,45.08 65.72,44.82 65.72,43.81 66.1,43.43 66.8,43.43 67.37,42.85 68.38,42.85 68.51,42.73 68.51,41.52 68.26,41.27 63.75,41.27 62.99,42.03 62.99,43.93 62.48,44.44 61.33,44.44 61.02,44.76 61.02,46.09 61.27,46.35 61.59,46.35 65.08,49.84 68.32,49.84
GND on IN2 (solid shape): 211.1,58.24 211.63,58.02 211.84,57.5 211.84,54.8 211.63,54.27 211.1,54.05 201.67,54.05 201.49,54.03 201.32,53.97 200.27,53.97 200.27,58.24
GND on IN2 (solid shape): 31.79,119.03 31.79,118.59 31.81,116.51 31.78,116.11 31.74,115.87 31.65,115.65 31.09,115.04 30.28,114.81 28.02,114.81 27.81,114.8 27.59,114.81 25.28,114.81 24.29,115.19 23.81,116.13 23.8,118.76 23.81,119.02 23.83,119.28 23.81,122.48 31.81,122.48
GND on IN2 (solid shape): 201.16,41.54 201.22,41.47 201.18,41.37 200.96,40.54 201.67,40.04 211.1,40.04 211.52,39.91 211.79,39.57 211.83,39.44 211.85,39.3 211.85,38.64 203.02,38.64 202.88,38.5 200.5,38.5 199.95,39.06 199.95,39.78 200.15,39.98 200.15,41.39 200.3,41.54
GND on IN2 (solid shape): 202.37,99.24 202.5,98.59 203.1,98.29 212.15,98.29 212.15,93.95 211.93,93.42 211.4,93.2 204.55,93.2 203.81,92.58 204.29,91.74 204.29,90.99 203.19,90.99 202.69,91.49 201.35,91.49 200.72,92.13 200.72,99.24
GND on IN2 (solid shape): outline of 256 points within 200.39,70.68 214.15,79.81
GND on IN2 (solid shape): outline of 107 points within 12.05,0.25 214.15,20.86
GND on IN2 (solid shape): outline of 1201 points within 0.25,30.77 212.15,122.55
GND on IN2 (solid shape): outline of 15857 points within 5.33,9.26 200.02,114.42
GND on IN3 (solid shape): 44.38,51.55 44.38,46.92 44.13,46.66 41.9,46.66 41.71,46.85 41.71,51.49 41.97,51.74 44.19,51.74
GND on IN3 (solid shape): 85.81,104.64 86.1,104.64 86.19,104.73 88.35,104.73 88.83,104.26 90.67,104.26 90.99,103.94 90.99,103.43 90.8,103.24 87.12,103.24 86.42,102.54 86.42,98.42 86.29,98.29 84.07,98.29 83.75,98.61 83.75,104.58 83.91,104.73 85.72,104.73
GND on IN3 (solid shape): 68.51,45.58 68.51,45.27 68.38,45.14 65.72,45.14 65.53,44.95 65.53,43.62 65.78,43.36 66.92,43.36 67.37,42.92 68.32,42.92 68.51,42.73 68.51,42.47 68.38,42.35 62.03,42.35 60.76,43.62 60.76,45.9 61.02,46.16 62.22,46.16 62.67,46.6 67.49,46.6
GND on IN3 (solid shape): 211.1,58.24 211.63,58.02 211.84,57.5 211.84,54.8 211.63,54.27 211.1,54.05 201.67,54.05 201.49,54.03 201.32,53.97 200.27,53.97 200.27,58.24
GND on IN3 (solid shape): 31.79,119.03 31.79,118.59 31.81,116.51 31.78,116.11 31.74,115.87 31.65,115.65 31.09,115.04 30.28,114.81 28.02,114.81 27.81,114.8 27.59,114.81 25.28,114.81 24.29,115.19 23.81,116.13 23.8,118.76 23.81,119.02 23.83,119.28 23.81,122.48 31.81,122.48
GND on IN3 (solid shape): 201.12,41.55 201.21,41.48 200.96,40.54 201.67,40.04 211.1,40.04 211.52,39.91 211.79,39.57 211.83,39.44 211.85,39.3 211.85,38.64 203.02,38.64 202.88,38.5 200.5,38.5 199.95,39.06 199.95,39.78 200.15,39.98 200.15,41.39 200.31,41.55
GND on IN3 (solid shape): 202.37,99.24 202.5,98.59 203.1,98.29 212.15,98.29 212.15,93.95 211.93,93.42 211.4,93.2 204.55,93.2 203.81,92.58 204.29,91.74 204.29,90.99 203.19,90.99 202.69,91.49 201.35,91.49 200.72,92.13 200.72,99.24
GND on IN3 (solid shape): outline of 256 points within 200.39,70.68 214.15,79.81
GND on IN3 (solid shape): outline of 107 points within 12.05,0.25 214.15,20.86
GND on IN3 (solid shape): outline of 1201 points within 0.25,30.77 212.15,122.55
GND on BOTTOM: 1.53,76.42 9.01,76.42 9.35,76.08 9.35,73.77 8.9,73.31 1.59,73.31 1.25,73.65 1.25,76.14
GND on GND1: outline of 212 points within 0.2,0.2 214.2,122.6
GND on VCC: 197.96,38.66 195.76,40.86 195.76,49.12 194.11,50.77 194.11,62.5 195.95,64.34 195.95,74.96 192.02,78.9 192.02,99.24 201.34,99.24 201.78,97.87 203.1,97.28 211.13,97.28 211.13,94.22 204.55,94.22 202.92,93.14 203.28,91.22 203.28,79.18 202.92,77.26 204.55,76.18 213.13,76.18 213.13,75.77 213.1,75.77 211.49,75.1 210.83,73.5 210.83,73.27 201.67,73.27 200.04,72.19 200.4,70.26 200.4,60.23 200.04,58.31 201.67,57.22 210.83,57.22 210.83,55.07 201.67,55.07 200.04,53.99 200.4,52.06 200.4,42.03 200.04,40.11 201.67,39.02 210.83,39.02 210.83,38.66 ; 1 cut-out
GND on VCC: 196.18,111.94 194.85,113.27 196.16,114.06 196.67,115.5 196.67,119.8 197.18,121.02 198.4,121.53 201.42,121.53 202.23,120.79 203.3,120.53 205.3,120.53 205.82,120.32 206.03,119.8 206.03,118.8 206.99,116.49 209.3,115.53 211.13,115.53 211.13,113.82 203.1,113.82 201.81,113.26 201.33,111.94 ; 1 cut-out
GND on VCC: outline of 138 points within 1.27,6.77 192.02,121.53 ; 1 cut-out
GND on GND2: outline of 212 points within 0.2,0.2 214.2,122.6
GNDA on TOP (solid shape): 196.4,26.09 196.4,25.45 196.3,25.35 196.14,25.27 196.06,25.11 195.48,24.53 192.4,24.53 192.31,24.44 191.84,24.44 191.7,24.58 191.7,27.36 191.83,27.49 195,27.49
GNDA on BOTTOM (solid shape): 193.8,23.17 193.84,23.15 193.9,23.13 193.99,23.04 194.3,23.04 194.36,22.98 194.37,22.98 194.49,22.85 194.49,22.15 194.37,22.03 193.1,22.03 192.97,22.15 192.97,23.04 193.1,23.17
GNDA on GND1: 191.55,16.82 188.97,19.4 188.97,19.93 189.29,20.25 189.29,21.71 188.97,22.03 188.84,22.03 188.83,22.01 188.51,22.01 187.7,22.83 187.7,28.72 188.65,29.67 188.65,33.99 189.52,34.85 196,34.85 199.3,38.15 211.9,38.15 211.9,36.9 211.66,36.34 211.1,36.1 200.85,36.1 200.15,35.5 200.65,34.73 200.65,29.52 200.15,28.75 200.85,28.15 211.1,28.15 211.66,27.91 211.9,27.35 211.9,24.05 212.08,23.41 212.59,22.96 213.51,22.27 214.07,21.26 200.87,21.26 200.23,20.63 199.3,20.63 199.19,20.73 199.19,21.16 199.3,21.26 200.31,21.26 201.22,22.17 201.22,24.93 200.7,25.45 198.71,25.45 198.05,24.8 198.05,23.91 197.41,23.27 197.41,22.26 197.31,22.15 195.79,22.15 193.86,20.23 193.86,17.16 193.6,16.82
GNDA on VCC: 191.55,16.82 188.97,19.4 188.97,19.95 189.29,20.27 189.29,21.69 188.95,22.03 188.5,22.03 187.7,22.83 187.7,28.72 188.65,29.67 188.65,33.99 189.52,34.85 196,34.85 199.3,38.15 210.83,38.15 210.83,37.17 200.85,37.17 199.22,36.09 199.58,34.17 199.58,30.08 199.22,28.16 200.85,27.08 210.83,27.08 210.83,24.05 211.18,22.84 212.13,22 212.58,21.69 212.92,21.26 200.87,21.26 200.23,20.63 199.3,20.63 199.19,20.73 199.19,21.16 199.3,21.26 200.31,21.26 201.22,22.17 201.22,24.93 200.7,25.45 198.71,25.45 198.05,24.8 198.05,23.91 197.41,23.27 197.41,22.26 197.31,22.15 195.79,22.15 193.86,20.23 193.86,17.16 193.6,16.82
GNDA on GND2: 191.55,16.82 188.97,19.4 188.97,19.93 189.29,20.25 189.29,21.71 188.95,22.05 188.48,22.05 187.7,22.83 187.7,28.72 188.65,29.67 188.65,33.99 189.52,34.85 196,34.85 199.3,38.15 211.9,38.15 211.9,36.9 211.66,36.34 211.1,36.1 200.85,36.1 200.15,35.5 200.65,34.73 200.65,29.52 200.15,28.75 200.85,28.15 211.1,28.15 211.66,27.91 211.9,27.35 211.9,24.05 212.08,23.41 212.59,22.96 213.51,22.27 214.07,21.26 200.87,21.26 200.23,20.63 199.3,20.63 199.19,20.73 199.19,21.16 199.3,21.26 200.31,21.26 201.22,22.17 201.22,24.93 200.7,25.45 198.71,25.45 198.05,24.8 198.05,23.91 197.41,23.27 197.41,22.26 197.31,22.15 195.79,22.15 193.86,20.23 193.86,17.16 193.6,16.82
PVCC_VGA on BOTTOM (solid shape): 72.13,43.81 72.13,43.23 72.32,43.04 74.42,43.04 74.48,42.98 74.48,42.85 74.42,42.79 73.34,42.79 73.15,42.6 72,42.6 71.88,42.47 71.88,42.16 71.75,42.03 71.3,42.03 71.24,42.09 71.24,43.74 71.37,43.87 72.07,43.87
