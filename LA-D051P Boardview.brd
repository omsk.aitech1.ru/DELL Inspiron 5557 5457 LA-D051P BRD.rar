# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_D15: length 86.5
  IN3 w0.102: v2(102.43,89.36) 101.92,88.86 100.13,88.86 95.24,83.97 95.24,77.55 99.32,73.48 99.32,48.88 100.77,47.43 101.72,47.43 103.13,46.03 103.13,42.78 103.23,42.68 103.74,42.68 103.84,42.58 103.84,42.37 103.74,42.27 103.23,42.27 103.13,42.17 103.13,41.97 103.23,41.87 103.74,41.87 103.84,41.77 103.84,41.56 103.74,41.46 103.26,41.46 103.16,41.36 103.16,41.16 103.26,41.05 103.74,41.05 103.84,40.95 103.84,38 108.81,33.04 108.81,32.03 109.22,31.63 v2(109.22,31.47)
  BOTTOM w0.076: 104.22,87.81 104.7,87.81 105.27,87.24 107.64,87.24 108.32,87.92 111,87.92 111.17,87.76 111.22,87.7 111.62,87.7 111.69,87.74 112.17,87.74 112.57,88.13 UC1.AH69
  BOTTOM w0.102: JDIMM2.7 110.35,33.58 109.65,32.89 109.65,31.68 109.44,31.47 v2(109.22,31.47) ; v2(102.43,89.36) 103.98,87.81 104.22,87.81
DDR_B_D16: length 67.8
  IN3 w0.102: v2(120.51,32.74) 120.52,32.74 120.52,33.23 119.16,34.58 118.5,34.58 117.6,35.48 117.6,37.47 115.62,39.46 115.62,44.19 115.51,44.29 115.01,44.29 114.88,44.41 114.88,44.67 115.01,44.79 115.51,44.79 115.62,44.9 115.62,45.2 115.51,45.3 115.01,45.3 114.88,45.43 114.88,46.92 108.36,53.44 108.36,62.78 107.59,63.55 107.59,69.53 107.49,69.63 107.05,69.63 106.95,69.74 106.95,69.94 107.05,70.04 107.49,70.04 107.59,70.14 107.59,70.35 107.49,70.45 106.89,70.45 106.79,70.55 106.79,70.75 106.89,70.85 107.49,70.85 107.59,70.95 107.59,71.16 107.49,71.26 106.89,71.26 106.79,71.36 106.79,74.19 107.95,75.35 107.95,77.82 109.92,79.79 110.86,79.79 111.48,80.41 111.48,81.19 112.45,82.16 113.2,82.16 113.72,82.68 113.72,83.03 v2(114.19,83.5)
  BOTTOM w0.076: v2(114.19,83.5) 114.44,83.75 UC1.AT66
  BOTTOM w0.102: JDIMM2.41 120.55,33.42 120.51,33.38 v2(120.51,32.74)
DDR_B_D17: length 67.3
  IN3 w0.102: v2(114.19,82.88) 113.28,81.97 112.68,81.97 111.76,81.05 111.76,80.29 110.86,79.39 110,79.39 108.28,77.67 108.28,75.21 107.17,74.1 107.17,72.65 107.27,72.55 107.79,72.55 107.9,72.45 107.9,72.25 107.79,72.14 107.4,72.14 107.3,72.04 107.3,71.84 107.4,71.74 107.79,71.74 107.9,71.64 107.9,63.67 108.66,62.9 108.66,53.57 115.92,46.31 115.92,39.59 117.91,37.6 117.91,35.6 118.62,34.89 119.29,34.89 120.92,33.26 120.92,31.62 v2(120.51,31.22)
  BOTTOM w0.076: v2(114.19,82.88) 114.49,83.1 UC1.AU66
  BOTTOM w0.102: JDIMM2.39 119.95,31.78 v2(120.51,31.22)
DDR_B_D18: length 70.3
  IN3 w0.089: v2(115.15,85.31) 115.49,84.97 115.49,83.18 115.67,83 115.67,82.02 113.61,79.96 113.1,79.96 112.5,79.36
  IN3 w0.102: 112.5,79.36 110.72,77.58 110.72,72.94 110.62,72.84 110.06,72.84 109.96,72.74 109.96,72.54 110.06,72.43 110.62,72.43 110.72,72.33 110.72,72.13 110.62,72.03 110.06,72.03 109.96,71.93 109.96,71.72 110.06,71.62 110.62,71.62 110.72,71.52 110.72,71.32 110.62,71.21 110.06,71.21 109.96,71.11 109.96,70.91 110.06,70.81 110.62,70.81 110.72,70.71 110.72,70.5 110.62,70.4 110.06,70.4 109.96,70.3 109.96,70.1 110.06,70 110.62,70 110.72,69.89 110.72,69.69 110.62,69.59 110.06,69.59 109.96,69.49 109.96,69.28 110.06,69.18 110.62,69.18 110.72,69.08 110.72,68.88 110.62,68.78 110.33,68.78 110.23,68.67 110.23,68.47 110.33,68.37 110.62,68.37 110.72,68.27 110.72,54.39 118.28,46.83 118.28,40.12 120.11,38.29 120.11,37.32 120.85,36.58 120.85,36.21 123.75,33.3 v2(123.75,32.74)
  BOTTOM w0.076: v2(115.15,85.31) 115.32,85.14 115.52,85.14 UC1.AP65
  BOTTOM w0.102: JDIMM2.51 123.55,32.94 v2(123.75,32.74)
DDR_B_D19: length 71
  IN3 w0.089: 112.72,78.65 112.72,79.27 113.21,79.75 113.65,79.75 115.88,81.97 115.88,83.04 115.67,83.25 115.67,85.43 v2(115.15,85.94)
  IN3 w0.102: 112.72,78.65 112.23,78.16 111.84,78.16 111.03,77.34 111.03,54.51 118.58,46.96 118.58,40.25 120.41,38.42 120.41,37.45 121.15,36.71 121.15,36.34 124.96,32.53 124.96,29.17 124.86,29.07 124.38,29.07 124.28,28.97 124.28,28.76 124.38,28.66 124.86,28.66 124.96,28.56 124.96,28.27 124.86,28.17 v2(123.75,28.17)
  BOTTOM w0.076: v2(115.15,85.94) 115.39,85.7 UC1.AN65
  BOTTOM w0.102: JDIMM2.50 123.25,27.67 v2(123.75,28.17)
DDR_B_D20: length 70.4
  IN3 w0.102: v2(114.24,85.31) 113.74,84.81 113.74,84.34 111.94,82.54 111.94,82.29 111.16,81.51 110.57,81.51 110.29,81.23 110.29,81.02 107.24,77.97 107.24,75.54 106.18,74.48 106.18,68.94 106.98,68.14 106.98,61.69 107.08,61.58 107.56,61.58 107.66,61.48 107.66,61.28 107.56,61.18 107.35,61.18 107.24,61.08 107.24,60.87 107.35,60.77 107.56,60.77 107.66,60.67 107.66,53.27 114.27,46.67 114.27,39.95 116.44,37.77 116.44,35.78 118.24,33.97 118.91,33.97 119.77,33.12 119.77,28.91 v2(120.51,28.17)
  BOTTOM w0.076: UC1.AN66 114.63,85.7 v2(114.24,85.31)
  BOTTOM w0.102: v2(120.51,28.17) 120.85,27.83 JDIMM2.42
DDR_B_D21: length 69.4
  IN3 w0.102: v2(120.51,29.69) 120.07,30.13 120.07,33.24 119.04,34.28 118.37,34.28 117.3,35.35 117.3,37.35 114.57,40.07 114.57,46.79 107.97,53.4 107.97,61.74 107.87,61.84 107.83,61.84 107.73,61.94 107.73,62.15 107.83,62.25 107.87,62.25 107.97,62.35 107.97,62.55 107.87,62.66 107.39,62.66 107.29,62.76 107.29,68.27 106.48,69.07 106.48,74.35 107.53,75.4 107.53,77.84 110.33,80.64 110.96,80.64 111.14,80.82 111.14,81.17 112.24,82.26 112.24,82.39 114.24,84.39 v2(114.24,84.67)
  BOTTOM w0.076: UC1.AP66 v2(114.24,84.67)
  BOTTOM w0.102: v2(120.51,29.69) 119.91,29.09 119.91,27.94 120.25,27.59 JDIMM2.40
DDR_B_D22: length 69.3
  IN3 w0.089: 113.54,80.15 115.49,82.1 115.49,82.93 115.11,83.3 v2(115.11,83.41)
  IN3 w0.102: v2(123.75,31.22) 123.34,31.62 123.34,33.28 120.54,36.08 120.54,36.45 119.8,37.19 119.8,38.15 117.98,39.98 117.98,46.7 110.42,54.26 110.42,65.5 110.29,65.63 109.73,65.63 109.63,65.73 109.63,65.93 109.73,66.04 110.29,66.04 110.39,66.14 110.39,66.34 110.29,66.44 109.73,66.44 109.63,66.54 109.63,66.75 109.73,66.85 110.29,66.85 110.39,66.95 110.39,67.15 110.29,67.26 109.73,67.26 109.63,67.36 109.63,67.56 109.73,67.66 109.98,67.66 110.08,67.76 110.08,67.97 109.98,68.07 109.73,68.07 109.63,68.17 109.63,77.54 110.35,78.27 111.12,78.27 112.99,80.15 113.54,80.15
  BOTTOM w0.076: v2(115.11,83.41) 115.45,83.75 UC1.AT65
  BOTTOM w0.102: v2(123.75,31.22) 124.16,31.62 124.16,33.37 124.15,33.38 JDIMM2.53
DDR_B_D23: length 68.5
  IN3 w0.089: 114.32,81.19 115.11,81.99 v2(115.11,82.77)
  IN3 w0.102: v2(123.75,29.69) 123.04,30.4 123.04,33.15 120.24,35.96 120.24,36.33 119.5,37.07 119.5,38.03 117.67,39.85 117.67,46.58 110.09,54.16 110.09,63.52 109.99,63.62 109.96,63.62 109.86,63.72 109.86,63.93 109.96,64.03 109.99,64.03 110.09,64.13 110.09,64.33 109.99,64.44 109.42,64.44 109.32,64.54 109.32,64.74 109.42,64.84 109.99,64.84 110.09,64.94 110.09,65.15 109.99,65.25 109.42,65.25 109.32,65.35 109.32,77.61 110.35,78.65 111.14,78.65 112.69,80.19 112.69,80.63 113.25,81.19 114.32,81.19
  BOTTOM w0.076: v2(115.11,82.77) 115.44,83.1 UC1.AU65
  BOTTOM w0.102: v2(123.75,29.69) 124.16,29.29 124.16,28 123.85,27.69 JDIMM2.52
DDR_B_D24: length 67.3
  IN3 w0.089: 115.26,79.02 115.26,79.82 116.47,81.03 116.47,82.66 117.06,83.25 v2(117.06,83.4)
  IN3 w0.102: v2(125.85,31.22) 125.85,30.95 125.94,30.85 126.32,30.85 126.41,30.94 126.41,33.19 121.95,37.65 121.76,37.65 121.52,37.88 121.52,38.86 120.21,40.17 120.21,40.62 120.11,40.72 119.92,40.72 119.82,40.83 119.82,41.03 119.92,41.13 120.11,41.13 120.21,41.23 120.21,45.76 120.11,45.86 119.78,45.86 119.68,45.96 119.68,46.17 119.78,46.27 120.11,46.27 120.21,46.37 120.21,46.88 112.37,54.71 112.37,72.95 112.74,73.31 112.74,77.19 113.38,77.83 114.07,77.83 115.26,79.02
  BOTTOM w0.076: UC1.AT61 117.41,83.75 v2(117.06,83.4)
  BOTTOM w0.102: JDIMM2.57 125.35,31.71 v2(125.85,31.22)
DDR_B_D25: length 66.7
  IN3 w0.089: v2(117.05,82.73) 116.69,82.37 116.69,80.9 115.51,79.73 115.51,78.95
  IN3 w0.102: 115.51,78.95 114.09,77.52 113.56,77.52 113.01,76.97 113.01,73.06 112.68,72.73 112.68,54.84 120.51,47.01 120.51,40.3 122.41,38.4 122.41,37.62 126.71,33.32 126.71,29.63 126.83,29.51 126.83,29.37 126.57,29.11 126.43,29.11 v2(125.85,29.69)
  BOTTOM w0.076: UC1.AU61 117.42,83.1 v2(117.05,82.73)
  BOTTOM w0.102: v2(125.85,29.69) 125.05,28.9 JDIMM2.56
DDR_B_D26: length 70.1
  IN3 w0.089: 117.39,79.71 118.63,80.96 118.63,83.52 118.26,83.89 118.26,84.95 v2(117.89,85.31)
  IN3 w0.102: 117.39,79.71 117.39,78.67 115.11,76.4 115.11,72.08 114.71,71.68 114.71,64.47 114.81,64.37 115.01,64.37 115.11,64.27 115.11,64.07 115.01,63.97 114.81,63.97 114.71,63.87 114.71,63.66 114.81,63.56 115.01,63.56 115.11,63.46 115.11,63.26 115.01,63.15 114.81,63.15 114.71,63.05 114.71,62.85 114.81,62.75 115.01,62.75 115.11,62.65 115.11,62.44 115.01,62.34 114.81,62.34 114.71,62.24 114.71,62.04 114.81,61.93 115.01,61.93 115.11,61.83 115.11,61.63 115.01,61.53 114.97,61.53 114.86,61.43 114.86,61.22 114.97,61.12 114.99,61.12 115.11,61 115.11,55.57 122.94,47.74 122.94,40.74 125.5,38.19 125.5,37.72 126,37.22 126.47,37.22 128.97,34.71 128.97,31.86 v2(129.62,31.22)
  BOTTOM w0.076: UC1.AP60 118.15,85.05 v2(117.89,85.31)
  BOTTOM w0.102: JDIMM2.69 128.95,33.54 129.17,33.32 129.82,33.32 130.25,32.89 130.25,31.29 130.18,31.22 v2(129.62,31.22)
DDR_B_D27: length 70.3
  IN3 w0.089: 117.74,79.54 118.99,80.79 118.99,83.41 118.44,83.96 118.44,85.41 v2(117.89,85.96)
  IN3 w0.102: 117.74,79.54 117.74,78.67 115.42,76.35 115.42,70.92 115.32,70.81 115.12,70.81 115.02,70.71 115.02,70.51 115.12,70.41 115.32,70.41 115.42,70.31 115.42,70.1 115.32,70 115.12,70 115.02,69.9 115.02,69.7 115.12,69.59 115.32,69.59 115.42,69.49 115.42,69.29 115.32,69.19 115.12,69.19 115.02,69.09 115.02,68.88 115.12,68.78 115.32,68.78 115.42,68.68 115.42,68.48 115.32,68.38 115.12,68.38 115.02,68.27 115.02,68.07 115.12,67.97 115.32,67.97 115.42,67.87 115.42,67.66 115.32,67.56 115.12,67.56 115.02,67.46 115.02,67.26 115.12,67.16 115.32,67.16 115.42,67.05 115.42,66.85 115.32,66.75 115.12,66.75 115.02,66.65 115.02,66.44 115.12,66.34 115.32,66.34 115.42,66.24 115.42,66.04 115.32,65.94 115.12,65.94 115.02,65.84 115.02,65.63 115.12,65.53 115.32,65.53 115.42,65.43 115.42,65.23 115.32,65.12 115.12,65.12 115.02,65.02 115.02,64.82 115.12,64.72 115.32,64.72 115.42,64.62 115.42,55.7 117.67,53.45 123.25,47.87 123.25,47.15 123.35,47.05 123.56,47.05 123.66,46.95 123.66,46.75 123.56,46.65 123.35,46.65 123.25,46.54 123.25,40.87 125.8,38.31 125.8,37.85 126.13,37.52 126.6,37.52 129.62,34.5 129.62,33.77 129.51,33.66 129.38,33.66 129.28,33.56 129.28,33.36 129.38,33.26 129.51,33.26 129.62,33.16 v2(129.62,32.74)
  BOTTOM w0.076: UC1.AN60 118.15,85.7 v2(117.89,85.96)
  BOTTOM w0.102: JDIMM2.67 128.35,33.39 129,32.74 v2(129.62,32.74)
DDR_B_D28: length 69.4
  IN3 w0.089: v2(116.98,85.31) 116.43,84.76 116.43,83.13 116.11,82.8 116.11,81.75 114.04,79.68 114.04,79.49
  IN3 w0.102: 114.04,79.49 112.26,77.71 111.78,77.71 111.51,77.45 111.51,71.1 111.61,71 111.64,71 111.74,70.9 111.74,70.69 111.64,70.59 111.61,70.59 111.51,70.49 111.51,70.29 111.61,70.19 111.64,70.19 111.74,70.08 111.74,69.88 111.64,69.78 111.61,69.78 111.51,69.68 111.51,69.47 111.61,69.37 111.64,69.37 111.74,69.27 111.74,69.07 111.64,68.97 111.61,68.97 111.51,68.86 111.51,68.66 111.61,68.56 111.64,68.56 111.74,68.46 111.74,68.26 111.64,68.15 111.61,68.15 111.51,68.05 111.51,67.85 111.61,67.75 111.64,67.75 111.74,67.65 111.74,67.44 111.64,67.34 111.61,67.34 111.51,67.24 111.51,67.04 111.61,66.93 111.64,66.93 111.74,66.83 111.74,66.63 111.64,66.53 111.61,66.53 111.51,66.43 111.51,54.71 119.07,47.16 119.07,40.45 120.9,38.62 120.9,37.65 121.5,37.04 121.7,37.04 122.47,36.27 122.47,35.7 125.44,32.73 125.44,28.58 v2(125.85,28.17)
  BOTTOM w0.076: v2(116.98,85.31) 117.37,85.7 UC1.AN61
  BOTTOM w0.102: v2(125.85,28.17) 125.65,27.97 JDIMM2.58
DDR_B_D29: length 68.7
  IN3 w0.089: 115.01,79.22 115.01,79.93 116.29,81.21 116.29,82.73 116.61,83.06 116.61,84.31 v2(116.98,84.67)
  IN3 w0.102: 115.01,79.22 114.01,78.22 113.23,78.22 112.31,77.3 112.31,73.53 112.07,73.29 112.07,66.33 111.91,66.17 111.91,65.91 112.07,65.75 112.07,65.46 111.97,65.36 111.92,65.36 111.82,65.26 111.82,65.05 111.92,64.95 111.97,64.95 112.07,64.85 112.07,64.65 111.97,64.54 111.92,64.54 111.82,64.44 111.82,64.24 111.92,64.14 111.97,64.14 112.07,64.04 112.07,63.83 111.97,63.73 111.92,63.73 111.82,63.63 111.82,63.43 111.92,63.32 111.97,63.32 112.07,63.22 112.07,63.02 111.97,62.92 111.92,62.92 111.82,62.82 111.82,62.61 111.92,62.51 111.97,62.51 112.07,62.41 112.07,62.21 111.97,62.11 111.92,62.11 111.82,62 111.82,61.8 111.92,61.7 111.97,61.7 112.07,61.6 112.07,61.39 111.97,61.29 111.92,61.29 111.82,61.19 111.82,60.99 111.92,60.89 111.97,60.89 112.07,60.78 112.07,60.58 111.97,60.48 111.92,60.48 111.82,60.38 111.82,60.18 111.92,60.07 111.97,60.07 112.07,59.97 112.07,59.77 111.97,59.67 111.92,59.67 111.82,59.57 111.82,59.36 111.92,59.26 111.97,59.26 112.07,59.16 112.07,58.96 111.97,58.85 111.92,58.85 111.82,58.75 111.82,58.55 111.92,58.45 111.97,58.45 112.07,58.35 112.07,58.14 111.97,58.04 111.92,58.04 111.82,57.94 111.82,57.74 111.92,57.64 111.97,57.64 112.07,57.53 112.07,57.33 111.97,57.23 111.92,57.23 111.82,57.13 111.82,56.92 111.92,56.82 111.97,56.82 112.07,56.72 112.07,56.52 111.97,56.42 111.92,56.42 111.82,56.31 111.82,56.11 111.92,56.01 111.97,56.01 112.07,55.91 112.07,55.7 111.97,55.6 111.92,55.6 111.82,55.5 111.82,55.3 111.92,55.2 111.97,55.2 112.07,55.1 112.07,54.59 119.37,47.28 119.37,40.57 121.2,38.74 121.2,37.77 121.63,37.34 121.83,37.34 123.02,36.15 123.02,36.01 122.89,35.88 122.89,35.73 123.03,35.59 123.18,35.59 123.31,35.72 123.45,35.72 123.59,35.58 123.59,35.43 123.46,35.3 123.46,35.16 123.61,35.01 123.75,35.01 123.88,35.14 124.02,35.14 124.17,35 124.17,34.86 124.04,34.73 124.04,34.58 124.18,34.44 124.33,34.44 124.46,34.57 124.6,34.57 124.74,34.43 124.74,34.28 124.6,34.14 124.6,34 124.82,33.78 124.96,33.78 125.1,33.92 125.24,33.92 125.85,33.32 v2(125.85,32.74)
  BOTTOM w0.076: v2(116.98,84.67) 117.36,85.05 UC1.AP61
  BOTTOM w0.102: JDIMM2.59 125.95,32.84 v2(125.85,32.74)
DDR_B_D30: length 69.4
  IN3 w0.089: 117.1,79.81 118.36,81.08 118.36,83.06 v2(118,83.42)
  IN3 w0.102: v2(129.62,29.69) 129.42,29.69 129.17,29.95 129.17,31.23 128.67,31.73 128.67,34.58 126.34,36.91 125.88,36.91 125.19,37.59 125.19,38.06 122.64,40.62 122.64,47.62 114.41,55.85 114.41,56.26 114.51,56.36 114.69,56.36 114.79,56.47 114.79,56.67 114.69,56.77 114.51,56.77 114.41,56.87 114.41,57.08 114.51,57.18 114.69,57.18 114.79,57.28 114.79,57.48 114.69,57.58 114.51,57.58 114.41,57.69 114.41,57.89 114.51,57.99 114.69,57.99 114.79,58.09 114.79,58.29 114.69,58.4 114.51,58.4 114.41,58.5 114.41,58.7 114.51,58.8 114.69,58.8 114.79,58.9 114.79,59.11 114.69,59.21 114.51,59.21 114.41,59.31 114.41,59.51 114.51,59.62 114.69,59.62 114.79,59.72 114.79,59.92 114.69,60.02 114.51,60.02 114.41,60.12 114.41,60.33 114.51,60.43 114.69,60.43 114.79,60.53 114.79,60.73 114.69,60.83 114.51,60.83 114.41,60.94 114.41,71.99 114.78,72.36 114.78,76.49 117.1,78.81 117.1,79.81
  BOTTOM w0.076: UC1.AT60 118.34,83.75 v2(118,83.42)
  BOTTOM w0.102: JDIMM2.68 128.65,28.73 v2(129.62,29.69)
DDR_B_D31: length 68.4
  IN3 w0.089: v2(118,82.74) 118.1,82.63 118.1,81.15 116.8,79.84
  IN3 w0.102: v2(129.62,28.17) 129.62,28.06 129.51,27.96 128.96,27.96 128.86,28.06 128.86,31.11 128.36,31.6 128.36,33.68 128.14,33.91 128.14,34.05 128.36,34.28 128.36,34.43 128.22,34.57 128.08,34.57 127.85,34.34 127.7,34.34 127.56,34.49 127.56,34.63 127.81,34.87 127.81,35.02 127.66,35.16 127.52,35.16 127.27,34.92 127.13,34.92 126.99,35.06 126.99,35.2 127.23,35.45 127.23,35.59 127.09,35.74 126.94,35.74 126.7,35.49 126.55,35.49 126.07,35.98 126.07,36.29 124.17,38.18 124.17,38.65 122.33,40.49 122.33,47.49 114.1,55.72 114.1,72.19 114.48,72.57 114.48,76.57 116.8,78.88 116.8,79.84
  BOTTOM w0.076: v2(118,82.74) 118.35,83.09 UC1.AU60
  BOTTOM w0.102: v2(129.62,28.17) 129.42,28.17 129.25,28 JDIMM2.70
DDR_B_D32: length 66.8
  IN3 w0.089: v2(128.88,82.72) 128.88,80.23 131.03,78.08
  IN3 w0.102: 131.03,78.08 131.03,65.4 147.66,48.77 147.66,40.94 149.89,38.7 149.89,35.7 149.23,35.03 149.23,30.72 149.35,30.6 149.35,30.15 148.88,29.69 v2(148.82,29.69)
  BOTTOM w0.076: UC1.AU40 129.26,83.1 v2(128.88,82.72)
  BOTTOM w0.102: v2(148.82,29.69) 149.04,29.69 150.25,28.49 JDIMM2.132
DDR_B_D33: length 67.4
  IN3 w0.089: v2(128.88,84.02) 128.52,83.66 128.52,80.26 130.18,78.59 130.18,72.79 130.71,72.26
  IN3 w0.102: v2(148.82,32.74) 148.82,35.06 149.59,35.83 149.59,38.58 147.35,40.81 147.35,46.97 147.14,47.18 147.14,47.32 147.35,47.53 147.35,47.67 147.21,47.82 147.06,47.82 146.86,47.61 146.71,47.61 146.57,47.75 146.57,47.9 147.26,48.59 147.26,48.73 147.12,48.88 146.97,48.88 146.28,48.18 146.14,48.18 146.05,48.27 146.05,49.05 146.15,49.15 146.39,49.15 146.49,49.25 146.49,49.46 146.39,49.56 146.15,49.56 146.05,49.66 146.05,49.95 130.71,65.29 130.71,72.26
  BOTTOM w0.076: v2(128.88,84.02) 129.05,84.02 UC1.AT40
  BOTTOM w0.102: v2(148.82,32.74) 149.43,32.74 149.95,33.26 JDIMM2.131
DDR_B_D34: length 68.2
  IN3 w0.089: 132.82,69.35 132.82,77.64 131.82,78.64 131.82,79.68 130.87,80.63 130.87,82.37 131.09,82.59 131.09,82.89 130.69,83.3 v2(130.69,83.4)
  IN3 w0.102: v2(152.2,31.22) 152.14,31.16 152.14,30.93 152.04,30.83 151.71,30.83 151.61,30.93 151.61,35.09 152.18,35.66 152.18,38.86 150.22,40.82 150.22,41 150.32,41.1 150.45,41.1 150.55,41.2 150.55,41.41 150.45,41.51 150.32,41.51 150.22,41.61 150.22,41.88 150.68,42.34 150.68,45.41 149.89,46.19 149.89,48.98 132.89,65.99 132.89,69.28 132.82,69.35
  BOTTOM w0.076: v2(130.69,83.4) 130.7,83.4 UC1.AT37
  BOTTOM w0.102: JDIMM2.143 153.55,32.57 v2(152.2,31.22)
DDR_B_D35: length 67.8
  IN3 w0.089: 131.94,78.14 131.57,78.51 131.57,79.64 130.7,80.51 v2(130.7,82.75)
  IN3 w0.102: 131.94,78.14 131.94,68.91 132.46,68.39 132.46,65.99 149.59,48.85 149.59,46.07 150.37,45.28 150.37,42.46 149.92,42.01 149.92,40.7 151.88,38.74 151.88,35.79 151.3,35.22 151.3,30.59 v2(152.2,29.69)
  BOTTOM w0.076: UC1.AU37 v2(130.7,82.75)
  BOTTOM w0.102: JDIMM2.140 152.65,27.55 152.46,27.74 151.68,27.74 151.46,27.96 151.46,28.96 v2(152.2,29.69)
DDR_B_D36: length 67.8
  IN3 w0.089: v2(128.89,84.72) 128.68,84.52 128.68,84.4 128.5,84.21 128.5,83.96 128.33,83.79 128.33,80.14 129.95,78.52 129.95,72.61 130.4,72.15
  IN3 w0.102: 130.4,72.15 130.4,65.16 145.74,49.82 145.74,48.15 147.05,46.84 147.05,40.69 149.28,38.45 149.28,35.95 148.42,35.08 148.42,31.53 148.73,31.22 v2(148.82,31.22)
  BOTTOM w0.076: v2(128.89,84.72) 129.01,84.72 UC1.AR40
  BOTTOM w0.102: JDIMM2.129 149.35,33.69 149.09,33.43 148.9,33.43 148.35,32.88 148.35,31.68 v2(148.82,31.22)
DDR_B_D37: length 69
  IN3 w0.089: v2(128.84,85.35) 128.46,84.97 128.46,84.51 128.32,84.37 128.32,84.05 128.13,83.86 128.13,80.01 128.95,79.18 128.95,78.45 129.67,77.73 129.67,72.5 129.85,72.32
  IN3 w0.102: 129.85,72.32 130.21,71.96 130.21,71.62 130.1,71.51 130.1,65.03 130.25,64.89 144.84,50.3 145.44,49.69 145.44,48.02 146.7,46.76 146.7,40.6 148.22,39.08 148.22,35.88 148.11,35.77 148.11,28.98 148.84,28.25 v2(149.06,28.25)
  BOTTOM w0.076: UC1.AP40 129.02,85.35 v2(128.84,85.35)
  BOTTOM w0.102: v2(149.06,28.25) 149.65,27.66 JDIMM2.130
DDR_B_D38: length 69.8
  IN3 w0.089: v2(130.7,84.67) 131.24,84.13 131.24,83.24 131.46,83.03 131.46,82.41 131.23,82.18 131.23,80.85 132.33,79.75 132.33,78.74 133.3,77.77 133.3,69.97
  IN3 w0.102: v2(152.2,28.17) 152.69,28.17 152.79,28.26 152.79,39.12 151.93,39.98 151.93,46.59 150.5,48.01 150.5,49.23 133.5,66.24 133.5,69.78 133.3,69.97
  BOTTOM w0.076: UC1.AP37 v2(130.7,84.67)
  BOTTOM w0.102: JDIMM2.142 153.25,27.84 153.16,27.93 153.16,28.19 152.9,28.44 152.47,28.44 v2(152.2,28.17)
DDR_B_D39: length 69.2
  IN3 w0.089: v2(130.7,84.04) 130.96,84.04 131.06,83.93 131.06,83.17 131.28,82.95 131.28,82.49 131.05,82.26 131.05,80.71 132.07,79.68 132.07,78.69 133.03,77.74 133.03,69.82
  IN3 w0.102: 133.03,69.82 133.19,69.65 133.19,66.12 150.2,49.11 150.2,47.65 150.31,47.54 150.54,47.54 150.79,47.29 150.79,47.15 150.69,47.04 150.3,47.04 150.2,46.95 150.2,46.32 150.43,46.09 150.68,46.09 150.81,46.22 150.81,46.59 151.08,46.86 151.22,46.86 151.62,46.46 151.62,40.79 151.31,40.48 151.31,40.16 152.48,38.99 152.48,34.95 152.38,34.85 152.01,34.85 151.91,34.75 151.91,34.53 152.01,34.43 152.38,34.43 152.48,34.33 152.48,34.13 152.38,34.03 152.01,34.03 151.91,33.92 151.91,33.72 152.01,33.62 152.38,33.62 152.48,33.52 152.48,33.31 152.38,33.21 152.01,33.21 151.91,33.11 151.91,32.82 151.99,32.74 v2(152.2,32.74)
  BOTTOM w0.076: v2(130.7,84.04) UC1.AR37
  BOTTOM w0.102: v2(152.2,32.74) 152.61,32.74 152.95,33.08 JDIMM2.141
DDR_B_D40: length 69.1
  IN3 w0.089: 134.87,70.4 134.87,75.76 134.31,76.32 134.31,78.8 133.47,79.64 133.47,80.19 132.9,80.76 132.9,83.12 v2(132.59,83.43)
  IN3 w0.102: 134.87,70.4 134.98,70.29 134.98,66.73 151.28,50.44 151.47,50.44 151.73,50.44 152.51,49.65 152.51,47.98 153.86,46.63 153.86,40.02 154.92,38.97 154.92,34.94 154.98,34.87 154.98,34.75 155.09,34.65 155.15,34.65 155.25,34.55 155.25,34.34 155.15,34.24 155.09,34.24 154.98,34.14 154.98,33.94 155.09,33.84 155.15,33.84 155.25,33.73 155.25,33.53 155.15,33.43 155.09,33.43 154.98,33.33 154.98,33.12 155.09,33.02 155.15,33.02 155.25,32.92 155.25,32.72 155.15,32.62 155.09,32.62 154.98,32.51 154.98,32.31 155.09,32.21 155.15,32.21 155.25,32.11 155.25,31.9 154.98,31.64 154.98,28.87 154.27,28.16 v2(154.23,28.16)
  BOTTOM w0.076: v2(132.59,83.43) 132.92,83.75 UC1.AT33
  BOTTOM w0.102: JDIMM2.148 155.05,27.94 154.83,28.16 v2(154.23,28.16)
DDR_B_D41: length 69
  IN3 w0.089: v2(132.53,82.77) 132.52,82.76 132.52,82.24 132.64,82.11 132.64,80.64 133.22,80.06 133.22,79.61 134.05,78.78 134.05,76.18 134.68,75.56 134.68,69.97
  IN3 w0.102: 134.68,69.97 134.68,66.61 151.15,50.13 151.6,50.13 152.2,49.53 152.2,47.86 153.56,46.51 153.56,39.9 154.61,38.84 154.61,38.58 154.49,38.45 154.49,38.17 154.61,38.05 154.61,37.76 154.49,37.64 154.49,37.36 154.61,37.23 154.61,36.95 154.55,36.88 153.98,36.88 153.88,36.78 153.88,36.58 153.98,36.47 154.51,36.47 154.61,36.37 154.61,36.17 154.51,36.07 153.98,36.07 153.88,35.97 153.88,35.76 153.98,35.66 154.51,35.66 154.61,35.56 154.61,35.36 154.51,35.25 153.98,35.25 153.88,35.15 153.88,34.95 153.98,34.85 154.58,34.85 154.68,34.75 154.68,34.54 154.58,34.44 153.98,34.44 153.88,34.34 153.88,34.14 153.98,34.04 154.58,34.04 154.68,33.93 154.68,33.73 154.58,33.63 154.21,33.63 154.11,33.53 154.11,33.32 154.21,33.22 154.58,33.22 154.68,33.12 154.68,32.73 154.58,32.63 154.33,32.63 v2(154.23,32.73)
  BOTTOM w0.076: UC1.AU33 132.7,82.9 v2(132.53,82.77)
  BOTTOM w0.102: JDIMM2.147 154.75,33.25 v2(154.23,32.73)
DDR_B_D42: length 68.1
  IN3 w0.089: 135.82,70.8 135.63,70.98 135.63,77.29 135.15,77.77 135.15,79.89 134.65,80.39 134.65,81.91 134.24,82.31 v2(134.24,82.74)
  IN3 w0.102: v2(157.53,31.21) 157.45,31.21 156.71,31.94 156.71,35.55 157.03,35.87 157.03,36.61 156.93,36.71 156.65,36.71 156.55,36.81 156.55,39.81 155.71,40.64 155.71,43.8 155.29,44.22 155.29,47.22 153.93,48.58 153.93,50.24 152.32,51.86 151.87,51.86 143.69,60.04 143.69,60.46 142.12,62.03 141.97,62.03 141.92,61.98 141.75,61.98 141.63,62.1 141.63,62.24 141.69,62.3 141.69,62.45 141.55,62.59 141.4,62.59 141.34,62.53 141.2,62.53 141.05,62.68 141.05,62.82 141.11,62.88 141.11,63.02 140.97,63.17 140.83,63.17 140.77,63.11 140.62,63.11 140.48,63.25 140.48,63.39 140.54,63.45 140.54,63.6 140.26,63.88 139.85,63.88 136.41,67.32 136.41,70.46 136.26,70.6 136.01,70.6 135.82,70.8
  BOTTOM w0.076: UC1.AU30 134.74,83.1 134.24,82.75 v2(134.24,82.74)
  BOTTOM w0.102: v2(157.53,31.21) 157.9,31.21 158.35,31.65 JDIMM2.159
DDR_B_D43: length 68.6
  IN3 w0.089: v2(134.26,83.44) 134.26,83.26 134.62,82.91 134.62,82.19 134.82,81.98 134.82,80.62 135.33,80.11 135.33,78.82 136.6,77.54 136.6,70.71
  IN3 w0.102: 136.6,70.71 136.71,70.6 136.71,67.87 136.89,67.7 136.89,67.56 136.82,67.49 136.82,67.34 136.96,67.2 137.11,67.2 137.17,67.27 137.32,67.27 137.46,67.12 137.46,66.98 137.39,66.91 137.39,66.77 137.54,66.62 137.68,66.62 137.75,66.69 137.89,66.69 138.04,66.55 138.04,66.4 137.97,66.34 137.97,66.19 138.11,66.05 138.26,66.05 138.32,66.12 138.47,66.12 138.75,65.83 138.75,65.69 138.68,65.62 138.68,65.48 138.83,65.33 138.97,65.33 139.04,65.4 139.18,65.4 139.33,65.26 139.33,65.12 139.26,65.05 139.26,64.9 139.4,64.76 139.55,64.76 139.61,64.83 139.76,64.83 139.9,64.68 139.9,64.54 139.83,64.47 139.83,64.33 139.98,64.18 140.12,64.18 140.19,64.25 140.33,64.25 144,60.59 144,60.16 152,52.17 152.44,52.17 154.24,50.37 154.24,48.7 155.59,47.35 155.59,44.35 156.02,43.92 156.02,40.77 157.34,39.45 157.34,39.17 157.23,39.07 157,39.07 156.9,38.97 156.9,38.76 157,38.66 157.23,38.66 157.34,38.56 157.34,38.36 157.23,38.26 157,38.26 156.9,38.15 156.9,37.95 157,37.85 157.23,37.85 157.34,37.75 157.34,37.55 157.23,37.44 157,37.44 156.9,37.34 156.9,37.14 157,37.04 157.23,37.04 157.34,36.94 157.34,35.74 157.02,35.43 157.02,32.45 157.13,32.34 157.38,32.34 157.53,32.5 v2(157.53,32.73)
  BOTTOM w0.076: UC1.AT30 134.7,83.75 134.27,83.44 v2(134.26,83.44)
  BOTTOM w0.102: v2(157.53,32.73) 157.75,32.95 JDIMM2.157
DDR_B_D44: length 70.1
  IN3 w0.089: 133.79,70.17 133.79,78.67 132.9,79.56 132.9,79.94 132.39,80.45 132.39,82.06 131.94,82.5 131.94,82.8 132.19,83.05 132.19,83.7 132.53,84.03 v2(132.53,84.04)
  IN3 w0.102: v2(154.23,31.21) 154.23,30.92 154.17,30.85 154.06,30.85 153.87,30.66 153.66,30.66 153.58,30.75 153.58,31.13 153.68,31.23 153.69,31.23 153.79,31.33 153.79,31.54 153.69,31.64 153.68,31.64 153.58,31.74 153.58,31.94 153.68,32.04 153.75,32.04 153.85,32.15 153.85,32.35 153.75,32.45 153.68,32.45 153.58,32.55 153.58,32.76 153.68,32.86 153.75,32.86 153.85,32.96 153.85,33.16 153.75,33.26 153.68,33.26 153.58,33.37 153.58,37.25 154.16,37.83 154.16,38.7 154.01,38.85 153.73,38.85 153.58,39.01 153.58,39.44 153.25,39.77 153.25,40.12 153.16,40.22 152.8,40.22 152.71,40.31 152.71,46.92 151.9,47.73 151.9,49.4 151.47,49.83 151.03,49.83 134.28,66.57 134.28,69.68 133.79,70.17
  BOTTOM w0.076: UC1.AR33 132.7,84.18 v2(132.53,84.04)
  BOTTOM w0.102: v2(154.23,31.21) 155.35,32.32 JDIMM2.149
DDR_B_D45: length 71
  IN3 w0.089: v2(132.53,84.67) 132.01,84.16 132.01,83.12 131.74,82.85 131.74,82.36 132.16,81.94 132.16,80.36 132.64,79.87 132.64,79.51 133.53,78.62 133.53,70.16
  IN3 w0.102: v2(154.23,29.68) 154.23,29.49 153.96,29.22 153.45,29.22 153.27,29.4 153.27,37.38 153.86,37.96 153.86,38.3 153.62,38.54 153.41,38.54 153.27,38.67 153.27,39.32 152.41,40.18 152.41,46.79 151.6,47.61 151.6,49.27 151.35,49.52 150.9,49.52 133.98,66.44 133.98,69.71 133.53,70.16
  BOTTOM w0.076: v2(132.53,84.67) 132.7,84.82 UC1.AP33
  BOTTOM w0.102: JDIMM2.146 154.45,27.33 153.73,28.06 153.73,29.18 v2(154.23,29.68)
DDR_B_D46: length 69.7
  IN3 w0.089: v2(134.35,84.67) 134.64,84.39 134.64,83.14 134.79,82.98 134.79,82.26 135,82.06 135,80.82 136.12,79.71 136.12,78.28 136.81,77.6 136.81,70.91
  IN3 w0.102: 136.81,70.91 137.02,70.7 137.02,68 144.3,60.71 144.3,60.29 152.12,52.47 152.57,52.47 154.54,50.5 154.54,48.83 156.32,47.05 156.32,40.89 157.64,39.57 157.64,35.62 157.32,35.3 157.32,33.52 158.12,32.72 158.12,30.27 v2(157.53,29.68)
  BOTTOM w0.076: UC1.AR30 134.36,84.67 v2(134.35,84.67)
  BOTTOM w0.102: JDIMM2.160 158.65,28.57 v2(157.53,29.68)
DDR_B_D47: length 70.1
  IN3 w0.089: 137.02,71.18 137.02,77.66 136.3,78.38 136.3,79.78 135.18,80.9 135.18,82.13 134.97,82.34 134.97,83.07 134.82,83.23 134.82,84.85 v2(134.35,85.31)
  IN3 w0.102: v2(157.53,28.16) 158.43,29.05 158.43,32.84 157.95,33.32 157.95,39.71 157.36,40.3 157.36,46.45 154.85,48.96 154.85,50.62 153.12,52.35 152.7,52.78 152.25,52.78 144.61,60.42 144.61,60.84 137.32,68.13 137.32,70.88 137.02,71.18
  BOTTOM w0.076: UC1.AP30 v2(134.35,85.31)
  BOTTOM w0.102: JDIMM2.158 158.05,27.64 v2(157.53,28.16)
DDR_B_D48: length 69.7
  IN3 w0.089: 138.63,70.78 138.63,77.56 137.07,79.12 137.07,80.05 135.89,81.23 135.89,82.54 v2(136.09,82.73)
  IN3 w0.102: 138.63,70.78 138.63,68.8 146.01,61.42 146.01,61 152.83,54.17 153.28,54.17 156.25,51.2 156.25,49.53 157.32,48.46 157.47,48.46 157.85,48.84 158.02,48.84 158.14,48.73 158.14,48.56 157.75,48.17 157.75,48.03 157.9,47.88 158.04,47.88 158.56,48.4 158.73,48.4 158.84,48.28 158.84,48.11 158.58,47.84 158.58,47.58 159.44,46.72 159.44,35.06 160.32,34.18 160.32,31.34 160.19,31.22 v2(159.9,31.22)
  BOTTOM w0.076: v2(136.09,82.73) 136.46,83.1 UC1.AU27
  BOTTOM w0.102: v2(159.9,31.22) 160.12,31.22 160.35,31.45 160.35,33.34 160.15,33.54 JDIMM2.165
DDR_B_D49: length 70.1
  IN3 w0.089: 138.33,70.76 138.33,77.57 136.89,79.01 136.89,79.98 135.71,81.16 135.71,82.35 135.69,82.38 135.69,82.89 136.12,83.32 v2(136.12,83.41)
  IN3 w0.102: 138.33,70.76 138.33,68.66 145.7,61.29 145.7,60.87 152.7,53.87 153.15,53.87 155.94,51.08 155.94,49.41 158.32,47.03 158.7,47.03 159.12,46.62 159.12,45.17 159.01,45.07 158.65,45.07 158.55,44.97 158.55,44.76 158.65,44.66 159.01,44.66 159.12,44.56 159.12,44.36 159.01,44.26 158.65,44.26 158.55,44.15 158.55,43.95 158.65,43.85 159.01,43.85 159.12,43.75 159.12,43.54 159.01,43.44 158.65,43.44 158.55,43.34 158.55,43.14 158.65,43.04 159.01,43.04 159.12,42.94 159.12,42.73 159.01,42.63 158.65,42.63 158.55,42.53 158.55,42.33 158.65,42.22 159.01,42.22 159.12,42.12 159.12,41.92 159.01,41.82 158.65,41.82 158.55,41.72 158.55,41.51 158.65,41.41 159.01,41.41 159.12,41.31 159.12,41.11 159.01,41 158.65,41 158.55,40.9 158.55,40.7 158.65,40.6 159.01,40.6 159.12,40.5 159.12,34.7 159.22,34.6 159.47,34.6 159.57,34.5 159.57,34.29 159.47,34.19 159.22,34.19 159.12,34.09 159.12,33.7 159.9,32.92 v2(159.9,32.74)
  BOTTOM w0.076: UC1.AT27 136.58,83.75 v2(136.12,83.41)
  BOTTOM w0.102: v2(159.9,32.74) 159.55,33.09 JDIMM2.163
DDR_B_D50: length 68.7
  IN3 w0.089: v2(137.06,83.43) 137.06,83.22 137.48,82.81 137.48,80.85 138.6,79.73 138.6,78.75 140.33,77.02 140.33,72.88
  IN3 w0.102: v2(163.15,31.22) 162.57,31.79 162.57,32.44 162.22,32.79 162.22,36.09 162.02,36.29 162.02,37.39 161.92,37.49 161.83,37.49 161.73,37.59 161.73,37.79 161.83,37.9 161.92,37.9 162.02,38 162.02,38.5 161.66,38.85 161.66,39.66 162.36,40.35 162.36,44.15 161.68,44.83 161.68,47.92 158.04,51.56 158.04,52.07 154.15,55.96 153.49,55.96 147.74,61.71 147.74,62.14 140.33,69.54 140.33,72.88
  BOTTOM w0.076: UC1.AT25 137.46,83.75 137.05,83.43 v2(137.06,83.43)
  BOTTOM w0.102: JDIMM2.177 163.75,31.82 v2(163.15,31.22)
DDR_B_D51: length 68.6
  IN3 w0.089: v2(137.05,82.7) 137.05,82.18 137.26,81.97 137.26,80.81 138.41,79.66 138.41,78.63 140.1,76.94 140.1,71.73
  IN3 w0.102: v2(163.15,28.17) 162.26,29.52 162.26,32.32 161.92,32.67 161.92,35.55 161.16,37.27 161.16,38.62 161.24,38.7 161.24,39.67 162.05,40.48 162.05,44.02 161.37,44.7 161.37,47.8 157.73,51.43 157.73,51.94 154.02,55.66 153.36,55.66 147.43,61.59 147.43,62.01 140.1,69.34 140.1,71.73
  BOTTOM w0.076: v2(137.05,82.7) 137.44,83.1 UC1.AU25
  BOTTOM w0.102: JDIMM2.176 163.45,27.87 v2(163.15,28.17)
DDR_B_D52: length 70.6
  IN3 w0.089: 138.06,70.77 138.06,77.57 136.71,78.92 136.71,79.9 135.54,81.08 135.54,82.28 135.49,82.32 135.49,82.95 135.74,83.21 135.74,83.74 135.81,83.8 135.81,84.3 v2(136.18,84.67)
  IN3 w0.102: v2(159.9,29.69) 159.21,30.38 159.21,33.17 158.74,33.65 158.74,40.04 158.15,40.63 158.15,44.99 158.81,45.66 158.81,46.49 158.57,46.73 158.19,46.73 155.64,49.28 155.64,50.95 153.02,53.56 152.58,53.56 145.4,60.74 145.4,61.17 138.06,68.5 138.06,70.77
  BOTTOM w0.076: UC1.AP27 v2(136.18,84.67)
  BOTTOM w0.102: v2(159.9,29.69) 159.32,29.12 159.32,28.05 159.85,27.52 JDIMM2.164
DDR_B_D53: length 70.9
  IN3 w0.089: v2(136.18,85.31) 136.18,85.31 135.8,84.93 135.8,84.65 135.63,84.48 135.63,83.87 135.57,83.81 135.57,83.29 135.31,83.04 135.31,82.25 135.36,82.2 135.36,81.01 136.53,79.83 136.53,78.47 137.22,77.79 137.22,71.42
  IN3 w0.102: v2(159.9,28.17) 159.08,28.17 158.91,28.34 158.91,33.04 158.43,33.52 158.43,39.91 157.84,40.5 157.84,46.65 155.33,49.16 155.33,50.82 152.9,53.26 152.45,53.26 145.09,60.62 145.09,61.04 137.72,68.41 137.72,70.91 137.22,71.42
  BOTTOM w0.076: UC1.AN27 v2(136.18,85.31)
  BOTTOM w0.102: v2(159.9,28.17) 160.45,27.61 JDIMM2.166
DDR_B_D54: length 71.1
  IN3 w0.089: v2(137.1,85.31) 137.42,84.99 137.42,84.65 137.62,84.45 137.62,83.17 137.96,82.83 137.96,81.05 139.6,79.41 139.61,79.41 139.9,79.11 139.9,77.97 140.96,76.91 140.96,74.41
  IN3 w0.102: 140.96,74.41 140.96,73.21 142.08,72.09 142.08,68.65 150.41,60.33 150.64,60.33 158.65,52.32 158.65,51.81 162.29,48.17 162.29,45.08 162.97,44.4 162.97,33.5 163.56,32.91 163.56,30.1 v2(163.15,29.69)
  BOTTOM w0.076: UC1.AN25 v2(137.1,85.31)
  BOTTOM w0.102: v2(163.15,29.69) 162.42,28.96 162.42,28.06 162.85,27.63 JDIMM2.174
DDR_B_D55: length 70.1
  IN3 w0.089: 140.65,72.99 140.65,76.97 138.9,78.72 138.9,79.85 137.78,80.97 137.78,82.75 137.44,83.1 137.44,84.3 v2(137.03,84.72)
  IN3 w0.102: 140.65,72.99 140.65,69.65 148.04,62.26 148.04,61.84 150.2,59.68 150.34,59.68 150.5,59.84 150.64,59.84 150.79,59.7 150.79,59.56 150.63,59.39 150.63,59.25 150.77,59.11 150.92,59.11 151.08,59.27 151.22,59.27 151.36,59.12 151.36,58.98 151.2,58.82 151.2,58.68 151.35,58.53 151.49,58.53 151.65,58.69 151.79,58.69 151.94,58.55 151.94,58.41 151.78,58.24 151.78,58.1 151.92,57.96 152.07,57.96 152.23,58.12 152.37,58.12 152.51,57.97 152.51,57.83 152.35,57.67 152.35,57.53 152.5,57.38 152.64,57.38 152.8,57.54 152.94,57.54 153.09,57.4 153.09,57.25 152.93,57.09 152.93,56.95 153.07,56.81 153.22,56.81 153.38,56.97 153.52,56.97 153.66,56.82 153.66,56.68 153.5,56.52 153.5,56.38 153.61,56.27 154.27,56.27 154.58,55.96 158.34,52.19 158.34,51.69 161.98,48.05 161.98,44.95 162.66,44.27 162.66,39.72 162.56,39.62 162.46,39.62 162.36,39.52 162.36,39.32 162.46,39.22 162.56,39.22 162.66,39.12 162.66,32.97 162.89,32.74 v2(163.15,32.74)
  BOTTOM w0.076: UC1.AP25 137.43,85.05 v2(137.03,84.72)
  BOTTOM w0.102: v2(163.15,32.74) 163.15,32.95 163.15,33.11 JDIMM2.175
DDR_B_D56: length 72.2
  IN3 w0.089: 140.46,78.41 140.46,79.46 138.49,81.42 138.49,82.85 138.92,83.28 v2(138.92,83.4)
  IN3 w0.102: v2(165.44,32.85) 165.44,32.67 164.9,32.14 164.74,32.14 164.65,32.22 164.65,32.78 165.28,33.42 165.28,33.56 165.08,33.76 164.94,33.76 164.66,33.48 164.53,33.48 164.06,33.95 164.06,34.08 164.16,34.18 164.76,34.18 164.86,34.28 164.86,34.49 164.76,34.59 164.16,34.59 164.06,34.69 164.06,34.89 164.16,34.99 164.76,34.99 164.86,35.09 164.86,35.3 164.76,35.4 164.16,35.4 164.06,35.5 164.06,35.7 164.16,35.81 164.32,35.81 164.43,35.91 164.43,36.11 164.32,36.21 164.16,36.21 164.06,36.31 164.06,44.85 163.38,45.53 163.38,48.63 159.74,52.27 159.74,52.77 151.31,61.2 151.09,61.42 150.86,61.42 147.82,64.46 147.82,64.6 147.87,64.65 147.87,64.79 147.72,64.94 147.58,64.94 147.53,64.89 147.39,64.89 147.25,65.03 147.25,65.18 147.29,65.22 147.29,65.37 147.15,65.51 147.01,65.51 146.96,65.46 146.81,65.46 146.67,65.61 146.67,65.75 146.72,65.8 146.72,65.94 146.57,66.09 146.43,66.09 146.38,66.04 146.24,66.04 146.1,66.18 146.1,66.33 146.14,66.37 146.14,66.52 146,66.66 145.85,66.66 145.81,66.62 145.66,66.62 145.52,66.76 145.52,66.9 145.57,66.95 145.57,67.09 145.42,67.24 145.28,67.24 145.23,67.19 145.09,67.19 143.18,69.1 143.18,74.19 142.04,75.33 142.04,76.82 140.46,78.41
  BOTTOM w0.076: UC1.AT22 139.38,83.73 v2(138.92,83.4)
  BOTTOM w0.102: JDIMM2.181 164.95,33.34 v2(165.44,32.85)
DDR_B_D57: length 71.9
  IN3 w0.089: 142.42,76.74 140.65,78.52 140.65,79.52 138.83,81.33 138.83,82.65 v2(138.89,82.71)
  IN3 w0.102: v2(165.44,31.33) 165.79,31.33 165.9,31.22 165.9,29.48 166,29.38 166.23,29.38 166.33,29.48 166.33,31.48 165.84,31.97 165.84,33.43 165.17,34.1 165.17,35.8 164.36,36.61 164.36,44.98 163.68,45.66 163.68,48.75 160.05,52.39 160.05,52.9 151.22,61.73 150.98,61.73 148.49,64.22 148.49,64.6 143.48,69.61 143.48,74.32 142.42,75.38 142.42,76.74
  BOTTOM w0.076: UC1.AU22 139.28,83.1 v2(138.89,82.71)
  BOTTOM w0.102: v2(165.44,31.33) 165.9,31.79 165.9,33.38 165.55,33.73 JDIMM2.183
DDR_B_D58: length 70.8
  IN3 w0.089: 142.53,78.75 142.32,78.96 141.64,78.96 141.31,79.29 141.31,80.1 140.07,81.33 140.07,82.57 v2(139.87,82.77)
  IN3 w0.102: v2(168.89,32.85) 168.48,32.45 168.48,31.8 168.35,31.67 168.16,31.67 167.8,32.03 167.8,32.17 168.14,32.5 168.14,32.65 167.99,32.79 167.85,32.79 167.51,32.46 167.37,32.46 167.27,32.56 167.27,33.23 167.37,33.33 168.13,33.33 168.23,33.44 168.23,33.64 168.13,33.74 167.37,33.74 167.27,33.84 167.27,34.02 166.59,34.7 166.59,35.14 166.7,35.24 166.85,35.24 166.95,35.34 166.95,35.54 166.85,35.64 166.7,35.64 166.59,35.74 166.59,36.68 166.45,36.82 166.45,41.19 165.79,41.86 165.79,45.57 165.11,46.25 165.11,49.35 161.47,52.98 161.47,53.49 158.64,56.32 158.64,56.73 156.47,58.9 156.2,58.9 147.89,67.22 147.89,68.02 145.02,70.89 145.02,76.27 142.53,78.75
  BOTTOM w0.076: UC1.AU21 140.2,83.1 v2(139.87,82.77)
  BOTTOM w0.102: v2(168.89,32.85) 168.55,33.19 JDIMM2.193
DDR_B_D59: length 71.8
  IN3 w0.089: 140.31,81.48 140.31,82.89 139.87,83.34 v2(139.87,83.41)
  IN3 w0.102: 140.31,81.48 145.32,76.46 145.32,74.64 145.42,74.54 145.52,74.54 145.62,74.44 145.62,74.24 145.52,74.13 145.42,74.13 145.32,74.03 145.32,73.83 145.42,73.73 145.88,73.73 145.98,73.63 145.98,73.42 145.88,73.32 145.42,73.32 145.32,73.22 145.32,73.02 145.42,72.91 145.88,72.91 145.98,72.81 145.98,72.61 145.88,72.51 145.42,72.51 145.32,72.41 145.32,71.02 148.19,68.15 148.19,67.34 156.24,59.3 156.52,59.3 158.95,56.87 158.95,56.45 161.78,53.62 161.78,53.11 165.41,49.47 165.41,46.38 166.09,45.7 166.09,42.96 166.76,42.29 166.76,37.01 167.41,36.35 167.41,34.91 169.3,33.02 169.3,31.36 169.18,31.25 168.97,31.25 v2(168.89,31.33)
  BOTTOM w0.076: v2(139.87,83.41) 140.21,83.75 UC1.AT21
  BOTTOM w0.102: v2(168.89,31.33) 167.95,32.27 JDIMM2.191
DDR_B_D60: length 73.8
  IN3 w0.089: 141.28,75.8 141.28,76.87 140.08,78.07 140.08,79.27 138.14,81.21 138.14,83 138.36,83.22 138.36,83.67 138.53,83.84 138.53,84.91 v2(138.93,85.31)
  IN3 w0.102: v2(165.44,28.28) 165.44,27.77 165.13,27.46 164.05,27.46 163.72,27.79 163.72,29.58 164.04,29.9 164.04,33.11 163.45,33.7 163.45,44.6 162.77,45.28 162.77,48.38 159.13,52.01 159.13,52.52 150.84,60.81 150.61,60.81 142.57,68.85 142.57,73.57 141.28,74.86 141.28,75.8
  BOTTOM w0.076: UC1.AN22 139.33,85.66 v2(138.93,85.31)
  BOTTOM w0.102: JDIMM2.182 165.25,28.1 v2(165.44,28.28)
DDR_B_D61: length 73.6
  IN3 w0.089: v2(138.93,84.67) 138.71,84.45 138.71,83.77 138.54,83.6 138.54,83.15 138.32,82.93 138.32,81.31 140.26,79.37 140.26,78.25 141.66,76.84
  IN3 w0.102: v2(165.44,29.8) 165.13,29.8 165.03,29.7 165.03,28.9 164.93,28.79 164.13,28.79 164.03,28.9 164.03,29.46 164.34,29.77 164.34,33.24 163.75,33.83 163.75,44.73 163.07,45.41 163.07,48.5 159.44,52.14 159.44,52.65 150.97,61.12 150.73,61.12 142.87,68.98 142.87,74 141.66,75.21 141.66,76.84
  BOTTOM w0.076: UC1.AP22 v2(138.93,84.67)
  BOTTOM w0.102: v2(165.44,29.8) 164.65,29.02 JDIMM2.180
DDR_B_D62: length 72.5
  IN3 w0.089: 140.9,81.77 140.9,83.37 140.39,83.88 140.39,84.4 v2(140.7,84.7)
  IN3 w0.102: v2(168.89,28.28) 169.7,28.28 169.91,28.49 169.91,33.27 168.02,35.16 168.02,36.61 167.37,37.26 167.37,43.12 167.27,43.23 166.8,43.23 166.7,43.33 166.7,43.74 166.81,43.85 166.81,44.38 166.7,44.48 166.7,45.95 166.02,46.63 166.02,49.72 162.38,53.36 162.38,53.87 159.6,56.66 159.6,57.11 156.77,59.94 156.47,59.94 148.8,67.6 148.8,68.4 146.6,70.6 146.6,76.08 140.9,81.77
  BOTTOM w0.102: UC1.AP21 140.34,85.05 v2(140.7,84.7) ; JDIMM2.194 168.85,28.24 v2(168.89,28.28)
DDR_B_D63: length 73.8
  IN3 w0.089: v2(139.84,85.31) 140.21,84.93 140.21,83.73 140.63,83.31 140.63,81.58
  IN3 w0.102: v2(168.89,29.8) 169.42,29.8 169.6,29.99 169.6,33.15 167.71,35.04 167.71,36.48 167.06,37.13 167.06,42.42 166.4,43.09 166.4,45.82 165.72,46.5 165.72,49.6 162.08,53.24 162.08,53.75 159.28,56.54 159.28,56.98 156.65,59.62 156.35,59.62 148.5,67.47 148.5,68.27 146.3,70.48 146.3,74.27 146.2,74.37 146.03,74.37 145.93,74.47 145.93,74.67 146.03,74.77 146.2,74.77 146.3,74.88 146.3,75.08 146.2,75.18 145.73,75.18 145.63,75.28 145.63,75.49 145.73,75.59 145.76,75.59 145.92,75.75 145.92,76.3 140.63,81.58
  BOTTOM w0.076: UC1.AN21 v2(139.84,85.31)
  BOTTOM w0.102: JDIMM2.192 168.25,29.17 v2(168.89,29.8)
DDR_B_DQS0: length 82.8
  IN3 w0.102: v2(115.11,87.81) 115.01,87.81 114.67,87.47 114.28,87.47 113.99,87.18 113.39,87.18 110.1,83.89 110.1,83.58 108.98,82.46 107.45,82.46 106.57,81.59 106.57,79.58 105.47,78.48 105.47,77.36 104.17,76.07 104.17,53.82 105.12,52.87 105.12,52.56 104.79,52.23 104.79,52.09 105.01,51.87 105.15,51.87 105.48,52.2 105.79,52.2 106.13,51.86 106.13,51.55 105.8,51.22 105.8,51.08 106.02,50.86 106.16,50.86 106.49,51.19 106.8,51.19 107.14,50.85 107.14,50.54 106.81,50.21 106.81,50.07 107.03,49.85 107.17,49.85 107.5,50.18 107.81,50.18 108.15,49.84 108.15,49.53 107.82,49.2 107.82,49.06 108.04,48.84 108.18,48.84 108.51,49.17 108.83,49.17 109.16,48.83 109.16,48.52 108.84,48.19 108.84,48.05 109.05,47.83 109.19,47.83 109.52,48.16 109.84,48.16 110.17,47.82 110.17,47.51 109.85,47.18 109.85,47.04 110.48,46.4 110.48,45.97 110.27,45.75 110.27,44.79 110.37,44.69 110.69,44.69 110.91,44.47 110.91,43.99 110.69,43.77 110.37,43.77 110.27,43.67 110.27,43.36 110.37,43.26 110.69,43.26 110.91,43.04 110.91,42.56 110.69,42.34 110.14,42.34 110.02,42.21 110.02,41.96 110.14,41.83 110.69,41.83 110.91,41.61 110.91,40 114.2,36.71 114.2,35.17 115.82,33.56 115.82,31.39 115.92,31.3 116.73,31.3 116.83,31.39 v2(116.83,31.6)
  BOTTOM w0.076: v2(115.11,87.81) 115.11,87.97 UC1.AH65
  BOTTOM w0.102: JDIMM2.29 116.95,33.55 116.11,32.71 116.11,31.43 116.27,31.27 116.74,31.27 116.83,31.36 v2(116.83,31.6)
DDR_B_DQS1: length 84.9
  IN3 w0.102: v2(106.41,88.31) 106.6,88.31 106.7,88.41 106.7,88.47 106.8,88.57 106.8,88.7 106.71,88.79 105.53,88.79 104.48,87.74 100.59,87.74 96.36,83.51 96.36,78.02 100.44,73.95 100.44,51.16 105,46.59 105,39.79 106.42,38.37 106.42,37.14 110.03,33.52 110.03,30.57 110.65,29.95 110.93,29.95 111.06,30.08 v2(111.06,30.33)
  BOTTOM w0.076: v2(106.41,88.31) 106.6,88.5 106.6,88.71 106.83,88.94 109.31,88.94 109.66,88.6 110.72,88.6 110.74,88.58 111.57,88.58 111.74,88.51 111.85,88.51 112,88.57 112.2,88.57 112.41,88.52 112.54,88.52 112.64,88.56 112.7,88.62 112.7,88.71 112.61,88.8 UC1.AG70
  BOTTOM w0.102: JDIMM2.12 111.85,27.81 111.89,27.85 111.89,29.16 111.72,29.33 111.72,29.67 v2(111.06,30.33)
DDR_B_DQS2: length 69.6
  IN3 w0.102: v2(115.09,84.72) 114.92,84.54 114.67,84.54 114.44,84.31 114.44,83.86 114.55,83.75 114.55,82.06 114.24,81.74 112.98,81.74 112.13,80.89 112.13,80.35 110.9,79.12 110.14,79.12 108.77,77.75 108.77,74.7 108.5,74.44 108.5,63.93 109.27,63.16 109.27,53.82 116.53,46.56 116.53,39.84 118.52,37.85 118.52,35.85 118.88,35.5 119.54,35.5 121.53,33.51 121.53,31.19 121.79,30.93 122.2,30.93 v2(122.29,30.84)
  BOTTOM w0.076: UC1.AR65 115.4,84.4 v2(115.09,84.72)
  BOTTOM w0.102: v2(122.29,30.84) 122.47,31.02 122.7,31.02 122.93,31.25 122.93,32.6 122.35,33.18 JDIMM2.47
DDR_B_DQS3: length 68.8
  IN3 w0.102: v2(128.14,29.31) 127.99,29.47 127.73,29.47 127.32,29.88 127.32,33.57 123.02,37.88 123.02,38.65 121.12,40.55 121.12,47.26 113.29,55.09 113.29,72.53 113.43,72.67 113.43,76.92 113.8,77.28 114.3,77.28 116.31,79.29 116.31,80.07 117.45,81.2 117.45,82.14 117.42,82.17 117.42,83.56 117.27,83.71 117.27,84.29 117.53,84.55 117.72,84.55 v2(117.87,84.69)
  BOTTOM w0.076: UC1.AR60 118.15,84.4 v2(117.87,84.69)
  BOTTOM w0.102: v2(128.14,29.31) 127.87,29.58 127.33,29.58 127.24,29.5 127.24,27.86 127.45,27.65 JDIMM2.64
DDR_B_DQS4: length 68.4
  IN3 w0.102: v2(129.85,84.09) 129.77,84.01 129.43,84.01 129.25,83.83 129.25,82.38 129.68,81.95 129.68,80.88 131.11,79.46 131.11,78.33 131.36,78.07 131.36,68.61 131.64,68.33 131.64,65.65 148.77,48.52 148.77,40.69 150.5,38.96 150.5,35.45 149.84,34.78 149.84,31.19 150.13,30.89 150.62,30.89 v2(150.68,30.84)
  BOTTOM w0.076: UC1.AR38 v2(129.85,84.09)
  BOTTOM w0.102: v2(150.68,30.84) 150.88,31.04 151.07,31.04 151.32,31.28 151.32,32.92 151.75,33.35 JDIMM2.137
DDR_B_DQS5: length 69.5
  IN3 w0.102: v2(155.71,30.06) 155.81,29.96 156.17,29.96 156.38,30.18 156.38,31.13 155.9,31.61 155.9,36.31 155.53,36.68 155.53,39.22 154.47,40.28 154.47,46.89 153.12,48.24 153.12,49.9 151.98,51.05 151.53,51.05 135.59,66.99 135.59,70.26 135.22,70.63 135.22,76.94 134.64,77.52 134.64,79.26 134.65,79.27 134.65,79.57 134.64,79.58 134.64,79.68 134.12,80.2 134.12,80.4 134.12,80.98 133.67,81.44 133.67,83.66 133.78,83.77 133.78,84 133.74,84.04 v2(133.44,84.04)
  BOTTOM w0.076: v2(133.44,84.04) 133.53,84.04 UC1.AR32
  BOTTOM w0.102: v2(155.71,30.06) 155.92,29.86 155.96,29.82 156.25,29.82 156.46,29.61 156.46,27.77 156.85,27.38 JDIMM2.154
DDR_B_DQS6: length 69.9
  IN3 w0.102: v2(161.65,30.84) 161.39,31.09 161.17,31.09 160.93,31.33 160.93,34.43 160.25,35.11 160.25,38.83 160.42,39 160.42,41.75 160.1,42.07 160.1,47.91 156.86,51.16 156.86,51.67 153.68,54.84 153.02,54.84 146.61,61.25 146.61,61.67 138.99,69.29 138.99,77.5 137.36,79.13 137.36,80.07 136.2,81.23 136.2,82.14 136.47,82.4 136.47,83.11 136.49,83.13 136.49,83.73 v2(136.18,84.04)
  BOTTOM w0.076: v2(136.18,84.04) UC1.AR27
  BOTTOM w0.102: JDIMM2.171 161.95,33.56 161.91,33.52 161.91,33.11 162.5,32.52 162.5,31.34 162.17,31.02 161.84,31.02 v2(161.65,30.84)
DDR_B_DQS7: length 72.5
  IN3 w0.102: v2(139.84,84.04) 139.84,84.2 139.72,84.32 139.46,84.32 139.31,84.18 139.31,83.87 139.49,83.7 139.49,82.4 139.88,82.01 139.88,81.08 141.04,79.92 141.04,79.22 143.52,76.75 143.52,75.64 144.41,74.75 144.41,70.59 147.28,67.72 147.28,66.97 149.31,64.94 149.31,64.56 151.32,62.54 151.56,62.54 160.86,53.24 160.86,52.73 164.5,49.09 164.5,46 165.18,45.32 165.18,37.23 165.98,36.42 165.98,34.44 166.66,33.77 166.66,32.31 167.61,31.35 167.61,29.99 167.4,29.79 167.09,29.79 166.96,29.66 v2(166.96,29.42)
  BOTTOM w0.076: v2(139.84,84.04) 140.2,84.4 UC1.AR21
  BOTTOM w0.102: JDIMM2.188 167.05,27.59 166.92,27.72 166.92,27.94 166.34,28.52 166.34,29.41 166.55,29.63 166.88,29.63 166.96,29.54 v2(166.96,29.42)
DDR_B_DQS#0: length 82.7
  IN3 w0.102: v2(114.45,87.84) 114.34,87.74 114.28,87.67 114.19,87.67 113.9,87.38 113.31,87.38 109.9,83.97 109.9,83.67 108.9,82.67 107.36,82.67 106.37,81.67 106.37,79.67 105.26,78.56 105.26,77.45 103.97,76.15 103.97,53.73 104.91,52.79 104.91,52.64 104.59,52.32 104.59,52 104.92,51.67 105.24,51.67 105.56,51.99 105.71,51.99 105.92,51.78 105.92,51.63 105.6,51.31 105.6,50.99 105.93,50.66 106.25,50.66 106.58,50.98 106.72,50.98 106.94,50.77 106.94,50.62 106.61,50.3 106.61,49.98 106.94,49.65 107.26,49.65 107.59,49.97 107.73,49.97 107.95,49.76 107.95,49.61 107.62,49.29 107.62,48.97 107.95,48.64 108.27,48.64 108.6,48.96 108.74,48.96 108.96,48.75 108.96,48.6 108.63,48.27 108.63,47.96 108.97,47.62 109.28,47.62 109.61,47.95 109.75,47.95 109.97,47.73 109.97,47.59 109.64,47.26 109.64,46.95 110.28,46.31 110.28,46.05 110.06,45.84 110.06,44.7 110.29,44.48 110.61,44.48 110.71,44.38 110.71,44.08 110.61,43.97 110.29,43.97 110.06,43.75 110.06,43.28 110.29,43.05 110.61,43.05 110.71,42.95 110.71,42.65 110.61,42.55 110.06,42.55 109.81,42.3 109.81,41.87 110.06,41.63 110.61,41.63 110.71,41.53 110.71,39.91 114,36.62 114,35.09 115.62,33.47 115.62,31.31 115.83,31.09 116.76,31.09 116.83,31.02 v2(116.83,30.84)
  BOTTOM w0.076: UC1.AH66 114.45,87.96 v2(114.45,87.84)
  BOTTOM w0.102: JDIMM2.27 116.35,33.67 116.48,33.54 116.48,33.38 115.9,32.8 115.9,31.34 116.19,31.06 116.61,31.06 v2(116.83,30.84)
DDR_B_DQS#1: length 84.9
  IN3 w0.102: v2(111.06,29.57) 110.88,29.74 110.56,29.74 109.83,30.48 109.83,33.44 106.21,37.05 106.21,38.29 104.8,39.7 104.8,46.51 100.23,51.07 100.23,73.86 96.16,77.93 96.16,83.59 100.51,87.94 104.39,87.94 105.44,88.99 106.8,88.99 107,88.79 107,88.37 v2(107.06,88.31)
  BOTTOM w0.076: UC1.AG69 112.81,88.5 112.74,88.43 112.62,88.37 112.58,88.35 112.38,88.35 112.18,88.41 112.03,88.41 111.89,88.35 111.71,88.35 111.54,88.42 109.58,88.42 109.24,88.76 106.91,88.76 106.78,88.64 106.78,88.52 106.99,88.31 v2(107.06,88.31)
  BOTTOM w0.102: JDIMM2.10 111.25,27.53 111.68,27.97 111.68,29.08 111.51,29.25 111.51,29.53 111.42,29.62 111.25,29.62 111.19,29.57 v2(111.06,29.57)
DDR_B_DQS#2: length 69.5
  IN3 w0.102: v2(115.11,84.07) 115.11,84.21 114.97,84.35 114.75,84.35 114.63,84.23 114.63,83.94 114.75,83.83 114.75,81.96 114.33,81.54 113.07,81.54 112.33,80.8 112.33,80.26 110.99,78.92 110.23,78.92 108.97,77.67 108.97,74.62 108.71,74.36 108.71,64.01 109.48,63.24 109.48,53.9 116.74,46.65 116.74,39.93 118.72,37.94 118.72,35.94 118.96,35.7 119.63,35.7 121.73,33.6 121.73,31.27 121.87,31.13 122.01,31.13 122.12,31.24 122.28,31.24 122.38,31.35 122.38,31.5 v2(122.29,31.6)
  BOTTOM w0.076: UC1.AR66 114.78,84.4 v2(115.11,84.07)
  BOTTOM w0.102: v2(122.29,31.6) 122.29,31.34 122.4,31.23 122.61,31.23 122.72,31.33 122.72,32.52 122.14,33.1 122.14,33.54 122.06,33.63 121.83,33.63 121.75,33.71 JDIMM2.45
DDR_B_DQS#3: length 68.8
  IN3 w0.102: v2(117.87,84.05) 117.87,84.18 117.71,84.34 117.62,84.34 117.48,84.2 117.48,83.8 117.63,83.65 117.63,82.25 117.65,82.23 117.65,81.12 116.52,79.98 116.52,79.2 114.39,77.08 113.88,77.08 113.64,76.83 113.64,72.59 113.49,72.45 113.49,55.18 121.33,47.34 121.33,40.63 123.22,38.74 123.22,37.96 127.53,33.65 127.53,29.96 127.82,29.67 127.96,29.67 128.14,29.86 v2(128.14,30.07)
  BOTTOM w0.076: UC1.AR61 117.52,84.4 v2(117.87,84.05)
  BOTTOM w0.102: v2(128.14,30.07) 127.86,29.79 127.24,29.79 127.04,29.59 127.04,27.91 126.85,27.72 JDIMM2.62
DDR_B_DQS#4: length 68.4
  IN3 w0.102: v2(129.86,83.48) 129.86,83.64 129.77,83.73 129.7,83.73 129.62,83.81 129.52,83.81 129.45,83.75 129.45,82.47 129.89,82.03 129.89,80.97 131.31,79.55 131.31,78.41 131.57,78.16 131.57,68.69 131.85,68.42 131.85,65.73 148.98,48.6 148.98,40.77 150.71,39.04 150.71,35.36 150.04,34.7 150.04,31.27 150.22,31.1 150.36,31.1 150.51,31.24 150.62,31.24 150.69,31.31 150.69,31.58 v2(150.68,31.6)
  BOTTOM w0.076: v2(129.86,83.48) 130.22,83.75 UC1.AT38
  BOTTOM w0.102: v2(150.68,31.6) 150.68,31.32 150.75,31.25 150.99,31.25 151.11,31.37 151.11,33.01 151.5,33.4 151.5,33.5 151.42,33.58 151.21,33.58 151.15,33.65 JDIMM2.135
DDR_B_DQS#5: length 69.5
  IN3 w0.102: v2(134.26,84.08) 134.03,84.08 133.99,84.03 133.99,83.68 133.9,83.59 133.9,83.58 133.87,83.56 133.87,81.52 134.33,81.07 134.33,80.49 134.33,80.29 134.85,79.77 134.85,79.66 134.86,79.66 134.86,79.18 134.85,79.18 134.85,77.61 135.43,77.03 135.43,70.71 135.8,70.35 135.8,67.07 151.62,51.25 152.06,51.25 153.33,49.99 153.33,48.32 154.68,46.97 154.68,40.36 155.73,39.3 155.73,36.76 156.1,36.39 156.1,31.69 156.58,31.21 156.58,30.09 156.25,29.76 155.97,29.76 155.87,29.66 155.77,29.66 155.71,29.59 v2(155.71,29.3)
  BOTTOM w0.076: UC1.AT32 134.22,84.08 v2(134.26,84.08)
  BOTTOM w0.102: JDIMM2.152 156.25,29.52 156.16,29.61 156,29.61 156,29.6 v2(155.71,29.3)
