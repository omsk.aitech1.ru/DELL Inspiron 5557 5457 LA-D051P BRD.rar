# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_B_DQS#6: length 69.9
  IN3 w0.102: v2(161.65,31.6) 161.65,31.47 161.47,31.3 161.26,31.3 161.14,31.42 161.14,34.52 160.46,35.19 160.46,38.75 160.63,38.92 160.63,41.83 160.31,42.15 160.31,48 157.06,51.24 157.06,51.75 153.77,55.05 153.11,55.05 146.82,61.33 146.82,61.76 139.2,69.38 139.2,77.58 137.57,79.21 137.57,80.16 136.41,81.32 136.41,82.05 136.67,82.32 136.67,83.02 136.69,83.05 136.69,83.77 v2(137.01,84.08)
  BOTTOM w0.076: UC1.AR25 137.41,84.4 v2(137.01,84.08)
  BOTTOM w0.102: v2(161.65,31.6) 161.65,31.35 161.77,31.23 162.09,31.23 162.29,31.43 162.29,32.43 161.7,33.02 161.7,33.53 161.65,33.58 161.43,33.58 161.35,33.66 JDIMM2.169
DDR_B_DQS#7: length 72.5
  IN3 w0.102: v2(166.96,30.19) 167.15,29.99 167.32,29.99 167.41,30.08 167.41,31.27 166.45,32.22 166.45,33.69 165.78,34.36 165.78,36.34 164.97,37.15 164.97,45.23 164.29,45.91 164.29,49.01 160.66,52.65 160.66,53.15 151.47,62.34 151.24,62.34 149.1,64.47 149.1,64.85 147.07,66.88 147.07,67.63 144.2,70.5 144.2,74.67 143.31,75.56 143.31,76.66 140.84,79.14 140.84,79.84 139.68,81 139.68,81.93 139.29,82.32 139.29,83.63 139.12,83.79 139.12,84.25 139.38,84.51 139.68,84.51 v2(139.84,84.67)
  BOTTOM w0.076: UC1.AR22 139.57,84.4 v2(139.84,84.67)
  BOTTOM w0.102: JDIMM2.186 166.45,27.49 166.67,27.71 166.67,27.9 166.13,28.43 166.13,29.5 166.47,29.84 166.77,29.84 166.96,30.02 v2(166.96,30.19)
DDR_B_MA0: length 69.7
  IN3 w0.165: v2(124.23,71.05) 124.23,68.71 123.34,67.82 123.34,59.62 136.85,46.11 136.85,40.4 138.33,38.92 138.33,37.56 140.14,35.75 140.14,28.56 140.75,27.96 140.75,27.12 140.43,26.8 137.79,26.8 137.64,26.95 137.64,27.36 137.79,27.51 139.3,27.51 v2(139.7,27.91)
  BOTTOM w0.076: UC1.BA46 126.32,80.46 126.59,80.19 126.59,79.85 126.45,79.71 126.45,79.06 126.12,78.72 126.12,77.46 125.89,77.24 125.89,76.71 125.78,76.61 125.78,76.07
  BOTTOM w0.102: 125.78,76.07 125.78,74
  BOTTOM w0.165: 125.78,74 125.78,72.61 v1(125.07,71.89) v2(124.23,71.05) ; v2(139.7,27.91) 140.05,27.57 JDIMM2.98
DDR_B_MA1: length 70.7
  IN3 w0.165: v2(139.7,31.72) 139.38,31.72 139.16,31.94 139.16,33.55 139.28,33.67 139.28,34.54 139.16,34.66 138.97,34.66 138.81,34.51 138.6,34.51 138.29,34.81 138.29,35.03 138.88,35.61 138.88,35.82 138.63,36.08 138.41,36.08 137.84,35.5 137.6,35.5 137.49,35.61 137.49,36.3 137.82,36.62 137.82,36.89 137.49,37.21 137.49,38.52 134.92,41.1 134.92,46.77 134.17,47.52 132.51,47.52 132.09,47.94 131.19,47.94 130.39,48.73 130.39,51.03 121.84,59.58 121.84,62.06 122,62.23 122.35,62.23 122.5,62.38 122.5,62.74 122.35,62.89 121.99,62.89 121.84,63.04 121.84,63.4 121.99,63.55 122.35,63.55 122.5,63.7 122.5,64.06 122.35,64.21 121.99,64.21 121.84,64.36 121.84,64.72 121.99,64.87 122.35,64.87 122.5,65.02 122.5,65.38 122.35,65.53 121.99,65.53 121.84,65.68 121.84,66.04 121.99,66.19 122.35,66.19 122.5,66.34 122.5,66.7 122.35,66.85 122,66.85 121.84,67.02 121.84,67.51 123.56,69.23 123.56,72.94 v2(123.98,73.36)
  BOTTOM w0.076: 125.16,76.04 125.16,76.53 125.38,76.75 125.38,77.51 125.69,77.83 125.69,78.76 126.12,79.2 126.12,79.78 126.06,79.85 126.06,80.09 126.11,80.21 126.11,80.35 126.05,80.58 126.05,80.71 126.12,80.93 126.23,81.03 UC1.AY46
  BOTTOM w0.102: 125.16,76.04 125.16,74.54 v2(123.98,73.36)
  BOTTOM w0.165: JDIMM2.97 139.75,33.81 139.87,33.69 139.88,33.69 140.14,33.43 140.14,33.42 140.22,33.34 140.22,32.24 v2(139.7,31.72)
DDR_B_MA2: length 70.6
  IN3 w0.089: v2(123.94,73.94) 123.76,73.94 123.31,73.49 123.31,69.57
  IN3 w0.165: v2(139.7,29.44) 139.7,29.3 139.17,28.77 139.17,28.59 138.51,27.93 138.26,27.93 138.03,28.16 138.03,28.6 138.96,29.52 138.96,30.18 138.74,30.4 138.74,33.77 137.07,35.44 137.07,38.35 134.5,40.92 134.5,46.6 133.99,47.1 132.33,47.1 131.91,47.52 131.01,47.52 129.97,48.56 129.97,50.86 121.42,59.41 121.42,67.68 123.31,69.57
  BOTTOM w0.076: UC1.AY47 125.93,81.31 125.93,80.88 125.88,80.72 125.88,80.58 125.94,80.36 125.94,80.24 125.91,80.16 125.89,80.13 125.89,79.77 125.96,79.7 125.96,79.26 125.43,78.74 125.43,77.95 125.08,77.59 125.08,76.94 124.89,76.75 124.89,74.89 v2(123.94,73.94)
  BOTTOM w0.165: JDIMM2.96 139.45,27.33 139.09,27.69 139.09,28.83 v2(139.7,29.44)
DDR_B_MA3: length 68.8
  IN3 w0.089: v2(124.01,72.23) 123.86,72.08 123.86,68.93
  IN3 w0.165: v2(139.7,33.25) 139.7,35.59 137.91,37.38 137.91,38.75 135.34,41.32 135.34,41.53 135.5,41.69 135.83,41.69 135.99,41.84 135.99,42.2 135.83,42.35 135.49,42.35 135.34,42.5 135.34,42.86 135.49,43.01 135.82,43.01 135.97,43.16 135.97,43.52 135.82,43.67 135.49,43.67 135.34,43.82 135.34,44.18 135.49,44.33 135.83,44.33 135.98,44.48 135.98,44.84 135.83,44.99 135.49,44.99 135.34,45.14 135.34,45.5 135.49,45.65 135.91,45.65 136.06,45.81 136.06,46.16 135.91,46.31 135.5,46.31 135.34,46.48 135.34,46.94 134.34,47.94 134.03,47.94 133.88,48.09 133.88,48.49 133.73,48.65 133.37,48.65 133.22,48.49 133.22,48.04 133.12,47.94 132.68,47.94 132.4,48.21 132.4,49.97 132.25,50.12 131.84,50.12 131.69,49.97 131.69,48.51 131.53,48.35 131.36,48.35 130.81,48.91 130.81,51.21 122.92,59.09 122.92,59.57 122.77,59.72 122.41,59.72 122.26,59.87 122.26,60.28 122.41,60.43 122.77,60.43 122.92,60.59 122.92,60.94 122.77,61.09 122.41,61.09 122.26,61.25 122.26,61.66 122.41,61.81 122.77,61.81 122.92,61.97 122.92,68 123.86,68.93
  BOTTOM w0.076: UC1.BB46 126.29,79.95 126.29,79.13 125.92,78.75 125.92,77.63 125.65,77.37 125.65,76.73 125.49,76.57 125.49,76.11
  BOTTOM w0.102: 125.33,74.25 125.49,74.41 125.49,76.11
  BOTTOM w0.165: JDIMM2.95 139.15,33.45 139.35,33.25 v2(139.7,33.25) ; v2(124.01,72.23) 124.01,72.23 125.09,73.31 125.09,74.01 125.33,74.25
DDR_B_MA4: length 69.6
  IN3 w0.089: v2(123.92,75.09) 123.61,75.09 123.12,74.59 123.12,69.97 122.54,69.39
  IN3 w0.165: 122.54,69.39 122.54,69.39 121,67.85 121,59.24 129.55,50.68 129.55,48.38 130.84,47.1 131.74,47.1 132.16,46.68 133.82,46.68 134.08,46.42 134.08,40.75 134.47,40.35 134.47,40.12 134.22,39.87 134.22,39.63 134.45,39.4 134.68,39.4 134.94,39.65 135.17,39.65 136.13,38.69 136.13,35.79 138.31,33.61 138.31,31.86 138.16,31.7 137.99,31.7 137.84,31.55 137.84,31.17 137.99,31.02 138.13,31.02 138.3,30.85 138.3,30.25 138.54,30.01 138.54,29.7 138.18,29.34 138.01,29.34 137.85,29.49 137.85,29.76 v2(137.42,30.2)
  BOTTOM w0.076: 124.68,76.49 124.68,76.89 124.83,77.04 124.83,77.69 125.17,78.03 125.17,79.52 125.43,79.78 125.43,80.12 125.43,80.12 125.39,80.21 125.39,80.41 125.43,80.5 125.43,80.5 125.43,80.5 125.44,80.51 125.44,80.74 UC1.BA47
  BOTTOM w0.102: 124.68,76.49 124.68,75.85 v2(123.92,75.09)
  BOTTOM w0.165: JDIMM2.92 138.25,27.42 138.38,27.55 138.38,29.24 v2(137.42,30.2)
DDR_B_MA5: length 70.3
  IN3 w0.089: v2(123.93,75.68) 123.62,75.68 122.93,74.99 122.93,71.05 120.62,68.74
  IN3 w0.165: v2(137.42,31.72) 137.9,32.2 137.9,33.43 135.71,35.61 135.71,38.52 135.54,38.7 134.55,38.7 133.64,39.61 133.64,40.22 133.47,40.39 133.25,40.39 132.69,39.82 132.47,39.82 132.13,40.17 132.13,40.39 132.83,41.09 133.05,41.09 133.21,41.24 133.21,41.61 133.05,41.76 132.93,41.76 132.78,41.91 132.78,42.35 132.93,42.5 133.09,42.5 133.24,42.65 133.24,43.01 133.09,43.16 132.93,43.16 132.78,43.31 132.78,43.67 132.93,43.82 133.05,43.82 133.2,43.97 133.2,44.33 133.05,44.48 131.86,44.48 131.7,44.63 131.7,44.99 131.86,45.14 133.05,45.14 133.2,45.29 133.2,45.65 133.05,45.8 131.88,45.8 131.72,45.97 131.72,46.53 131.57,46.68 130.67,46.68 129.13,48.21 129.13,50.51 120.58,59.06 120.58,68.7 120.62,68.74
  BOTTOM w0.076: v2(123.93,75.68) 124.35,76.1 124.35,76.94 124.55,77.14 124.55,77.78 124.93,78.16 124.93,79.51 125.27,79.85 125.27,80.09 125.23,80.18 125.23,80.19 125.23,80.44 125.27,80.53 125.27,80.74 125.23,80.82 125.23,80.82 125.2,80.92 125.2,81.09 UC1.AY48
  BOTTOM w0.165: JDIMM2.91 137.95,32.26 v2(137.42,31.72)
DDR_B_MA6: length 68.9
  IN3 w0.089: 121.73,71.04 122.47,71.77 122.47,75.34 122.47,75.35 122.47,76.1 v2(123.92,77.55)
  IN3 w0.165: v2(137.42,28.68) 137.12,28.68 136.98,28.53 136.98,28.17 136.83,28.02 136.24,28.02 136.09,28.17 136.09,29.3 136.29,29.5 136.81,29.5 136.98,29.67 136.98,30 136.81,30.16 136.58,30.16 136.41,30.33 136.41,30.66 136.58,30.82 136.81,30.82 136.98,30.99 136.98,31.32 136.81,31.49 136.58,31.49 136.41,31.65 136.41,31.98 136.58,32.15 136.81,32.15 136.98,32.31 136.98,32.64 136.81,32.81 136.58,32.81 136.41,32.97 136.41,33.73 133.96,36.19 133.96,38.11 133.08,38.99 132.1,38.99 130.1,40.98 130.1,46.04 128.3,47.85 128.3,50.16 119.74,58.72 119.74,69.05 121.73,71.04
  BOTTOM w0.076: v2(123.92,77.55) 123.92,77.82 124.54,78.44 124.54,79.95 125,80.41 UC1.BA48
  BOTTOM w0.165: JDIMM2.90 137.65,27.45 137.88,27.69 137.88,28.21 v2(137.42,28.68)
DDR_B_MA7: length 72.3
  IN3 w0.089: v2(125.16,84.7) 124.76,84.3 124.76,82.64 124.07,81.95 124.07,81.43 122.8,80.17 122.8,78.55 121.02,76.77 121.02,71.92
  IN3 w0.165: 121.02,71.92 121.02,70.81 120.72,70.51 120.03,70.51 119.32,69.8 119.32,58.54 119.95,57.91 119.95,57.68 119.59,57.32 119.59,57.09 119.83,56.85 120.06,56.85 120.42,57.21 120.65,57.21 120.89,56.98 120.89,56.74 120.53,56.39 120.53,56.15 120.76,55.92 121,55.92 121.35,56.28 121.59,56.28 127.88,49.99 127.88,47.53 128.86,46.55 128.86,41.47 129.48,40.85 129.64,40.85 131.92,38.57 132.9,38.57 133.54,37.93 133.54,36.01 136,33.55 136,30.64 v2(135.56,30.2)
  BOTTOM w0.076: UC1.AP48 124.81,85.05 v2(125.16,84.7)
  BOTTOM w0.165: JDIMM2.86 136.45,27.49 136.5,27.54 136.5,29.26 v2(135.56,30.2)
DDR_B_MA8: length 67.5
  IN3 w0.089: v2(123.96,76.84) 122.68,75.55 122.68,71.39
  IN3 w0.165: 122.68,71.39 120.16,68.88 120.16,58.89 128.71,50.34 128.71,48.02 130.82,45.92 130.82,45.43 130.52,45.14 130.52,44.77 130.82,44.48 130.82,44.11 130.52,43.82 130.52,43.45 130.82,43.16 130.82,42.79 130.52,42.49 130.52,42.09 130.77,41.85 130.77,41.57 130.54,41.35 130.54,41.13 130.84,40.84 131.05,40.84 131.7,41.49 131.7,43.91 131.86,44.06 132.21,44.06 132.36,43.91 132.36,41.21 131.53,40.38 131.53,40.15 132.27,39.41 133.25,39.41 134.37,38.28 134.37,37.32 135.3,36.39 135.3,35.44 136.83,33.9 136.83,33.43 137.02,33.25 v2(137.42,33.25)
  BOTTOM w0.076: v2(123.96,76.84) 123.96,76.96 124.31,77.31 124.31,77.89 124.71,78.29 124.71,79.69 UC1.BB48
  BOTTOM w0.165: JDIMM2.89 137.35,33.89 136.88,33.42 136.88,33.21 137.01,33.09 137.29,33.09 137.42,33.21 v2(137.42,33.25)
DDR_B_MA9: length 66.9
  IN3 w0.089: v2(124.33,84.71) 123.94,84.32 123.94,82.46 123.44,81.96 123.44,81.33 122.48,80.38 122.48,78.78 120.08,76.38 120.08,76.06
  IN3 w0.165: v2(135.56,33.25) 135.56,33.4 133.12,35.84 133.12,36.78 129.47,40.43 128.67,40.43 128.44,40.66 128.44,46.38 127.46,47.36 127.46,49.72 123.64,53.53 123.41,53.53 123.07,53.2 122.84,53.2 122.6,53.43 122.6,53.66 122.94,54 122.94,54.23 122.71,54.47 122.48,54.47 122.14,54.13 121.9,54.13 121.67,54.36 121.67,54.6 122.01,54.94 122.01,55.17 121.77,55.4 121.54,55.4 121.2,55.06 120.97,55.06 118.9,57.13 118.9,70.06 120.08,71.24 120.08,76.06
  BOTTOM w0.076: v2(124.33,84.71) 123.99,85.05 UC1.AP50
  BOTTOM w0.165: v2(135.56,33.25) 136.15,33.84 JDIMM2.85
DDR_B_MA10: length 70
  IN3 w0.165: v2(126.48,74.27) 126.04,74.27 125.81,74.04 125.81,61 126.02,60.8 126.27,60.8 126.54,61.07 126.77,61.07 127.01,60.83 127.01,60.6 126.51,60.11 126.51,59.87 126.75,59.64 126.98,59.64 127.47,60.13 127.71,60.13 127.94,59.9 127.94,59.67 127.45,59.17 127.45,58.94 127.68,58.71 127.91,58.71 128.41,59.2 128.64,59.2 128.88,58.97 128.88,58.73 128.38,58.24 128.38,58 128.61,57.77 128.85,57.77 129.34,58.27 129.58,58.27 129.81,58.03 129.81,57.8 129.32,57.3 129.32,57.07 139.58,46.81 139.58,46.5 139.25,46.17 139.25,45.84 139.58,45.51 139.58,44.84 139.74,44.67 139.74,44.24 139.58,44.07 139.58,43.22 139.73,43.07 139.73,42.63 139.58,42.47 139.58,42.03 139.72,41.89 139.72,41.48 139.58,41.34 139.58,41.02 142.56,38.04 142.56,37.19 143.08,36.66 143.08,35.06 143.82,34.32 143.82,31.74 143.91,31.65 144.19,31.65 v2(144.26,31.72)
  BOTTOM w0.076: 126.05,75.95 126.05,76.47 126.18,76.59 126.18,77.03 126.29,77.14 126.29,78.66 126.62,78.99 126.62,79.64 126.76,79.78 126.76,80.63 126.52,80.86 126.52,81.36 126.41,81.56 126.23,81.75 UC1.AW46
  BOTTOM w0.102: 126.05,75.95 126.05,74.71 v2(126.48,74.27)
  BOTTOM w0.165: v2(144.26,31.72) 144.11,31.72 142.75,33.08 JDIMM2.107
DDR_B_MA11: length 72.2
  IN3 w0.089: v2(124.3,85.96) 123.81,85.47 123.81,85.2 123.37,84.76 123.37,84.01 122.86,83.5 122.86,81.58 121.89,80.61 121.89,78.97 119.36,76.44 119.36,76.2
  IN3 w0.165: 119.36,76.2 119.36,71.73 118.07,70.44 118.07,56.74 124.63,50.17 125.82,50.17 126.48,49.51 126.48,46.75 126.73,46.49 126.73,41.08 128.22,39.59 129.12,39.59 132.28,36.43 132.28,35.49 134.46,33.31 134.46,30.38 134.63,30.22 134.92,30.22 135.08,30.05 135.08,29.72 134.69,29.33 134.69,28.9 134.91,28.68 v2(135.56,28.68)
  BOTTOM w0.076: v2(124.3,85.96) 124.55,85.7 UC1.AN48
  BOTTOM w0.165: JDIMM2.84 135.85,27.48 136.08,27.71 136.08,28.15 v2(135.56,28.68)
DDR_B_MA12: length 71.3
  IN3 w0.089: v2(124.33,85.36) 123.76,84.79 123.76,82.65 123.18,82.07 123.18,81.49 122.17,80.47 122.17,78.91 119.71,76.46 119.71,76.19
  IN3 w0.165: v2(135.56,31.72) 135.56,31.52 135.42,31.38 135.04,31.38 134.88,31.54 134.88,33.48 132.7,35.66 132.7,36.61 129.29,40.01 128.39,40.01 127.15,41.25 127.15,46.67 126.9,46.92 126.9,49.69 125.99,50.59 124.81,50.59 124.6,50.8 124.6,51.03 124.93,51.36 124.93,51.6 124.69,51.83 124.46,51.83 124.13,51.5 123.9,51.5 123.66,51.74 123.66,51.97 123.85,52.16 123.85,52.37 123.6,52.62 123.38,52.62 123.2,52.44 122.96,52.44 118.49,56.92 118.49,70.26 119.71,71.49 119.71,76.19
  BOTTOM w0.076: v2(124.33,85.36) 123.99,85.7 UC1.AN50
  BOTTOM w0.165: v2(135.56,31.72) 135.06,32.22 135.06,33.39 135.55,33.88 JDIMM2.83
DDR_B_MA13: length 67.1
  IN3 w0.165: v2(146.41,38.1) 146.41,38.01 146.23,37.82 145.99,37.82 145.6,38.22 145.6,38.55 145.47,38.68 145.47,38.91 145.57,39.01 145.57,39.22 145.32,39.48 145.11,39.48 145,39.37 144.78,39.37 144.53,39.62 144.53,39.83 144.64,39.94 144.64,40.16 144.39,40.41 144.17,40.41 144.07,40.31 143.84,40.31 143.63,40.52 143.63,46.85 142.07,48.42 142.07,48.65 142.44,49.02 142.44,49.24 142.19,49.49 141.98,49.49 141.6,49.12 141.39,49.12 141.14,49.37 141.14,49.58 141.94,50.39 141.94,50.62 141.71,50.86 141.48,50.86 141.13,50.51 140.89,50.51 140.65,50.75 140.65,50.93 141.06,51.35 141.06,51.56 140.82,51.81 140.61,51.81 140.22,51.42 139.99,51.42 139.76,51.66 139.76,51.89 140.13,52.26 140.13,52.5 139.9,52.73 139.66,52.73 139.29,52.36 139.05,52.36 138.82,52.59 138.82,52.82 139.2,53.2 139.2,53.43 138.96,53.67 138.73,53.67 138.35,53.29 138.12,53.29 137.89,53.52 137.89,53.76 138.26,54.13 138.26,54.37 138.03,54.6 137.79,54.6 137.42,54.23 137.19,54.23 136.95,54.46 136.95,54.69 137.33,55.07 137.33,55.3 137.09,55.53 136.86,55.53 136.49,55.16 136.25,55.16 136.02,55.39 136.02,55.63 136.39,56 136.39,56.23 128.33,64.3 128.33,71.92 128.58,72.18 128.58,74.22 128.34,74.46 v2(128.14,74.46)
  BOTTOM w0.076: 127.8,75.86 127.8,76.33 127.45,76.68 127.45,78.42 127.61,78.58 127.61,78.93 127.71,79.03 128.1,79.03 128.32,79.25 128.32,79.55 128.25,79.62 128.25,80.12 128.3,80.26 128.3,80.37 128.26,80.46 128.24,80.5 128.24,80.74 UC1.BA43
  BOTTOM w0.102: v2(128.14,74.46) 127.8,74.8 127.8,75.86
  BOTTOM w0.165: JDIMM2.119 146.35,35.94 146.11,36.19 146.11,37.8 v2(146.41,38.1)
DDR_B_MA14: length 70.9
  IN3 w0.089: v2(123.33,85.38) 122.97,85.02 122.97,83.98 122.58,83.6 122.58,81.71 121.6,80.73 121.6,79.07 119.03,76.5 119.03,75.62
  IN3 w0.165: v2(133.53,30.2) 133.57,30.15 133.89,30.15 134.04,30.31 134.04,33.13 131.86,35.32 131.86,36.26 128.95,39.17 128.04,39.17 126.31,40.9 126.31,46.32 125.86,46.78 125.86,48.36 117.65,56.57 117.65,70.62 119.03,72 119.03,75.62
  BOTTOM w0.076: v2(123.33,85.38) 123,85.7 UC1.AN52
  BOTTOM w0.165: v2(133.53,30.2) 134.67,30.2 134.93,29.94 134.93,27.85 134.65,27.58 JDIMM2.80
DDR_B_MA15: length 71.8
  IN3 w0.089: v2(121.55,85.31) 121.91,84.95 121.91,82.65 120.97,81.71 120.97,80.61 120.44,80.08 120.44,79.05 117.56,76.17 117.56,75.83
  IN3 w0.165: 117.56,75.83 117.56,71.73 116.77,70.93 116.77,56.26 125.02,48.01 125.02,41.01 129.04,36.99 129.78,36.99 130.97,35.8 130.97,34.12 132.44,32.65 132.44,29.76 v2(133.53,28.68)
  BOTTOM w0.076: UC1.AN53 v2(121.55,85.31)
  BOTTOM w0.165: v2(133.53,28.68) 133.89,28.68 134,28.78 134,29.51 134.09,29.6 134.38,29.6 134.51,29.47 134.51,28.03 134.05,27.57 JDIMM2.78
DDR_B_ODT0: length 67.3
  IN3 w0.165: v2(145.18,25.01) 145.18,25.59 145.02,25.75 144.32,25.75 144.16,25.9 144.16,26.84 144.32,26.99 144.79,26.99 145.19,27.39 145.19,28.92 145.54,29.26 145.54,34.98 145.33,35.19 145.33,36.33 144.76,36.9 144.76,37.36 144.23,37.88 144.23,38.73 142.79,40.17 142.79,46.51 140.3,49 140.3,49.92 127.49,62.73 127.49,76.34 v2(127.93,76.78)
  BOTTOM w0.076: v2(127.93,76.78) 127.94,76.79 128.25,76.79 128.78,77.32 128.78,78.87 128.86,78.96 128.86,79.73 128.95,79.81 128.95,80.09 128.87,80.27 128.74,80.41 128.68,80.47 UC1.BA42
  BOTTOM w0.165: v2(145.18,25.01) 145.45,25.28 JDIMM2.116
DDR_B_ODT1: length 68.4
  IN3 w0.089: v2(127.99,78.47) 128.32,78.14 128.32,78.14 129.43,77.03 129.43,70.82 129.58,70.66 129.58,68.63
  IN3 w0.165: 129.58,68.63 129.58,64.82 144.93,49.48 144.93,46.85 145.08,46.7 146.04,46.7 146.19,46.54 146.19,40.39 147.71,38.87 147.71,36.1 147.6,35.98 147.6,28.21 146.48,27.09 146.48,26.88 146.83,26.52 v2(146.83,24.95)
  BOTTOM w0.076: UC1.AW42 128.68,81.73 128.41,81.46 128.41,80.54 128.47,80.4 128.47,80.22 128.41,80.09 128.41,79.76 128.53,79.65 128.53,79.22 128.2,78.9 128.2,78.68 v2(127.99,78.47)
  BOTTOM w0.165: v2(146.83,24.95) 146.65,25.13 JDIMM2.120
DDR_B_PAR: length 1.1
  TOP w0.076: v2(127.08,84.75) 127.41,85.08 T23.1
  BOTTOM w0.076: UC1.AP43 v2(127.08,84.75)
DDR_B_RAS#: length 69.6
  IN3 w0.165: v2(126.49,76.09) 125.55,75.14 125.55,67.5 125.34,67.29 125.34,60.38 138.83,46.89 138.83,45.66 139.16,45.33 139.16,40.84 142.14,37.86 142.14,37.01 142.66,36.49 142.66,34.89 143.4,34.15 143.4,31.18 143.24,31.02 142.69,31.02 142.53,30.85 142.53,30.52 142.69,30.36 143.07,30.36 143.22,30.2 143.22,28.83 143.07,28.68 142.61,28.68 142.45,28.52 142.45,25.16 142.6,25.01 v2(143.38,25.01)
  BOTTOM w0.076: UC1.AW44 127.45,81.78 127.29,81.61 127.18,81.4 127.16,81.33 127.16,80.86 126.92,80.63 126.92,79.71 126.78,79.57 126.78,78.92 126.52,78.65 126.52,77.08 126.42,76.98 126.42,76.16 126.49,76.09 v2(126.49,76.09)
  BOTTOM w0.165: JDIMM2.110 143.65,25.28 v2(143.38,25.01)
DDR_B_WE#: length 71.4
  IN3 w0.165: v2(144.26,29.44) 144.53,29.44 144.7,29.61 144.7,34.63 143.92,35.41 143.92,37.01 143.4,37.53 143.4,38.38 141.05,40.73 141.05,46.92 140.83,47.14 140.43,47.14 140.15,47.43 140.15,47.66 140.17,47.68 140.17,47.92 139.93,48.15 139.7,48.15 139.68,48.13 139.44,48.13 138.96,48.61 138.96,48.85 139.46,49.35 139.46,49.57 139.21,49.82 139,49.82 138.48,49.3 138.27,49.3 138.02,49.55 138.02,49.77 138.53,50.28 138.53,50.5 138.28,50.75 138.06,50.75 137.55,50.24 137.33,50.24 137.08,50.49 137.08,50.7 137.6,51.22 137.6,51.43 137.34,51.68 137.13,51.68 137,51.55 136.78,51.55 136.53,51.8 136.53,52.02 136.65,52.14 136.65,52.38 126.65,62.38 126.65,68.32 126.96,68.62 126.96,71.59 v2(126.42,72.12)
  BOTTOM w0.076: UC1.AY44 127.45,81.04 127.55,80.94 127.55,80.93 127.63,80.71 127.63,80.58 127.56,80.35 127.56,80.21 127.62,80.09 127.62,79.85 127.42,79.65 127.42,79.5 127.28,79.37 127.28,78.72 127.11,78.54 127.11,76.5 127.42,76.18 127.42,75.99
  BOTTOM w0.102: 127.42,75.99 127.42,74.66 127.25,74.49 127.25,72.95 v2(126.42,72.12)
  BOTTOM w0.165: JDIMM2.113 144.55,33.62 144.73,33.44 144.73,29.91 v2(144.26,29.44)
DDR_DRAMRST#: length 139.1
  TOP w0.102: v2(105.56,37.3) 105.56,36.78 CD30.1 CD3.1 105.96,35.45 RD1.2
  IN1 w0.076: v2(144.39,83.37) 144.39,82.03 144.58,81.84 144.58,80.76 147.73,77.62 147.73,77.14
  IN1 w0.089: v2(105.56,37.3) 107.2,35.65 137,35.65 137.6,36.25 137.6,37.65 138.66,38.71 157.52,38.71 158.36,39.55 158.36,45.46 158.68,45.77 158.68,46.04 157.75,46.97 157.75,49.31 154.49,52.57 154.49,58.47 149.47,63.49 149.47,66.54 152.08,69.14 152.08,69.66 147.73,74.01 147.73,77.14
  BOTTOM w0.076: UC1.AT13 144.78,83.75 v2(144.39,83.37)
  BOTTOM w0.102: JDIMM1.30 104.85,38 v2(105.56,37.3) 106.48,36.37 106.48,34.09 108.15,32.42 108.15,29.89 107.75,29.49 107.75,25.33 108.91,24.17 115.54,24.17 116.34,24.97 116.85,24.97 117.25,25.38 JDIMM2.30
DDR_VTT_CNTL: length 103.3
  TOP w0.102: UC7.2 158.17,57.33 v2(157.79,56.95)
  IN3 w0.102: v2(95.72,75.33) 98.09,72.96 98.09,60.93 97.47,60.31 v2(97.47,57.52)
  BOTTOM w0.076: 108.64,79.97 109.11,79.97 109.98,80.84 109.98,81.41 110.37,81.8 111.09,81.8 111.39,82.1 112.66,82.1 112.72,82.03 113.35,82.03 113.46,81.93 UC1.AW67
  BOTTOM w0.102: v2(95.72,75.33) v1(98.8,75.33) 103.19,75.33 106.6,78.74 106.6,79.49 107.09,79.97 108.64,79.97 ; v2(157.79,56.95) 157.79,56.7 157.22,56.13 100.69,56.13 99.29,57.52 v2(97.47,57.52)
DEVSLP0: length 118.3
  IN1 w0.076: 154.87,97.34 153.31,97.34 v2(152.93,96.96)
  IN1 w0.102: v2(166.55,20.63) 169.87,23.94 169.87,30.04 170.96,31.13 170.96,35.13 170.1,35.99 170.1,43.1 169.32,43.88 169.32,48.68 169.99,49.35 169.99,57.4 170.96,58.37 170.96,60.8 172.71,62.55 172.71,66.62 172.97,66.87 172.97,69.62 173.6,70.25 173.6,70.93 172.97,71.57 172.97,76.75 171.94,77.78 171.94,91.69 166.8,96.83 162.55,96.83 161.73,97.65 158.93,97.65 158.3,97.02 156.27,97.02 155.95,97.34 154.87,97.34
  BOTTOM w0.076: v2(152.93,96.96) 152.93,97.44 152.59,97.78 UC1.J1
  BOTTOM w0.102: v2(166.55,20.63) v1(167.47,19.71) 168.21,18.97 168.21,16.56 169.6,15.17 175.89,15.17 176.44,14.62 180.68,14.62 RS8.1
DEW1: length 4.5
  TOP w0.102: RS36.1 RS34.1 182.29,8.75 183.76,8.75 184.22,9.22 US2.16
DEW2: length 4.2
  TOP w0.102: v1(186.43,17.29) 186.87,16.84 RS33.1 185.98,15.5 RS35.1 185.98,15.12 186.22,14.88 US2.6
DGPU_HOLD_RST#: length 142.5
  TOP w0.102: UV12.2 83.97,82.63 84.45,82.15 84.45,81.7 v2(84.73,81.42) ; v2(155.54,100.13) 155.82,100.13 v1(156.08,100.38)
  IN1 w0.102: v2(155.54,100.13) 154.49,100.13 153,101.62 153,103.54 151.92,104.62 151.92,106.05 151.32,106.66 151.32,109.32 149.96,110.68 143.91,110.68 143.34,111.25 136.63,111.25 136.33,111.55 123.18,111.55 121.74,110.11 104.06,110.11 103.86,110.31 99.76,110.31 98.17,108.71 92.63,108.71 92.39,108.96 78.1,108.96 77.17,108.03 72.42,108.03 71.28,109.17 v2(71.28,109.34)
  IN3 w0.102: v2(84.73,81.42) 84.73,81.59 84.8,81.67 84.8,89.68 84.26,90.22 81.21,90.22 80.07,91.37 80.07,98.93 77.1,101.9 75.89,101.9 73.65,104.13 73.65,105.26 71.28,107.63 v2(71.28,109.34)
  BOTTOM w0.076: 154.87,100.13 154.54,100.13 153.28,98.88 153.28,96.13 152.58,95.43 151.25,95.43 150.94,95.13 UC1.P3
  BOTTOM w0.102: RC214.1 155.71,99.97 v2(155.54,100.13) 154.87,100.13
DGPU_MAIN_EN: length 64.9
  TOP w0.102: v2(74.49,85.03) 74.49,84.93 79.91,79.51 RPV5.1 80.52,80.27 80.7,80.44 84.22,80.44 v2(84.57,80.1) ; UV10.3 92.33,61.51 v2(92.51,61.33)
  IN3 w0.102: v2(84.57,80.1) 84.57,76.26 v2(86.04,74.79)
  BOTTOM w0.102: v2(74.49,85.03) 74.12,85.4 UV1.A3 ; PR823.2 72.76,49.71 74.86,51.81 84.54,51.81 87.95,55.22 87.95,57.71 88.3,58.06 89,58.06 92.28,61.33 v2(92.51,61.33) 92.83,61.65 92.83,67.3 91.62,68.51 v1(89.66,68.51) 86.04,72.13 v2(86.04,74.79)
DGPU_PSI: length 43.6
  TOP w0.102: v2(73.68,84.18) 74.81,84.18 79.43,79.56 v2(79.43,79.37) 79.79,79.01 RPV5.2
  IN3 w0.102: v2(79.43,79.37) 80.77,78.03 80.77,71.81 81.21,71.37 81.21,63.75 75.11,57.65 75.11,51.62 v2(75.69,51.05)
  BOTTOM w0.102: UV1.B4 73.3,84.56 v2(73.68,84.18)
  BOTTOM w0.254: PR803.2 v1(75.11,50.47) v2(75.69,51.05)
DGPU_PWR_EN: length 159.4
  TOP w0.102: v2(86.1,68.06) 86.1,67.81 85.27,66.98 QV8.2
  IN1 w0.102: v2(155.79,98.45) 155.79,98.51 152.77,101.53 152.77,103.5 151.69,104.58 151.69,105.96 151.09,106.56 151.09,109.22 149.86,110.45 143.82,110.45 143.24,111.02 136.54,111.02 136.24,111.33 123.28,111.33 121.83,109.88 103.97,109.88 103.77,110.08 99.86,110.08 98.26,108.48 92.54,108.48 92.29,108.73 78.19,108.73 77.26,107.8 72.18,107.8 v2(70.64,109.34)
  IN3 w0.102: v2(86.04,75.37) 84.97,76.43 84.97,80.27 84.67,80.57 84.58,80.57 84.32,80.83 84.32,82.54 84.58,82.8 84.58,89.53 84.13,89.97 81.08,89.97 79.81,91.24 79.81,98.86 77.02,101.65 75.75,101.65 73.4,104 73.4,105.15 70.64,107.9 v2(70.64,109.34)
  BOTTOM w0.076: 154.87,97.58 RC211.1 154.5,97.34 153.92,97.34 153.66,97.08 153.66,96.77 153.79,96.64 153.79,95.3 152.28,93.8 UC1.U1
  BOTTOM w0.102: 154.87,97.58 155.3,97.58 155.38,97.65 155.38,98.04 v2(155.79,98.45) 156.11,98.14 157.33,98.14 157.63,98.43 157.63,98.78 157.52,98.88 RC230.1 ; v2(86.04,75.37) 86.04,75.37 85.59,74.92 v1(85.59,69.84) 85.59,68.57 v2(86.1,68.06)
DGPU_PWROK: length 220.7
  TOP w0.102: RV210.1 v2(94.86,63.24) ; QV3.2 75.48,73.34 75.86,73.71 80.8,73.71 v1(80.88,73.79) RV201.1 83.23,75.02 84.17,75.96 84.23,75.96 UV23.1 85.31,76.41 85.53,76.18 86.6,76.18 v2(86.8,76.38)
  IN1 w0.102: v2(152.37,104.78) 152.37,105.93 151.55,106.75 151.55,109.41 150.05,110.91 144.01,110.91 143.43,111.48 136.73,111.48 136.42,111.78 123.09,111.78 121.64,110.34 104.16,110.34 103.96,110.54 99.67,110.54 99.54,110.41 98.07,108.94 92.72,108.94 92.48,109.19 78,109.19 77.08,108.26 72.64,108.26 71.91,108.98 v2(71.91,109.34)
  IN3 w0.102: v2(86.8,76.38) 85.22,77.96 85.22,84.7 87.83,87.31 87.83,93.85 85.35,96.33 81.58,96.33 80.51,97.4 80.51,98.95 77.33,102.13 76.04,102.13 73.91,104.26 73.91,105.33 71.91,107.32 v2(71.91,109.34)
  BOTTOM w0.076: 152.55,105.34 152.37,105.16 v2(152.37,104.78) 151.97,104.39 149.91,104.39 149.24,103.71 149.24,103.44 148.88,103.08 148.38,103.08 148.14,102.84 148.14,101.91 148.02,101.79 UC1.C8
  BOTTOM w0.102: v2(86.8,76.38) 88.26,76.38 94.2,70.44 94.2,68.03 94.86,67.36 v2(94.86,63.24) 94.86,62.19 93.47,60.79 92.06,60.79 89.42,58.15 89.42,53.29 82.61,46.47 82.61,37.93 80.69,36.01 74.53,36.01 74.14,36.4 74.14,38.97 PR814.2 ; RC217.2 152.71,105.5 152.55,105.34
  BOTTOM w0.203: PU801.13 75.53,40.37 PR814.2
DGPU_VID: length 45.2
  TOP w0.102: v2(76.45,45.27) v1(76.45,45.77)
  IN3 w0.076: v2(71.21,81.74) 76.13,76.83
  IN3 w0.102: 76.13,76.83 76.76,76.19 76.76,73.84 78.96,71.64 78.96,68.92 77.83,67.79 77.83,66.34 73.46,61.97 73.46,50.98 76.45,48 v2(76.45,45.27)
  BOTTOM w0.102: v2(71.21,81.74) 70.8,82.16 UV1.E7
  BOTTOM w0.203: v2(76.45,45.27) 76.33,45.15 PU801.5
DRMOS: length 33.6
  TOP w0.254: v2(94.16,106.8) 94.8,107.43 94.8,111.12 95.24,111.56 98.16,111.56 98.8,112.2 99.37,112.2 100.1,112.93 100.1,113.5 v1(100.64,114.04) v2(101.21,114.04)
  IN1 w0.254: v2(80.99,100.14) 80.99,104.68 81.91,105.59 87.88,105.59 88.45,106.16 93.53,106.16 v2(94.16,106.8)
  BOTTOM w0.254: PR662.1 PC677.1 v2(80.99,100.14) 81.23,100.38 PU605.2
E51_RX1: length 4
  TOP w0.102: T4928.1 183.51,66.49 v2(182.87,67.12)
  BOTTOM w0.102: JNGFF.38 183.73,66.27 v2(182.87,67.12)
E51_TX1: length 2.7
  TOP w0.102: v2(182.87,66.54) 182.56,66.22 RM12.1
  BOTTOM w0.102: v1(182.43,66.79) 182.68,66.54 v2(182.87,66.54) 183.23,66.19 JNGFF.36
E51_TX2: length 4.2
  TOP w0.102: v2(181.79,66.73) 181.79,66.48 181.67,66.35 RM13.1 RM9.1
  BOTTOM w0.102: v1(180.97,67.11) 181.41,67.11 v2(181.79,66.73) 181.79,66.48 181.73,66.41 JNGFF.30
EC_AGND: length 28.7
  TOP w0.203: v2(138.36,5.01) 138.6,4.76 UE5.112
  TOP w0.254: RE385.1 115.61,1.77 RE344.1 CE71.2 CE80.2 R2453.1 C5230.2 120.28,1.69 v1(120.58,1.39) 122.05,1.39 CE90.2 123.6,1.69 CE83.2 123.59,1.71 123.01,2.29 v2(123.01,2.68)
  IN1 w0.254: v2(123.01,2.68) 124.22,2.68 124.78,3.24 125.56,3.24 126.03,2.77 128.92,2.77 129.79,3.64 136.99,3.64 v2(138.36,5.01)
EC_MISO_R: length 160.6
  TOP w0.102: v2(179.41,25.19) 179.41,25.4 179.53,25.53 179.81,25.53 179.91,25.43 179.91,24.18 179.79,24.06 v1(178.87,24.06) 177.09,24.06 176.97,23.93 176.97,23.68 177.09,23.55 180.2,23.55 180.32,23.67 180.32,25.43 180.42,25.53 180.66,25.53 180.79,25.4 RPC5.8 ; RE374.1 151.2,20.19 151.72,20.19 152.72,21.19 154.16,21.19 156.21,23.23 172.71,23.23 172.72,23.24 175.76,26.28 v2(177.2,26.28)
  IN1 w0.089: v2(177.2,26.28) 177.2,31.63 186.31,40.73 186.31,46.46 v2(185.73,47.04)
  IN3 w0.102: v2(157.41,79.77) 158.02,79.17 158.02,75.22 161.83,71.41 161.83,68.44 166.28,63.99 166.28,61 166.1,60.82 166.1,59.23 167.55,57.78 171.46,57.78 171.96,57.27 177.88,57.27 179.26,55.88 183.43,55.88 185.57,53.75 185.57,47.21 v2(185.73,47.04) 186.31,46.46 186.31,41.44 185.35,40.48 185.35,40.19 185.99,39.55 185.99,39.37 185.84,39.22 185.66,39.22 184.96,39.92 184.79,39.92 184.67,39.8 184.67,39.63 185.4,38.9 185.4,38.76 185.26,38.62 185.11,38.62 184.38,39.35 184.22,39.35 184.1,39.23 184.1,39.06 184.83,38.33 184.83,38.19 184.32,37.68 183.38,37.68 178.94,33.25 178.94,25.9 179.06,25.77 180.9,25.77 181.29,25.39 181.29,23.74 180.97,23.42 178.74,23.42 178.24,23.93 178.24,24.1 178.36,24.22 180.37,24.22 180.52,24.38 180.52,25.06 180.4,25.19 v2(179.41,25.19)
  BOTTOM w0.102: RC57.2 156.95,79.77 v2(157.41,79.77)
EC_MOSI_R: length 161
  TOP w0.102: v2(178.71,25.19) 178.71,25.65 178.83,25.77 v1(179.06,25.77) 180.75,25.77 181.29,25.23 RPC5.7 ; RE373.1 152.93,20.96 154.26,20.96 156.22,22.91 172.72,22.91 175.32,25.52 v2(177.41,25.52)
  IN1 w0.089: v2(177.41,25.52) 176.9,25.52 176.65,25.77 176.65,31.68 185.89,40.92 v2(185.89,45.73)
  IN3 w0.102: v2(178.71,25.19) 178.71,28.93 178.61,29.04 177.81,29.04 177.69,29.16 177.69,29.32 177.81,29.44 178.61,29.44 178.71,29.54 178.71,29.77 178.61,29.87 177.79,29.87 177.69,29.98 177.69,30.18 177.79,30.28 178.56,30.28 178.68,30.4 178.68,30.57 178.56,30.69 177.79,30.69 177.69,30.79 177.69,30.99 177.79,31.09 178.59,31.09 178.71,31.21 178.71,31.38 178.59,31.5 177.79,31.5 177.69,31.6 177.69,31.8 177.79,31.91 178.59,31.91 178.71,32.02 178.71,32.19 178.59,32.31 177.79,32.31 177.69,32.41 177.69,32.62 177.79,32.72 178.61,32.72 178.71,32.82 178.71,33.34 179.34,33.97 179.34,34.15 178.8,34.68 178.8,34.85 178.92,34.97 179.09,34.97 179.64,34.42 179.79,34.42 179.93,34.56 179.93,34.71 179.38,35.26 179.38,35.43 179.5,35.55 179.66,35.55 180.22,34.99 180.36,34.99 180.51,35.14 180.51,35.28 179.95,35.83 179.95,36 180.07,36.12 180.24,36.12 180.79,35.57 180.94,35.57 181.08,35.71 181.08,35.86 180.53,36.41 180.53,36.58 180.65,36.7 180.81,36.7 181.37,36.14 181.51,36.14 181.66,36.29 181.66,36.43 181.1,36.98 181.1,37.15 181.22,37.27 181.39,37.27 181.94,36.72 182.09,36.72 182.23,36.86 182.23,37.01 181.68,37.56 181.68,37.73 181.8,37.85 181.96,37.85 182.52,37.29 182.66,37.29 182.81,37.44 182.81,37.58 182.54,37.85 182.54,37.99 182.68,38.14 182.83,38.14 183.09,37.87 183.24,37.87 183.38,38.01 183.38,38.16 183.11,38.42 183.11,38.57 183.26,38.71 183.4,38.71 184.13,37.98 184.3,37.98 184.42,38.1 184.42,38.27 183.69,39 183.69,39.14 185.31,40.76 185.31,41.84 185.38,41.9 185.79,41.9 185.89,42 185.89,42.24 185.79,42.34 185.41,42.34 185.31,42.45 185.31,42.65 185.41,42.75 185.79,42.75 185.89,42.85 185.89,43.05 185.79,43.16 185.41,43.16 185.31,43.26 185.31,43.46 185.41,43.56 185.79,43.56 185.89,43.66 185.89,43.87 185.79,43.97 185.41,43.97 185.31,44.07 185.31,44.27 185.41,44.38 185.79,44.38 185.89,44.48 185.89,44.68 185.79,44.78 185.41,44.78 185.31,44.88 185.31,45.09 185.41,45.19 185.79,45.19 185.89,45.29 v2(185.89,45.73) 185.31,46.31 185.31,53.68 183.33,55.66 179.17,55.66 177.79,57.04 173.17,57.04 172.48,56.35 171.04,56.35 169.85,57.55 167.46,57.55 165.87,59.13 165.87,60.91 166.05,61.1 166.05,63.89 161.6,68.34 161.6,71.32 156.77,76.14 156.77,76.83 156.9,76.95 157.29,76.95 v2(157.41,76.83)
  BOTTOM w0.102: v2(157.41,76.83) 157.1,77.14 RC58.2
EC_MUTE#: length 96.6
  TOP w0.102: RE365.1 RE368.1 124.53,6.4 v2(124.41,6.52)
  IN3 w0.102: v2(200.72,16.69) 200.72,12.31 199.83,11.42 197.41,11.42 196.97,11.87 193.67,11.87 187.83,6.02 183.51,6.02 183.13,5.64 164.08,5.64 157.31,12.41 152.04,12.41 148.9,9.26 146.74,9.26 145.73,10.28 143,10.28 141.74,9.02 136.95,9.02 135.35,7.42 134.67,7.42 134.07,6.82 130.7,6.82 129.5,5.62 126.54,5.62 125.85,6.3 124.63,6.3 v2(124.41,6.52)
  BOTTOM w0.102: UA1.47 199.98,17.69 200.21,17.45 200.21,17.2 v2(200.72,16.69) 200.72,16.65 RA14.2 201.29,15.99 202.06,15.22 v1(202.24,15.22)
EC_MUTE#_R: length 22.4
  TOP w0.102: v1(124.96,3.51) 124.95,3.51 v2(124.59,3.86) 124.38,3.86 124.07,4.17 124.07,4.93 RE368.2 ; UE5.119 141.4,5.33 v2(141.22,5.52)
  IN1 w0.102: v2(124.59,3.86) 124.68,3.78 125.75,3.78 126.45,3.08 128.76,3.08 129.63,3.94 136.59,3.94 138.17,5.52 v2(141.22,5.52)
EC_SPI_CLK: length 6
  TOP w0.102: 147.88,19.42 149.35,20.88 149.35,21.15 RE372.2 ; 147.88,19.42 v1(147.88,19.42) ; 147.88,19.42 147.57,19.1 147.57,17.96 147.35,17.75 UE5.32
EC_SPI_CS0#: length 4.8
  TOP w0.102: UE5.27 148.42,15.75 149.65,16.98 149.65,17.64 RE377.1
EC_SPI_MISO: length 6.7
  TOP w0.102: RE374.2 149.47,19.99 148.8,19.32 148.8,18.33 148.84,18.29 148.84,18.03 149.19,17.68 149.19,17.17 148.57,16.55 v1(148.2,16.55) UE5.29
EC_SPI_MOSI: length 6.5
  TOP w0.102: RE373.2 149.84,19.3 149.3,19.3 v1(149.16,19.16) 149.16,18.03 149.42,17.77 149.42,17.07 148.5,16.15 UE5.28
EC_SPICLK_R: length 160.9
  TOP w0.102: RPC5.6 181.79,25.41 v1(180.46,26.74) v2(179.64,26.74) ; v2(177.73,26.79) 174.62,26.79 172.33,24.5 157.03,24.5 156.77,24.76 155.89,24.76 153.59,22.46 151.57,22.46 RE372.1
  IN1 w0.089: v2(177.73,26.79) 179.19,28.25 179.19,32.95 186.78,40.54 186.78,47.14 v2(186.27,47.65)
  IN3 w0.102: v2(159.76,80.5) 158.96,79.7 158.96,74.96 162.31,71.61 162.31,68.64 166.76,64.19 166.76,60.8 166.58,60.62 166.58,59.43 167.75,58.26 171.66,58.26 172.16,57.75 178.08,57.75 179.03,56.8 183.28,56.8 186.05,54.03 186.05,47.87 v2(186.27,47.65) 186.79,47.13 186.79,39.47 184.52,37.2 183.58,37.2 179.53,33.16 179.53,29.41 179.63,29.31 180.43,29.31 180.55,29.19 180.55,29.02 180.43,28.9 179.63,28.9 179.53,28.8 179.53,28.59 179.63,28.49 181.25,28.49 181.37,28.37 181.37,28.21 181.25,28.09 179.63,28.09 179.53,27.99 179.53,27.78 179.63,27.68 182.25,27.68 182.37,27.56 182.37,25.52 182.47,25.42 183.39,25.42 183.51,25.3 183.51,25.13 183.39,25.01 182.47,25.01 182.37,24.91 182.37,24.15 182.47,24.05 183.52,24.05 183.64,23.93 183.64,23.76 183.52,23.64 182.02,23.64 181.86,23.8 181.86,27.15 181.73,27.27 181.46,27.27 181.36,27.17 181.36,26.34 181.24,26.22 181.08,26.22 180.96,26.34 180.96,27.17 180.85,27.27 180.65,27.27 180.55,27.17 180.55,26.37 180.43,26.25 180.26,26.25 180.14,26.37 180.14,27.17 180.04,27.27 179.63,27.27 179.53,27.17 179.53,26.84 v2(179.64,26.74)
  BOTTOM w0.102: v2(159.76,80.5) 159.34,80.5 RC59.2
EC_SPICS#_R: length 209.5
  TOP w0.102: RE377.2 151.01,18.26 153.48,20.72 156.16,20.72 156.26,20.83 156.26,22.57 156.38,22.69 156.55,22.69 156.67,22.57 156.67,20.83 156.77,20.72 156.97,20.72 157.07,20.83 157.07,22.57 157.19,22.69 157.36,22.69 157.48,22.57 157.48,20.83 157.58,20.72 157.78,20.72 157.88,20.83 157.88,22.54 158,22.66 158.17,22.66 158.29,22.54 158.29,20.83 158.39,20.72 158.6,20.72 158.7,20.83 158.7,22.54 158.82,22.66 158.98,22.66 159.1,22.54 159.1,20.83 159.21,20.72 159.41,20.72 159.51,20.83 159.51,22.54 159.63,22.66 159.8,22.66 159.92,22.54 159.92,20.83 160.02,20.72 160.22,20.72 160.32,20.83 160.32,22.48 160.44,22.6 160.61,22.6 160.73,22.48 160.73,20.83 160.83,20.72 161.09,20.72 161.22,20.85 161.22,22.47 161.35,22.6 161.61,22.6 161.71,22.5 161.71,20.81 161.83,20.69 162,20.69 162.11,20.81 162.11,22.5 162.22,22.6 162.42,22.6 162.52,22.5 162.52,20.87 162.64,20.76 162.81,20.76 162.93,20.87 162.93,22.5 163.03,22.6 163.23,22.6 163.33,22.5 163.33,21.7 163.45,21.58 163.62,21.58 163.74,21.7 163.74,22.5 163.84,22.6 165.03,22.6 165.13,22.5 165.13,21.14 165.23,21.04 165.44,21.04 165.54,21.14 165.54,22.5 165.64,22.6 165.84,22.6 165.94,22.5 165.94,21.14 166.05,21.04 166.25,21.04 166.35,21.14 166.35,22.5 166.45,22.6 166.66,22.6 166.76,22.5 166.76,21.14 166.86,21.04 167.06,21.04 167.16,21.14 167.16,22.5 167.27,22.6 167.47,22.6 167.57,22.5 167.57,21.14 167.67,21.04 167.87,21.04 167.98,21.14 167.98,22.5 168.08,22.6 168.28,22.6 168.38,22.5 168.38,21.14 168.48,21.04 168.69,21.04 168.79,21.14 168.79,22.5 168.89,22.6 169.09,22.6 169.2,22.5 169.2,21.14 169.3,21.04 169.5,21.04 169.6,21.14 169.6,22.5 169.7,22.6 169.91,22.6 170.01,22.5 170.01,21.14 170.11,21.04 170.31,21.04 170.41,21.14 170.41,22.5 170.52,22.6 170.72,22.6 170.82,22.5 170.82,21.14 170.92,21.04 171.13,21.04 171.23,21.14 171.23,22.5 171.33,22.6 171.53,22.6 171.63,22.5 171.63,21.14 171.74,21.04 171.94,21.04 172.04,21.14 172.04,22.5 172.14,22.6 172.73,22.6 175.24,25.11 v3(176.27,25.11) 178.02,25.11 v2(178.11,25.2)
  IN3 w0.102: v2(155.34,82.49) 156.52,81.31 156.52,76.07 161.37,71.22 161.37,68.25 164.34,65.28 164.34,64.45 164.96,63.83 165.4,63.83 165.64,63.59 165.64,62.39 165.19,61.93 165.19,61.57 165.64,61.11 165.64,59.04 167.36,57.32 169.75,57.32 170.95,56.13 172.57,56.13 173.21,56.76 177.74,56.76 179.09,55.41 183.25,55.41 185.08,53.58 185.08,40.86 182.38,38.15 181.78,38.15 178.39,34.77 178.39,34.62 178.94,34.08 178.94,33.91 178.82,33.79 178.65,33.79 178.11,34.34 177.96,34.34 177.82,34.19 177.82,34.05 178.46,33.41 178.46,33.24 178.34,33.12 178.18,33.12 177.81,33.48 177.61,33.48 177.46,33.33 177.46,28.93 177.59,28.81 178.3,28.81 178.48,28.63 178.48,26.5 178.33,26.34 177.98,26.34 177.86,26.22 177.86,25.45 v2(178.11,25.2)
  BOTTOM w0.102: JC1.1 UC2.1 180.33,24.31 180.23,24.21 178.61,24.21 178.49,24.09 178.49,23.92 178.61,23.8 180.23,23.8 180.33,23.7 180.33,23.42 180.21,23.3 179.7,23.3 179.57,23.17 179.57,21.2 179.44,21.07 179.15,21.07 179.03,21.2 179.03,23.17 178.9,23.3 178.62,23.3 178.49,23.17 178.49,21.77 178.36,21.65 176.5,21.65 176.4,21.75 176.4,21.95 176.5,22.05 177.88,22.05 177.98,22.15 177.98,22.36 177.88,22.46 176.5,22.46 176.4,22.56 176.4,22.76 176.5,22.87 177.88,22.87 177.98,22.97 177.98,23.17 177.88,23.27 176.5,23.27 176.4,23.37 176.4,23.58 176.5,23.68 177.88,23.68 177.98,23.78 177.98,23.98 177.88,24.08 176.83,24.08 176.71,24.2 176.71,24.37 176.83,24.49 177.98,24.49 178.11,24.62 v2(178.11,25.2) ; RC53.1 155.57,82.49 v2(155.34,82.49) 153.5,82.49 152.89,83.1 152.64,83.1 152.28,83.46 151.07,83.46 UC1.AU3
EC_WAKE#: length 72.8
  TOP w0.102: UE5.35 144.2,20.34 144.37,20.5 145.05,20.5 v2(145.27,20.72) ; RC56.2 159.84,62.36 v2(159.51,62.03)
  IN3 w0.102: v2(145.27,20.72) 145.27,21.19 147.39,23.31 166.05,23.31 168.38,25.65 170.24,25.65 171.37,26.78 171.37,33.77 170.41,34.72 170.41,36.56 168.43,38.54 168.43,40.41 168.81,40.79 168.81,43.2 168.28,43.73 168.28,45.88 167.52,46.64 167.52,50.25 163.3,54.47 163.3,56.03 161.61,57.71 161.61,58.61 160.17,60.06 160.17,61.56 159.7,62.03 v2(159.51,62.03)
EDP_AUX#_C: length 2.7
  TOP w0.089: C4322.1 4.06,95.38 3.75,95.69 3.62,95.69 v2(3.44,95.5)
  BOTTOM w0.089: JEDP.8 2.34,95.5 2.5,95.66 3.28,95.66 v2(3.44,95.5)
EDP_AUX_C: length 2.7
  TOP w0.089: C4321.1 4.06,96.18 3.75,95.88 3.64,95.88 v2(3.44,96.08)
  BOTTOM w0.089: JEDP.7 2.31,96 2.47,95.84 3.19,95.84 v2(3.44,96.08)
EDP_AUX_DN: length 140
  TOP w0.089: v2(5.85,95.5) 5.64,95.71 5.32,95.71 C4322.2
  IN3 w0.089: v2(126.15,100.11) 126.25,100 126.63,100 126.8,99.83 126.8,99.24 126.7,99.14 126.7,98.57 126.36,98.23 117.61,98.23 117.04,97.65 113.59,97.65 111.94,99.31 109.72,99.31 106.29,102.73 106.29,105.45 103.1,108.64 99.64,108.64 98.83,107.83 79.84,107.83 75.65,112.02 43.27,112.02 34.89,103.64 21.28,103.64 13.33,95.69 6.04,95.69 v2(5.85,95.5)
  BOTTOM w0.076: UC1.E45 v2(126.15,100.11)
EDP_AUX_DP: length 139.9
  TOP w0.089: C4321.2 5.32,95.89 5.66,95.89 v2(5.85,96.08)
  IN3 w0.089: v2(5.85,96.08) 6.05,95.88 13.25,95.88 21.21,103.83 34.81,103.83 43.2,112.21 75.73,112.21 79.92,108.02 98.75,108.02 99.56,108.83 103.18,108.83 106.48,105.53 106.48,102.81 109.8,99.5 112.02,99.5 113.67,97.84 116.96,97.84 117.53,98.42 126.28,98.42 126.51,98.64 126.51,99.22 126.61,99.32 126.61,99.75 126.55,99.81 126.36,99.81 126.15,99.6 v2(126.15,99.47)
  BOTTOM w0.076: UC1.F45 126.68,99.34 126.68,99.45 126.5,99.62 126.3,99.62 v2(126.15,99.47)
EDP_COMP: length 2.1
  TOP w0.076: v2(123.38,99.46) v1(123.92,99.46)
  TOP w0.254: RC1.2 123.27,99.46 v2(123.38,99.46)
  BOTTOM w0.254: v2(123.38,99.46) 123.36,99.46 UC1.E52
EDP_HPD: length 295.2
  TOP w0.076: v2(147.14,96.18) 147.25,96.07 147.25,94.99 146.93,94.67 v1(146.93,94.54) 146.93,93.79 RC220.2
  IN1 w0.076: v2(147.14,96.18) 147.14,95.14 147.53,94.75 150.58,94.75 152.27,93.06 154.32,93.06 154.87,92.51 154.87,90.32 153.79,89.25 153.22,89.25 151.81,87.83 151.81,86.66 152.58,85.88 154.39,85.88 154.45,85.95 154.87,85.95
  IN1 w0.102: v2(166.32,42.16) 166.24,42.24 166.24,45.42 165.61,46.05 165.61,52.26 163.91,53.96 163.91,56.02 164.27,56.37 165.15,56.37 166.1,57.31 166.1,60.48 167.05,61.44 167.05,64.75 170.06,67.76 170.06,73 169.51,73.54 169.51,76.33 169.16,76.68 169.16,84.5 165.94,87.72 158.54,87.72 157.65,86.83 157.14,86.83 156.25,85.95 154.87,85.95
  IN2 w0.102: v2(4.06,93.84) 4.41,94.19 7.14,94.19 9.2,92.13 16.06,92.13 19.61,88.57 23.87,88.57 24.5,87.94 24.5,80.38 25.43,79.46 25.43,70 32.57,62.86 32.57,55.06 42.33,45.3 45.68,45.3 56.06,34.92 80.03,34.92 81.93,36.82 88.13,36.82 91.58,40.27 157.06,40.27 159.48,42.69 165.79,42.69 v2(166.32,42.16)
  BOTTOM w0.076: UC1.L10 146.82,96.64 v2(147.14,96.18)
  BOTTOM w0.102: v2(4.06,93.84) 4.06,94.23 3.78,94.5 JEDP.10
EDP_TX0#_C: length 2.9
  TOP w0.089: v2(3.42,99.06) 3.61,99.24 3.74,99.24 4.04,98.94 C4311.1
  BOTTOM w0.089: v2(3.42,99.06) 3.24,99.24 3.17,99.24 2.6,98.67 2.41,98.67 2.24,98.5 JEDP.2
EDP_TX0_C: length 2.9
  TOP w0.089: v2(3.42,99.64) 3.63,99.43 3.74,99.43 4.04,99.74 C4312.1
  BOTTOM w0.089: JEDP.1 2.27,99 2.41,98.86 2.52,98.86 3.1,99.43 3.21,99.43 v2(3.42,99.64)
EDP_TX0_DN: length 138
  TOP w0.089: v2(5.84,99.05) 5.64,99.24 5.29,99.24 C4311.2
  IN3 w0.089: v2(125.09,107.04) 124.89,107.24 123.93,107.24 123.61,107.56 117.47,107.56 114.86,104.96 108.58,104.96 103.73,109.81 99.09,109.81 98.36,109.08 80.25,109.08 76.13,113.19 42.73,113.19 34.34,104.81 20.37,104.81 14.8,99.24 6.03,99.24 v2(5.84,99.05)
  BOTTOM w0.076: 125.46,104.96 125.45,104.95 125.45,104.94 125.41,104.9 125.41,104.82 125.42,104.82 125.42,104.82 125.42,101.86 UC1.C47
  BOTTOM w0.089: 125.46,104.96 125.54,105.03 125.54,107.1 125.4,107.24 125.29,107.24 v2(125.09,107.04)
EDP_TX0_DP: length 138
  TOP w0.089: v2(5.84,99.64) 5.63,99.43 5.33,99.43 C4312.2
  IN3 w0.089: v2(5.84,99.64) 6.04,99.43 14.73,99.43 20.29,105 34.26,105 42.65,113.38 76.21,113.38 80.33,109.27 98.29,109.27 99.02,110 103.81,110 108.66,105.15 114.79,105.15 117.39,107.75 123.69,107.75 124.01,107.43 124.89,107.43 v2(125.09,107.63)
  BOTTOM w0.076: UC1.C46 125.58,101.77 125.58,104.82 125.59,104.83
  BOTTOM w0.089: 125.59,104.83 125.72,104.96 125.72,107.18 125.47,107.43 125.29,107.43 v2(125.09,107.63)
EDP_TX1#_C: length 2.8
  TOP w0.089: v2(3.42,97.28) 3.61,97.46 3.74,97.46 4.04,97.16 C4313.1
  BOTTOM w0.089: JEDP.5 2.32,97 2.47,97.15 2.74,97.15 3.06,97.48 3.22,97.48 v2(3.42,97.28)
EDP_TX1_C: length 2.8
  TOP w0.089: C4314.1 4.04,97.96 3.74,97.65 3.63,97.65 v2(3.42,97.86)
  BOTTOM w0.089: v2(3.42,97.86) 3.22,97.66 2.99,97.66 2.66,97.34 2.47,97.34 2.31,97.5 JEDP.4
EDP_TX1_DN: length 142.3
  TOP w0.089: v2(5.84,97.27) 5.62,97.49 5.31,97.49 C4313.2
  IN3 w0.089: v2(126.3,107.78) 126.3,106.87 125.6,106.16 123.61,106.16 122.91,106.86 117.66,106.86 115.12,104.32 108.39,104.32 103.49,109.22 99.34,109.22 98.61,108.49 80.01,108.49 75.89,112.61 43.03,112.61 34.65,104.23 20.93,104.23 14.17,97.46 6.03,97.46 v2(5.84,97.27)
  BOTTOM w0.076: 126.3,104.01 126.3,103.99 126.29,103.99 126.29,103.48 126.72,103.06 126.72,102.51 126.67,102.38 126.67,102.19 126.69,102.15 126.71,102.1 126.71,101.85 126.69,101.8 126.65,101.65 126.63,101.58 126.58,101.41 126.58,101.27 126.53,101.16 126.36,100.99 UC1.D46
  BOTTOM w0.089: 126.3,104.01 126.3,105.34 126.33,105.37 126.33,106.14 126.3,106.17 v2(126.3,107.78)
EDP_TX1_DP: length 142.2
  TOP w0.089: v2(5.84,97.86) 5.65,97.67 5.31,97.67 C4314.2
  IN3 w0.089: v2(5.84,97.86) 6.04,97.65 14.09,97.65 20.85,104.42 34.57,104.42 42.95,112.8 75.97,112.8 80.08,108.68 98.53,108.68 99.26,109.41 103.56,109.41 108.47,104.51 115.04,104.51 117.58,107.05 122.99,107.05 123.69,106.35 125.52,106.35 126.11,106.95 126.11,107.38 v2(125.72,107.78)
  BOTTOM w0.076: UC1.C45 126.12,101.15 125.97,101.15 125.85,101.27 125.85,101.35 126.11,101.61 126.4,101.61 126.48,101.69 126.54,101.88 126.54,102.07 126.51,102.16 126.51,102.41 126.55,102.54 126.55,102.98 126.12,103.41 126.12,103.99 126.12,103.99 126.12,104.01
  BOTTOM w0.089: v2(125.72,107.78) 126.12,107.38 v4(126.12,105.85) 126.12,104.01
EDP_VDD_EN: length 281.9
  TOP w0.102: v1(13.39,88.4) v2(13,88) 13,86.88 DX5.2
  IN1 w0.076: v2(145.37,93.03) 145.37,93.42 145.73,93.78 151.08,93.78 151.61,93.25 152.13,92.73 154.15,92.73 154.54,92.34 154.54,90.46 153.66,89.58 152.31,89.58 151.48,88.74 151.48,86.52 152.45,85.55 154.23,85.55 154.3,85.49 154.87,85.49
  IN1 w0.102: v2(165.91,40.7) 165.69,40.93 165.69,45.33 165.16,45.86 165.16,52.07 163.46,53.77 163.46,56.21 164.08,56.83 164.96,56.83 165.64,57.5 165.64,60.67 166.59,61.62 166.59,64.94 169.6,67.94 169.6,72.81 169.06,73.35 169.06,76.14 168.7,76.5 168.7,83.84 165.27,87.27 158.73,87.27 157.81,86.34 157.39,86.34 156.54,85.49 154.87,85.49
  IN2 w0.102: v2(13,88) 13.19,87.81 23.36,87.81 23.74,87.43 23.74,79.87 24.63,78.99 24.63,69 31.81,61.83 31.81,54.86 42.04,44.62 45.39,44.62 55.86,34.15 80.24,34.15 81.52,35.44 88.14,35.44 92.22,39.51 157.38,39.51 159.84,41.97 164.64,41.97 v2(165.91,40.7)
  BOTTOM w0.076: v2(145.37,93.03) 145.37,93.04 144.84,93.57 UC1.U13
EDRAM_OPIO_RCOMP: length 2.2
  TOP w0.076: v2(113.93,98.27) 114.23,97.97 v1(114.23,97.72)
  TOP w0.254: v2(113.93,98.27) 113.59,97.93 RC7.1
  BOTTOM w0.254: UC1.H66 114.2,98 v2(113.93,98.27)
EMMC_RCOMP: length 2.9
  BOTTOM w0.254: UC1.AT1 151.91,83.73 152.39,83.73 152.56,83.56 v1(153.45,83.56) 153.97,83.56 RC89.2
EN_0.675VSP: length 3.8
  TOP w0.102: v2(82.92,12.95) v1(82.92,12.25)
  TOP w0.254: v2(82.92,12.95) 83.11,13.14 PC203.1
  BOTTOM w0.203: PU200.7 83.12,13.14 v2(82.92,12.95) 82.23,12.25 PR202.2
EN_1.0V_VCCSTU: length 28.1
  TOP w0.102: RC144.2 159.76,65.75 CC104.1 160.19,65.7 160.28,65.79 160.78,65.79 160.99,65.57 160.99,65.07 161.23,64.82 162.11,64.82 162.46,65.18 163.73,65.18 164.17,64.73 169.06,64.73 v1(170.97,66.63) 171.76,67.43 171.76,69.33 172.85,70.43 v2(173.15,70.43) ; UC5.3 177.76,75.21 177.16,74.6 177.16,71.37 v2(177.35,71.17)
  BOTTOM w0.102: v2(173.15,70.43) 173.89,71.17 v2(177.35,71.17)
EN_1.0VS: length 4.2
  TOP w0.102: UV10.5 92.34,62.31 RV210.2 93.88,62.62 v1(95.14,62.62)
EN_1.8VALW: length 92.7
  TOP w0.102: v2(156,24.2) 156,24.19 153.7,21.89 R2460.1
  IN2 w0.102: v2(82.31,33.74) 82.53,33.52 96.46,33.52 104.31,25.67 155.31,25.67 156,24.98 v2(156,24.2)
  IN3 w0.102: v2(82.31,33.74) 82.31,31.03 80.32,29.04 v2(80.32,28.76)
  BOTTOM w0.254: PC505.1 83.26,27.67 PU501.1 ; PC505.1 82.67,29.13 PR504.2 ; PC505.1 PR505.1 PR507.2 80.82,28.26 v2(80.32,28.76)
EN_1.8VS: length 2
  TOP w0.203: RC194.2 178.56,73.72 v1(178.56,74.6) UC5.5
EN_1.35V: length 3.7
  TOP w0.254: v2(82.61,13.45) 82.61,13.9 v1(82.86,14.15) PC202.1
  BOTTOM w0.203: PR201.2 82.3,13.45 v2(82.61,13.45) 82.7,13.54 PU200.8
EN_3V: length 28.7
  TOP w0.254: PD101.2 63.86,32.12 57.33,32.12 v1(56.57,31.36) v2(56.57,30.28)
  IN3 w0.254: v2(61.51,17.68) 55.49,23.7 55.49,29.2 v2(56.57,30.28)
  BOTTOM w0.254: PU100.12 61.57,17.62 v2(61.51,17.68) 61.38,17.81 60.39,17.81 PR121.1
EN_3V_PRIM: length 3.2
  TOP w0.102: RC174.2 v1(178.54,97.32) ; RC174.2 RC191.2 ; RC174.2 177.54,96.83 177.33,96.62 UC8.4
EN_5V: length 6
  TOP w0.254: PR120.1 62.35,29.76 v2(62.35,29.39) v1(62.86,28.88) 63.18,28.57 64.38,28.57 64.89,29.07 PD101.3
  BOTTOM w0.254: PU102.12 62.46,29.28 v2(62.35,29.39)
EN_+1VALWP: length 8
  BOTTOM w0.254: PR315.2 182.37,42.71 PR314.2 PR312.1 PR313.2 PR302.1 PC405.1 182.17,46.41 v1(180.9,47.68) 179.9,48.69 PU301.1
ENLDO_3V5V: length 27.6
  TOP w0.102: PR102.1 59.44,17.38 58.92,17.9 v1(58.79,17.9)
  TOP w0.254: PR103.1 61.14,16.69 v2(60.51,17.33) 59.92,17.33 PR102.1
  IN3 w0.254: v2(61.28,29.15) 61.28,29.44 60.32,30.41 57.71,30.41 57.33,30.79 56,30.79 54.86,29.65 54.86,23.68 60.51,18.03 v2(60.51,17.33)
  BOTTOM w0.254: PU102.11 62.01,28.97 61.83,29.15 v2(61.28,29.15) ; PU100.11 61.12,17.16 60.95,17.33 v2(60.51,17.33)
ENVDD_R: length 25.4
  TOP w0.102: RX48.1 DX5.1 14.69,83.65 14.47,83.43 v1(14.47,76.51) v2(14.47,74.1)
  TOP w0.508: UX4.4 v2(23.17,75.73)
  IN3 w0.102: v2(14.47,74.1) 18.31,74.1 19.17,73.23 21.48,73.23 23.17,74.92 v2(23.17,75.73)
EOPIO_RCOMP: length 1.9
  TOP w0.076: v1(116.39,97.97) 116.13,98.23 v2(115.94,98.23)
  TOP w0.254: RC8.1 115.64,98.23 v2(115.94,98.23)
  BOTTOM w0.254: UC1.H65 115.68,98.23 v2(115.94,98.23)
EXT_PWR_GATE#_R: length 3.3
  TOP w0.102: UC4.4 187.72,75.72 188.51,74.93 RC210.2 188.78,75.98 v1(188.96,76.15)
FAN1_DAC_1: length 183
  TOP w0.102: v2(145.34,14.79) 145.58,14.55 UE5.24 ; UE3.4 v2(2.98,70.92) v1(1.96,70.92)
  IN1 w0.102: v2(2.98,70.92) 6.98,66.92 6.98,64.32 7.55,63.75 10.47,63.75 15.27,58.94 20.44,58.94 23.88,62.39 23.88,64.96 24.16,65.24 27.13,65.24 29.34,63.03 29.34,56.55 40.82,45.08 44.95,45.08 54.98,35.04 79.77,35.04 80.59,35.86 83.55,35.86 84.37,35.04 95.82,35.04 106.71,24.15 108.59,24.15 112.95,19.8 114.29,19.8 115.06,20.57 122.45,20.57 123.6,19.42 128.42,19.42 129.76,18.09 130.12,18.09 132.44,15.76 134.06,15.76 135.38,14.45 140.14,14.45 140.32,14.62 145.18,14.62 v2(145.34,14.79)
FAN1_TACH: length 194.4
  TOP w0.102: UE5.40 v2(142.2,21.07) 142.2,21.37 CE86.1 142.6,22.66 RE353.1 ; CE24.1 RE50.2 3.44,73.09 v3(2.79,72.44) 2.79,71.78 v2(3.02,71.56)
  IN1 w0.102: v2(142.2,21.07) 141.23,22.05 135.67,22.05 134.88,21.26 134.88,20.76 134.2,20.08 131.84,20.08 131.52,20.4 131.52,21.28 130.04,22.75 113.02,22.75 109.52,26.24 107.58,26.24 104.7,29.12 104.7,32.19 99.57,37.32 87.39,37.32 87.06,37.65 81.08,37.65 79.91,36.48 54.95,36.48 45.43,45.99 41.7,45.99 31.68,56.01 31.68,62.73 26.92,67.49 23.68,67.49 21.65,65.46 21.65,60.48 20.34,59.17 15.68,59.17 15.36,59.49 15.36,66.03 14.2,67.19 7.09,67.19 3.44,70.84 3.44,71.14 v2(3.02,71.56)
  BOTTOM w0.102: JFAN.2 5.8,71.08 5.57,70.84 3.73,70.84 v2(3.02,71.56)
FB_1.8VALW: length 4.7
  BOTTOM w0.254: PC503.2 82.68,25.15 PR501.2 ; PR501.2 82.7,25.13 PR506.1 81.73,23.3 v1(81.4,23.3) ; PR501.2 83.75,25.15 PU501.6
FB_1.35V: length 6.6
  BOTTOM w0.102: v1(80.45,8.25) 80.45,9.78 PR207.1
  BOTTOM w0.203: PR204.1 83.37,12.74 PU200.6
  BOTTOM w0.254: PR204.1 81.97,11.35 PC214.1 PR207.1
FB_+1VALWP: length 5.4
  BOTTOM w0.102: PR311.1 v1(184.74,50.88)
  BOTTOM w0.254: PR311.1 183.53,50.88 PR306.2 181.81,49.98 PR308.2 181.48,50.31 PU301.4
FB_A_CLK0: length 80.7
  TOP w0.102: UV5.J7 67.68,99.51 67.68,99.22 67.79,99.11 67.87,99.11 67.92,99.06 68,99.06 68.07,99.13 68.07,99.39 68.14,99.46 68.27,99.46 68.49,99.24 68.86,99.24 69.14,99.52 69.49,99.52 69.6,99.41 69.6,99.25 69.44,99.09 v2(69.32,99.09) ; v2(55.17,98.77) 55.06,98.77 54.82,98.53 54.82,98.4 54.6,98.18 54.12,98.18 53.61,98.7 53.61,98.9 53.4,99.11 53.2,99.11 53.07,99.24 53.07,99.41 53.24,99.58 UV9.J7
  IN1 w0.102: v2(56.3,83.39) 56.64,83.05 57.32,83.05 57.57,83.31 58.08,83.31 58.91,84.13 60.12,84.13 60.62,84.63 60.62,86.17 61.32,86.87 61.32,90.24 61.22,90.34 60.42,90.34 60.17,90.58 60.17,91 60.42,91.24 62.46,91.24 62.7,91 62.7,89.34 62.83,89.21 63.16,89.21 63.29,89.34 63.29,90.45 63.5,90.67 65.14,90.67 65.27,90.8 65.27,91.05 65.14,91.18 63.5,91.18 63.29,91.39 63.29,91.62 63.16,91.75 59.25,91.75 59.01,91.99 59.01,92.41 59.25,92.65 63.16,92.65 63.29,92.78 63.29,93.03 63.16,93.16 60.79,93.16 60.57,93.37 60.57,93.84 60.79,94.06 61.52,94.06 61.65,94.18 61.65,94.99 61.52,95.11 59.22,95.11 58.98,95.36 58.98,96.02 59.22,96.26 62.33,96.26 v2(62.48,96.41)
  IN3 w0.102: 65.03,97.15 65.03,97.76 65.47,98.2 67.95,98.2 68.17,98.42 69.69,98.42 69.85,98.57 69.85,98.66 69.42,99.09 v2(69.32,99.09) ; v2(55.17,98.77) 55.1,98.83 55.01,98.83 54.91,98.73 54.91,98.62 54.86,98.56 54.86,98.41 54.93,98.34 58.62,98.34 59.14,97.81 59.14,97.46 59.16,97.45 59.16,97.43
  IN3 w0.127: 65.03,97.15 65.03,96.75 64.48,96.21 62.78,96.21 62.73,96.26 62.63,96.26 v2(62.48,96.41) 62.33,96.26 59.6,96.26 59.16,96.7 59.16,97.43
  BOTTOM w0.102: UV8.J7 70.95,99.72 70.87,99.8 70.68,99.8 70.6,99.73 70.6,98.79 70.22,98.42 69.6,98.42 69.37,98.65 69.37,99.04 v2(69.32,99.09) ; v2(55.17,98.77) 54.88,99.06 54.88,99.32 54.98,99.43 55.18,99.43 55.33,99.27 55.81,99.27 56.05,99.51 56.05,99.77 56.27,99.99 56.53,99.99 56.62,99.9 56.62,99.73 UV4.J7
  BOTTOM w0.112: UV1.D24 56.69,83 56.32,83.37 v2(56.3,83.39)
  BOTTOM w0.127: v2(62.48,96.41) 62.54,96.35 62.88,96.35 RV2706.1
