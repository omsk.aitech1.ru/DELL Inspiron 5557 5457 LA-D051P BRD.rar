# Allegro board LA-D051P Boardview.brd (continued)
## Nets (continued)
+1.0V_VCCST: CC48.1 PC602.1 PR601.1 PR604.1 PR605.1 RC2.1 RC14.2 RC113.1 RC140.2 RC179.1 RC181.1 RC184.2 UC1.A18
+1.0V_VCCSTU: CC96.1 RC140.1 RC143.1 UC5.13 UC5.14
+1.0V_XDP: RC12.2 RC31.1
+1.0VO_DSW: CC85.1 UC1.AL1
+1.0VS_DGPU: CV2.1 CV3.1 CV7.1 CV8.1 CV9.1 CV10.1 CV21.1 CV22.1 CV23.1 CV24.1 CV25.1 CV26.1 CV27.1 CV28.1 CV65.1 CV296.1 LV3.1 LV4.2 LV5.1 RV12.1 UV1.AA10 UV1.AA12 UV1.AA13 UV1.AA16 UV1.AA18 UV1.AA19 UV1.AA20 UV1.AA21 UV1.AA22 UV1.AB22 UV1.AB23 UV1.AC23 UV1.AC24 UV1.AD24 UV1.AD25 UV1.AE25 UV1.AE26 UV1.AE27 UV1.AF26 UV1.AF27 UV10.8 UV10.9
+1.0VS_PLLAVDD: CV51.1 CV52.2 CV53.1 CV55.1 LV4.1 UV1.F16 UV1.H22 UV1.P22
+1.0VS_VCCIO: CC27.1 CC28.1 CC29.1 CC30.1 CC31.1 CC32.1 CC33.1 CC34.1 CC35.1 CC36.1 CC90.1 JP15.2 RC1.1 UC1.AK28 UC1.AK30 UC1.AL30 UC1.AL42 UC1.AM28 UC1.AM30 UC1.AM42
+1.0VS_VCCSTG: CC56.1 CC89.1 RC3.1 RC11.2 RC13.2 RC15.2 RC188.2 UC1.A22 UC1.G20
+1.0VS_VCCSTG_IO: JP15.1 RC188.1 UC6.6
+1.8V_PG: PR312.2 PU501.5
+1.8V_PRIM: CC72.1 PJP502.2 RC196.1 RC361.1 RC393.1 UC1.AA1 UC1.AF16
+1.8V_PRIM_VS: CC99.1 RC393.2 UC5.6 UC5.7
+1.8VALWP: PC501.1 PC503.1 PC504.1 PJP502.1 PL501.2 PR501.1
+1.8VS: CC100.1 RA8.1 RC177.1 UC5.8 UC5.9
+1.8VS_3VS_PGPPA: RC107.2 RC122.2 RC177.2 RC178.2 RC225.2
+1.35V_VCCSFR_OC: CC49.1 RC141.2 UC1.AL23
+1.35V_VDDQ: CC37.1 CC38.1 CC39.1 CC40.1 CC41.1 CC42.1 CC43.1 CC44.1 CC45.1 CC46.1 CC57.1 CD4.1 CD5.1 CD6.1 CD7.1 CD8.1 CD9.1 CD10.1 CD11.1 CD12.1 CD13.1 CD14.1 CD15.1 CD16.1 CD19.1 CD20.1 CD32.1 CD33.1 CD34.1 CD35.1 CD36.1 CD37.1 CD38.1 CD39.1 CD40.1 CD41.1 CD42.1 CD43.1 CD44.1 CD45.1 CD46.1 CV117.1 CV290.1 JDIMM1.75 JDIMM1.76 JDIMM1.81 JDIMM1.82 JDIMM1.87 JDIMM1.88 JDIMM1.93 JDIMM1.94 JDIMM1.99 JDIMM1.100 JDIMM1.105 JDIMM1.106 JDIMM1.111 JDIMM1.112 JDIMM1.117 JDIMM1.118 JDIMM1.123 JDIMM1.124 JDIMM2.75 JDIMM2.76 JDIMM2.81 JDIMM2.82 JDIMM2.87 JDIMM2.88 JDIMM2.93 JDIMM2.94 JDIMM2.99 JDIMM2.100 JDIMM2.105 JDIMM2.106 JDIMM2.111 JDIMM2.112 JDIMM2.117 JDIMM2.118 JDIMM2.123 JDIMM2.124 PJP200.2 PJP202.2 QV7.5 RC141.1 RC208.1 RD1.1 RD9.1 RD13.1 RD18.1 UC1.AU23 UC1.AU28 UC1.AU35 UC1.AU42 UC1.BB23 UC1.BB32 UC1.BB41 UC1.BB47 UC1.BB51 UC7.5
+1.35V_VDDQC: CC47.1 CC141.1 RC208.2 UC1.AM40
+1.35VP: PC213.1 PC214.2 PC215.1 PC216.1 PC217.1 PC218.1 PC219.1 PC220.1 PJP200.1 PJP202.1 PL200.1 PR207.2 PU200.5 PU200.19
+1.35VS_VRAM: CV38.1 CV39.1 CV40.1 CV41.1 CV42.1 CV43.1 CV44.1 CV45.1 CV57.1 CV72.2 CV73.2 CV74.2 CV75.2 CV76.2 CV77.2 CV78.2 CV79.2 CV80.2 CV81.2 CV82.2 CV162.1 CV163.1 CV164.1 CV165.1 CV166.1 CV167.1 CV168.1 CV169.1 CV170.1 CV198.1 CV199.1 CV201.1 CV202.1 CV203.1 CV204.1 CV205.1 CV206.1 CV207.1 CV235.1 CV236.1 CV237.1 CV238.1 CV239.1 CV240.1 CV241.1 CV242.1 CV243.1 CV244.1 CV245.1 CV246.1 CV247.1 CV248.1 CV249.1 CV250.1 CV251.1 CV252.1 CV253.1 CV254.1 CV255.1 CV256.1 CV257.1 CV258.1 CV259.1 CV260.1 CV261.1 CV262.1 CV263.1 CV264.1 CV265.1 CV266.1 CV267.1 CV268.1 CV269.1 CV270.1 CV271.1 CV272.1 CV273.1 CV274.1 CV275.1 CV276.1 CV277.1 CV278.1 CV279.1 CV280.1 CV281.1 CV282.1 CV283.1 CV284.1 CV285.1 CV286.1 CV287.1 CV288.1 CV292.1 QV7.1 QV7.2 QV7.3 RPV8.6 RPV8.7 RPV9.6 RPV9.7 RPV10.6 RPV10.7 RPV11.6 RPV11.7 RPV12.6 RPV12.7 RPV13.6 RPV13.7 RPV14.6 RPV14.7 RPV15.6 RPV15.7 RPV16.6 RPV16.7 RPV17.6 RPV17.7 RPV18.6 RPV18.7 RV41.2 RV82.2 RV83.2 RV95.1 RV100.1 RV108.1 RV115.1 RV2721.2 UV1.B26 UV1.C25 UV1.E23 UV1.E26 UV1.F14 UV1.F21 UV1.G13 UV1.G14 UV1.G15 UV1.G16 UV1.G18 UV1.G19 UV1.G20 UV1.G21 UV1.H24 UV1.H26 UV1.J21 UV1.K21 UV1.L22 UV1.L24 UV1.L26 UV1.M21 UV1.N21 UV1.R21 UV1.T21 UV1.V21 UV1.W21 UV4.A1 UV4.A8 UV4.B2 UV4.C1 UV4.C9 UV4.D2 UV4.D9 UV4.E9 UV4.F1 UV4.G7 UV4.H2 UV4.H9 UV4.K2 UV4.K8 UV4.N1 UV4.N9 UV4.R1 UV4.R9 UV5.A1 UV5.A8 UV5.B2 UV5.C1 UV5.C9 UV5.D2 UV5.D9 UV5.E9 UV5.F1 UV5.G7 UV5.H2 UV5.H9 UV5.K2 UV5.K8 UV5.N1 UV5.N9 UV5.R1 UV5.R9 UV6.A1 UV6.A8 UV6.B2 UV6.C1 UV6.C9 UV6.D2 UV6.D9 UV6.E9 UV6.F1 UV6.G7 UV6.H2 UV6.H9 UV6.K2 UV6.K8 UV6.N1 UV6.N9 UV6.R1 UV6.R9 UV7.A1 UV7.A8 UV7.B2 UV7.C1 UV7.C9 UV7.D2 UV7.D9 UV7.E9 UV7.F1 UV7.G7 UV7.H2 UV7.H9 UV7.K2 UV7.K8 UV7.N1 UV7.N9 UV7.R1 UV7.R9 UV8.A1 UV8.A8 UV8.B2 UV8.C1 UV8.C9 UV8.D2 UV8.D9 UV8.E9 UV8.F1 UV8.G7 UV8.H2 UV8.H9 UV8.K2 UV8.K8 UV8.N1 UV8.N9 UV8.R1 UV8.R9 UV9.A1 UV9.A8 UV9.B2 UV9.C1 UV9.C9 UV9.D2 UV9.D9 UV9.E9 UV9.F1 UV9.G7 UV9.H2 UV9.H9 UV9.K2 UV9.K8 UV9.N1 UV9.N9 UV9.R1 UV9.R9 UV14.A1 UV14.A8 UV14.B2 UV14.C1 UV14.C9 UV14.D2 UV14.D9 UV14.E9 UV14.F1 UV14.G7 UV14.H2 UV14.H9 UV14.K2 UV14.K8 UV14.N1 UV14.N9 UV14.R1 UV14.R9 UV15.A1 UV15.A8 UV15.B2 UV15.C1 UV15.C9 UV15.D2 UV15.D9 UV15.E9 UV15.F1 UV15.G7 UV15.H2 UV15.H9 UV15.K2 UV15.K8 UV15.N1 UV15.N9 UV15.R1 UV15.R9
+1VALWP: PC307.1 PC308.1 PC309.1 PC310.1 PC311.1 PJP302.1 PL301.2 PR306.1
+3V_1.8V_PGPPA: RC196.2 RC197.2 UC1.AK15
+3V_PGPPB: CC102.1 RC161.2 UC1.AG15
+3V_PGPPC: CC73.1 RC163.2 UC1.Y16
+3V_PGPPD: CC103.1 RC172.2 UC1.Y15
+3V_PGPPE: CC74.1 RC167.2 UC1.T16
+3V_PRIM: CC51.1 CC63.1 CC67.1 CC113.1 CC114.1 CC115.1 CC116.1 JP16.2 JP18.2 PR314.1 QC3.2 QC3.5 RC49.2 RC50.2 RC64.2 RC68.2 RC108.1 RC110.2 RC154.1 RC161.1 RC163.1 RC167.1 RC171.1 RC172.1 RC197.1 RC202.1 RC221.1 RC229.1 RC233.2 RC234.1 RC327.2 RI54.1 RI55.1 RPC7.5 RPC7.6 RPC7.7 RPC7.8 RPC14.5 RPC14.6 RPC14.7 RPC14.8 RPC18.5 RPC18.6 RPC18.7 RPC18.8 UC1.AD15 UC1.AJ19 UC1.AJ21 UC1.V19
+3V_PRIM_RTC: CC77.1 CC78.1 RC171.2 UC1.AK17
+3V_PRIMJP: JP18.1 UC8.1
+3V_SPI: CC8.1 JC1.8 RC47.2 RC48.2 RC53.2 RC154.2 UC1.AJ16 UC2.8
+3VALW: C2316.1 C2318.1 C5224.1 CC50.1 CC83.1 CC92.1 CL39.1 DC8.2 JP3.2 JP16.1 PC312.1 PJP102.2 PJP501.1 PR3.2 PR16.2 PR28.1 PR37.1 PR209.1 PR307.1 PU301.7 RA10.1 RC9.1 RC115.1 RC123.1 RC166.2 RC209.1 RE332.2 RE342.2 RE348.2 RE356.2 RE358.2 RE360.2 RE361.2 RE363.1 RE379.2 RE380.1 RE384.1 RE390.1 RE391.1 RE392.1 RE393.1 RE394.1 RE400.1 RL40.1 RM11.1 RPE1.5 RPE1.6 RPE1.7 RPE1.8 RPE2.5 RPE2.6 RPE2.7 RPE2.8 RPE3.1 RPE3.2 RPE3.3 RPE3.4 RPE4.1 RPE4.2 RPE4.3 RPE4.4 RPE5.1 RPE5.2 RPE5.3 RPE5.4 RPE6.1 RPE6.2 RPE6.3 RPE6.4 U2301.6 U2301.7 UC8.5 UC11.5 UC12.5 UC13.5 UC15.5 UL3.5
+3VALW_DSW: RC103.1 RC104.1 RC106.1 RC111.2 RC209.2 RPC11.7 UC1.AD17 UC1.AD18 UC1.AJ17
+3VALW_EC: CE62.1 CE63.1 CE64.2 CE65.2 CE66.1 CE67.1 CE68.1 CE69.1 CE70.1 CE78.1 CE80.1 JLED.3 R2452.1 RE342.1 RE343.1 RE346.2 RE347.2 RE349.2 RE350.2 RE351.2 RE352.1 RE354.2 RI93.2 RI94.2 UE5.5 UE5.19 UE5.22 UE5.43 UE5.65 UE5.82 UE5.103 UE5.115
+3VALWP: PC106.1 PC107.1 PC108.1 PC109.1 PC110.1 PJP102.1 PL100.2 PR107.1 PR108.2 PR109.1 PR113.1 PU100.14
+3VL_RTC: CC79.1 CC84.1 DC1.1 DC8.1 RA11.1 RC91.1 RC93.1 RC94.1 RE345.2 RE370.2 RE376.1 UC1.AK19 UC1.BB14
+3VL_RTC_VBAT: CE72.1 RE345.1 UE5.122
+3VLP: DC1.3 PC111.1 PU100.16 PU100.17 RE333.2 RE369.2
+3VS: C2323.1 C2324.1 C2498.1 C5225.1 CA57.1 CA58.1 CA59.1 CA60.1 CC14.1 CD26.1 CD27.1 CD54.1 CD55.1 CE82.1 CI20.2 CI23.2 CM8.2 CM9.1 CS27.1 CS42.1 CX1.1 CX7.1 DB1.9 DB1.10 J511.1 JDIMM1.199 JDIMM2.199 JDIMM2.201 JEDP.34 JEDP.35 JIO.6 PR612.1 PR804.2 PR814.1 Q2409.2 Q2409.5 QC2.2 QC2.5 QE6.2 QE6.5 QE11.2 QX3.2 QX4.2 QX4.5 QX5.1 R2448.1 R2456.1 R2457.1 RA13.2 RA14.1 RC62.2 RC63.2 RC65.2 RC117.1 RC118.1 RC125.1 RC126.1 RC127.1 RC129.1 RC178.1 RC199.2 RC200.2 RC201.2 RC206.2 RC215.1 RC216.1 RC217.1 RC218.1 RC222.1 RC224.1 RC230.2 RC231.2 RC314.1 RC318.1 RC320.2 RC321.2 RC322.2 RC323.1 RC325.1 RC329.2 RC330.2 RC388.2 RC390.1 RC391.1 RC394.1 RC395.1 RE50.1 RE330.1 RE353.2 RE399.1 RI19.1 RI20.1 RI21.1 RI22.1 RI23.1 RI26.1 RI42.1 RI44.1 RI52.1 RI53.1 RI88.1 RI89.1 RI91.2 RL33.1 RM7.1 RM10.1 RPC1.1 RPC1.2 RPC1.3 RPC1.4 RPC10.5 RPC10.6 RPC10.7 RPC10.8 RPC11.5 RS19.1 RS20.1 RS25.1 RS26.1 RS27.1 RS28.1 RS29.1 RS30.1 RS33.2 RS34.2 RS38.2 RV207.1 RV211.2 RX10.1 RX12.1 RX13.1 RX27.1 RX30.1 U2407.1 UA1.1 UA1.9 UA1.36 UC3.5 UE6.5 UI8.1 UI8.13 UX4.5
+3VS_CAM: JEDP.29 RX27.2
+3VS_D: CV58.1 CV289.1 QV6.3 RV207.2 UV10.1 UV10.2
+3VS_DGPU: CV56.1 CV291.1 PR801.2 RV40.1 RV80.1 RV81.1 RV84.1 UV10.13 UV10.14
+3VS_DGPU_AON: CV4.1 CV5.1 CV19.1 CV64.1 CV295.1 QV6.1 RPV5.6 RPV5.7 RPV5.8 RPV6.8 RPV7.6 RPV7.7 RV23.2 RV45.1 RV46.1 RV47.1 RV51.1 RV58.1 RV61.1 RV68.1 RV69.2 RV203.2 RV204.2 RV208.2 RV2718.2 UV1.AA8 UV1.AA9 UV1.AB8 UV12.5 UV13.5
+3VS_TOUCH: CE58.1 JTP.8 QE7.2 QE9.1 RC78.2 RE329.1 RE334.1 RE335.1 RE338.1 RE339.1 RE399.2 RE402.1
+3VS_WLAN_NGFF: CM4.1 CM5.1 CM6.1 CM7.1 CM10.1 JNGFF.2 JNGFF.4 JNGFF.64 JNGFF.66 RM7.2 RM8.1 RM10.2 RM11.2
+5V_CAM: C94.2 J521.2 JCAM3D.1 JCAM3D.2 U2409.7 U2409.8
+5V_HDD: CS5.1 CS6.1 CS7.1 JHDD.9 JHDD.10 JP13.1
+5V_PVDD: CA53.1 CA54.1 CA55.1 CA56.1 RA1110.1 UA1.41 UA1.46
+5V_USB_PWR1: CI1.1 CI2.1 CI40.1 JUSB1.1 RI111.1 UI5.1
+5V_USB_PWR2: CI8.1 CI9.1 CI43.1 JUSB2.1 RI111.2 UI6.1
+5V_USB_PWR3: JIO.1 JIO.2 JIO.3 JIO.4 UI7.1
+5VA: CA51.1 CA71.1 RA1111.1 UA1.26
+5VALW: C2305.1 C2306.1 C5221.1 C5222.1 CC52.1 CC88.1 CC98.1 CI6.1 CI7.1 CI12.1 CI14.1 CI18.1 CI44.1 CI45.1 CV63.1 CV293.1 J521.1 JLED.1 JWDB1.4 PC685.1 PJP103.2 PR8.1 PR206.1 PR210.2 PR602.2 PR662.2 PU602.9 PU602.10 PU606.6 RV212.2 RV2719.1 RV2720.1 U2301.1 U2301.2 U2301.4 U2409.1 U2409.2 U2409.4 UC4.3 UC5.4 UC6.3 UI5.5 UI6.5 UI7.5 UV10.4
+5VALWP: PC120.1 PC121.1 PC122.1 PC123.1 PC124.1 PJP103.1 PL101.2 PR115.1 PR117.2 PU102.14
+5VS: C2307.1 C2308.1 C5223.1 CE25.1 CE56.1 DX3.2 DX4.1 FE1.2 J510.1 JLED.2 JP13.2 PR817.2 QE10.3 RA1110.2 RA1111.2 RX29.1 UE3.1 UE3.2
+5VS_KBL: CE57.1 FE1.1 JKBBL.1
+17.4V_BATT+: PC7.1 PC761.1 PC766.1 PC775.1 PC776.1 PC777.1 PJP3.2 PL3.1 PQ710.3 PR745.2 PR765.4 PR780.2
+17.4V_BATT++: PBATT.8 PBATT.9 PC8.1 PJP3.1 PL3.2
+19V_ADPIN: PC1.1 PC2.1 PJP1.2 PJPDC.4 PJPDC.5 PL1.1
+19V_VIN: PC3.1 PC4.1 PD704.2 PJP1.1 PL1.2 PQ740.5 PR5.1 PR7.2 PR31.2 PR720.1 PR729.1 PR739.2 PR744.2
+19VB: FX3.1 PD706.1 PJP105.1 PJP106.1 PJP206.2 PJP301.2 PJP601.2 PJP701.1 PJP801.1 PL102.1 PL103.1 PL602.2 PL704.1 PL801.1 PQ709.4 PQ717.5 PR102.2 PR703.4 RX4.1
+19VB_1.35V: PC201.1 PC206.1 PC208.1 PC212.1 PJP206.1 PQ201.2 PQ201.3 PQ201.4 PQ201.10 PR208.1
+19VB_+1VALWP: PC301.1 PC303.1 PC305.1 PC306.1 PJP301.1 PU301.8
+19VB_VGA: PC813.1 PC814.1 PC2118.1 PC2119.1 PC2120.1 PC2121.1 PJP801.2 PL801.2 PQ800.2 PQ801.2 PR809.2
+VCC_CORE: CV297.1 CV298.1 CV299.1 CV300.1 PC1001.1 PC1002.1 PC1003.1 PC1004.1 PC1005.1 PC1006.1 PC1007.1 PC1008.1 PC1009.1 PC1010.1 PC1011.1 PC1012.1 PC1013.1 PC1030.1 PC1033.1 PC1034.1 PC1036.1 PC1037.1 PC1038.1 PC1039.1 PC1050.1 PC1052.1 PC1053.1 PC1061.1 PC1062.1 PC1064.1 PC1065.1 PC1066.1 PC1069.1 PC1070.1 PC1071.1 PC1072.1 PC1073.1 PC1074.1 PC1075.1 PC1076.1 PC1077.1 PC1078.1 PC1079.1 PC1080.1 PC1081.1 PC1082.1 PC1083.1 PC1084.1 PC1085.1 PC1086.1 PC1087.1 PC1088.1 PC1089.1 PC1090.1 PC1092.1 PC1093.1 PC1094.1 PC1095.1 PC1096.1 PC1097.1 PC1098.1 PC1099.1 PC1125.1 PC1126.1 PC1127.1 PC1164.1 PC1173.1 PC1174.1 PL603.2 PR673.1 RC203.2 UC1.A30 UC1.A34 UC1.A39 UC1.A44 UC1.AK33 UC1.AK35 UC1.AK37 UC1.AK38 UC1.AK40 UC1.AL33 UC1.AL37 UC1.AL40 UC1.AM32 UC1.AM33 UC1.AM35 UC1.AM37 UC1.AM38 UC1.G30 UC1.G32 UC1.G33 UC1.G35 UC1.G37 UC1.G38 UC1.G40 UC1.G42 UC1.J30 UC1.J33 UC1.J37 UC1.J40 UC1.K33 UC1.K35 UC1.K37 UC1.K38 UC1.K40 UC1.K42 UC1.K43
+VCC_CORE_L: PC642.2 PC645.1 PC646.2 PH605.2 PR640.2 PR644.2 PR656.2 PR673.2
+VCC_GT: CV297.2 CV298.2 CV301.2 CV302.2 PC1014.1 PC1015.1 PC1016.1 PC1017.1 PC1018.1 PC1019.1 PC1020.1 PC1021.1 PC1022.1 PC1023.1 PC1024.1 PC1025.1 PC1026.1 PC1027.1 PC1028.1 PC1029.1 PC1040.1 PC1041.1 PC1042.1 PC1043.1 PC1044.1 PC1045.1 PC1046.1 PC1047.1 PC1048.1 PC1049.1 PC1055.1 PC1056.1 PC1063.1 PC1129.1 PC1130.1 PC1131.1 PC1132.1 PC1133.1 PC1134.1 PC1135.1 PC1136.1 PC1137.1 PC1138.1 PC1154.1 PC1155.1 PC1156.1 PC1158.1 PC1159.1 PC1161.1 PC1162.1 PC1163.1 PC1175.1 PC1176.1 PC1177.1 PC1178.1 PC1179.1 PC1180.1 PC1181.1 PC1182.1 PC1183.1 PC1184.1 PC1221.1 PC1222.1 PC1223.1 PC1224.1 PL605.2 PR675.1 RC219.2 UC1.A48 UC1.A53 UC1.A58 UC1.A62 UC1.A66 UC1.AA63 UC1.AA64 UC1.AA66 UC1.AA67 UC1.AA69 UC1.AA70 UC1.AA71 UC1.AC64 UC1.AC65 UC1.AC66 UC1.AC67 UC1.AC68 UC1.AC69 UC1.AC70 UC1.AC71 UC1.J43 UC1.J45 UC1.J46 UC1.J48 UC1.J50 UC1.J52 UC1.J53 UC1.J55 UC1.J56 UC1.J58 UC1.J60 UC1.K48 UC1.K50 UC1.K52 UC1.K53 UC1.K55 UC1.K56 UC1.K58 UC1.K60 UC1.L62 UC1.L63 UC1.L64 UC1.L65 UC1.L66 UC1.L67 UC1.L68 UC1.L69 UC1.L70 UC1.L71 UC1.M62 UC1.N63 UC1.N64 UC1.N66 UC1.N67 UC1.N69 UC1.N70 UC1.N71 UC1.R63 UC1.R64 UC1.R65 UC1.R66 UC1.R67 UC1.R68 UC1.R69 UC1.R70 UC1.R71 UC1.T62 UC1.U65 UC1.U68 UC1.U71 UC1.W63 UC1.W64 UC1.W65 UC1.W66 UC1.W67 UC1.W68 UC1.W69 UC1.W70 UC1.W71 UC1.Y62
+VCC_GT_L: PC624.2 PC626.2 PC641.1 PH602.2 PR632.1 PR633.2 PR638.1 PR675.2
+VCC_SA: CV299.2 CV300.2 PC633.2 PC637.2 PC644.1 PC1057.1 PC1058.1 PC1059.1 PC1060.1 PC1139.1 PC1140.1 PC1141.1 PC1142.1 PC1143.1 PC1144.1 PC1145.1 PC1146.1 PC1147.1 PC1148.1 PC1149.1 PC1150.1 PC1151.1 PC1152.1 PC1153.1 PH604.2 PL601.2 PR636.2 PR641.2 PR643.1 RC227.2 UC1.AK23 UC1.AK25 UC1.G23 UC1.G25 UC1.G27 UC1.G28 UC1.J22 UC1.J23 UC1.J27 UC1.K23 UC1.K25 UC1.K27 UC1.K28 UC1.K30
+VDD_TOUCH: CX49.1 CX50.1 FX2.2 JEDP.11 JEDP.26 RX28.1 RX47.1
GND: C94.1 C2305.2 C2306.2 C2307.2 C2308.2 C2309.2 C2316.2 C2318.2 C2322.2 C2323.2 C2324.2 C2498.2 C5216.2 C5217.2 C5220.2 C5221.2 C5222.2 C5223.2 C5224.2 C5225.2 C5231.2 C5232.2 C5233.2 CA21.2 CA22.2 CA25.1 CA26.2 CA29.2 CA30.2 CA31.2 CA32.2 CA53.2 CA54.2 CA55.2 CA56.2 CA57.2 CA58.2 CA59.2 CA60.2 CA64.1 CA69.2 CC8.2 CC9.2 CC10.1 CC11.1 CC12.2 CC13.2 CC14.2 CC15.2 CC16.2 CC27.2 CC28.2 CC29.2 CC30.2 CC31.2 CC32.2 CC33.2 CC34.2 CC35.2 CC36.2 CC37.2 CC38.2 CC39.2 CC40.2 CC41.2 CC42.2 CC43.2 CC44.2 CC45.2 CC46.2 CC47.2 CC48.2 CC49.2 CC50.2 CC51.2 CC52.2 CC55.2 CC56.2 CC57.2 CC58.2 CC59.2 CC61.2 CC63.2 CC64.2 CC67.2 CC68.2 CC71.2 CC72.2 CC73.2 CC74.2 CC75.2 CC76.2 CC77.2 CC78.2 CC79.2 CC80.2 CC81.2 CC82.2 CC83.2 CC84.2 CC85.2 CC86.2 CC87.2 CC88.2 CC89.2 CC90.2 CC91.2 CC92.2 CC93.1 CC94.2 CC95.2 CC96.2 CC97.2 CC98.2 CC99.2 CC100.2 CC101.2 CC102.2 CC103.2 CC104.2 CC111.2 CC112.2 CC113.2 CC114.2 CC115.2 CC116.2 CC117.2 CC118.2 CC119.2 CC122.2 CC123.2 CC124.2 CC125.2 CC126.2 CC127.2 CC128.2 CC129.2 CC130.2 CC141.2 CC142.2 CD1.2 CD2.2 CD3.2 CD4.2 CD5.2 CD6.2 CD7.2 CD8.2 CD9.2 CD10.2 CD11.2 CD12.2 CD13.2 CD14.2 CD15.2 CD16.2 CD17.2 CD18.2 CD19.2 CD20.2 CD22.2 CD23.2 CD24.2 CD25.2 CD26.2 CD27.2 CD28.2 CD29.2 CD30.2 CD32.2 CD33.2 CD34.2 CD35.2 CD36.2 CD37.2 CD38.2 CD39.2 CD40.2 CD41.2 CD42.2 CD43.2 CD44.2 CD45.2 CD46.2 CD47.2 CD48.2 CD50.2 CD51.2 CD52.2 CD53.2 CD54.2 CD55.2 CE20.2 CE22.2 CE23.2 CE24.2 CE25.2 CE26.2 CE56.2 CE57.2 CE58.2 CE62.2 CE63.2 CE64.1 CE65.1 CE66.2 CE67.2 CE68.2 CE69.2 CE70.2 CE72.2 CE73.2 CE74.2 CE75.2 CE76.2 CE77.2 CE78.2 CE79.2 CE81.2 CE82.2 CE84.2 CE85.2 CE86.2 CE87.2 CE88.2 CE89.1 CE91.1 CE92.1 CI1.2 CI2.2 CI6.2 CI7.2 CI8.2 CI9.2 CI12.2 CI13.2 CI14.2 CI15.2 CI18.2 CI20.1 CI23.1 CI26.2 CI40.2 CI43.2 CI44.2 CI45.2 CI46.2 CI47.2 CL3.2 CL4.2 CL5.2 CL6.2 CL7.2 CL8.2 CL9.2 CL12.2 CL13.2 CL14.2 CL15.2 CL16.1 CL17.2 CL19.2 CL33.2 CL36.1 CL37.1 CL39.2 CL41.1 CLRP1.1 CLRP2.1 CLRP3.2 CM4.2 CM5.2 CM6.2 CM7.2 CM8.1 CM9.2 CM10.2 CS5.2 CS6.2 CS7.2 CS27.2 CS42.2 CV2.2 CV3.2 CV4.2 CV5.2 CV6.2 CV7.2 CV8.2 CV9.2 CV10.2 CV19.2 CV20.2 CV21.2 CV22.2 CV23.2 CV24.2 CV25.2 CV26.2 CV27.2 CV28.2 CV29.2 CV30.2 CV31.2 CV32.2 CV34.2 CV35.2 CV36.2 CV37.2 CV38.2 CV39.2 CV40.2 CV41.2 CV42.2 CV43.2 CV44.2 CV45.2 CV46.2 CV47.2 CV48.2 CV49.2 CV50.2 CV51.2 CV52.1 CV53.2 CV54.2 CV55.2 CV56.2 CV57.2 CV58.2 CV59.2 CV60.2 CV61.2 CV63.2 CV64.2 CV65.2 CV66.1 CV67.2 CV69.2 CV70.2 CV71.2 CV72.1 CV73.1 CV74.1 CV75.1 CV76.1 CV77.1 CV78.1 CV79.1 CV80.1 CV81.1 CV82.1 CV83.2 CV105.2 CV106.2 CV117.2 CV162.2 CV163.2 CV164.2 CV165.2 CV166.2 CV167.2 CV168.2 CV169.2 CV170.2 CV198.2 CV199.2 CV200.2 CV201.2 CV202.2 CV203.2 CV204.2 CV205.2 CV206.2 CV207.2 CV235.2 CV236.2 CV237.2 CV238.2 CV239.2 CV240.2 CV241.2 CV242.2 CV243.2 CV244.2 CV245.2 CV246.2 CV247.2 CV248.2 CV249.2 CV250.2 CV251.2 CV252.2 CV253.2 CV254.2 CV255.2 CV256.2 CV257.2 CV258.2 CV259.2 CV260.2 CV261.2 CV262.2 CV263.2 CV264.2 CV265.2 CV266.2 CV267.2 CV268.2 CV269.2 CV270.2 CV271.2 CV272.2 CV273.2 CV274.2 CV275.2 CV276.2 CV277.2 CV278.2 CV279.2 CV280.2 CV281.2 CV282.2 CV283.2 CV284.2 CV285.2 CV286.2 CV287.2 CV288.2 CV289.2 CV290.2 CV291.2 CV292.2 CV293.2 CV295.2 CV296.2 CV301.1 CV302.1 CX1.2 CX2.2 CX3.2 CX4.2 CX5.2 CX6.2 CX7.2 CX8.2 CX9.2 CX11.2 CX21.2 CX22.2 CX49.2 CX50.2 CX51.2 DA10.1 DA12.1 DA13.1 DA14.1 DB1.2 DB1.11 DB1.12 DE2.1 DE3.2 DI1.3 DI1.8 DI2.1 DI3.3 DI3.8 DI4.3 DI4.8 DI5.1 DX2.1 H2.1(TP-1) H3.1(TP-1) H4.1(TP-1) H5.1(TP-1) H6.1(TP-1) H7.1(TP-1) H8.1(TP-1) H9.1(TP-1) H11.1(TP-1) H12.1(TP-1) H13.1(TP-1) H14.1(TP-1) H15.1(TP-1) H16.1(TP-1) H17.1(TP-1) H18.1(TP-1) H19.1(TP-1) HE1.2 JC1.4 JCAM3D.7 JCAM3D.10 JCAM3D.11 JCAM3D.12 JDEG1.10 JDEG1.11 JDEG1.12 JDIMM1.2 JDIMM1.3 JDIMM1.8 JDIMM1.9 JDIMM1.11 JDIMM1.13 JDIMM1.14 JDIMM1.19 JDIMM1.20 JDIMM1.25 JDIMM1.26 JDIMM1.28 JDIMM1.31 JDIMM1.32 JDIMM1.37 JDIMM1.38 JDIMM1.43 JDIMM1.44 JDIMM1.46 JDIMM1.48 JDIMM1.49 JDIMM1.54 JDIMM1.55 JDIMM1.60 JDIMM1.61 JDIMM1.63 JDIMM1.65 JDIMM1.66 JDIMM1.71 JDIMM1.72 JDIMM1.127 JDIMM1.128 JDIMM1.133 JDIMM1.134 JDIMM1.136 JDIMM1.138 JDIMM1.139 JDIMM1.144 JDIMM1.145 JDIMM1.150 JDIMM1.151 JDIMM1.153 JDIMM1.155 JDIMM1.156 JDIMM1.161 JDIMM1.162 JDIMM1.167 JDIMM1.168 JDIMM1.170 JDIMM1.172 JDIMM1.173 JDIMM1.178 JDIMM1.179 JDIMM1.184 JDIMM1.185 JDIMM1.187 JDIMM1.189 JDIMM1.190 JDIMM1.195 JDIMM1.196 JDIMM1.197 JDIMM1.201 JDIMM1.205 JDIMM1.206 JDIMM2.2 JDIMM2.3 JDIMM2.8 JDIMM2.9 JDIMM2.11 JDIMM2.13 JDIMM2.14 JDIMM2.19 JDIMM2.20 JDIMM2.25 JDIMM2.26 JDIMM2.28 JDIMM2.31 JDIMM2.32 JDIMM2.37 JDIMM2.38 JDIMM2.43 JDIMM2.44 JDIMM2.46 JDIMM2.48 JDIMM2.49 JDIMM2.54 JDIMM2.55 JDIMM2.60 JDIMM2.61 JDIMM2.63 JDIMM2.65 JDIMM2.66 JDIMM2.71 JDIMM2.72 JDIMM2.127 JDIMM2.128 JDIMM2.133 JDIMM2.134 JDIMM2.136 JDIMM2.138 JDIMM2.139 JDIMM2.144 JDIMM2.145 JDIMM2.150 JDIMM2.151 JDIMM2.153 JDIMM2.155 JDIMM2.156 JDIMM2.161 JDIMM2.162 JDIMM2.167 JDIMM2.168 JDIMM2.170 JDIMM2.172 JDIMM2.173 JDIMM2.178 JDIMM2.179 JDIMM2.184 JDIMM2.185 JDIMM2.187 JDIMM2.189 JDIMM2.190 JDIMM2.195 JDIMM2.196 JDIMM2.197 JDIMM2.205 JDIMM2.206 JEDP.3 JEDP.6 JEDP.9 JEDP.12 JEDP.15 JEDP.18 JEDP.20 JEDP.31 JEDP.41 JEDP.42 JEDP.43 JEDP.44 JEDP.45 JEDP.46 JFAN.3 JFAN.4 JFAN.5 JHDD.3 JHDD.6 JHDD.11 JHDD.12 JHDMI.2 JHDMI.5 JHDMI.8 JHDMI.11 JHDMI.17 JHDMI.20 JHDMI.21 JHDMI.22 JHDMI.23 JIO.8 JIO.9 JIO.10 JIO.13 JIO.16 JIO.17 JIO.18 JKB.1 JKB.31 JKB.32 JKBBL.5 JKBBL.6 JLAN.9 JLAN.10 JLED.8 JLED.9 JLED.10 JNGFF.1 JNGFF.7 JNGFF.18 JNGFF.25 JNGFF.31 JNGFF.37 JNGFF.43 JNGFF.49 JNGFF.55 JNGFF.61 JNGFF.67 JNGFF.68 JNGFF.69 JRTC.2 JRTC.3 JRTC.4 JSPK.5 JSPK.6 JTP.5 JTP.9 JTP.10 JUSB1.4 JUSB1.7 JUSB1.10 JUSB1.11 JUSB1.12 JUSB1.13 JUSB2.4 JUSB2.7 JUSB2.10 JUSB2.11 JUSB2.12 JUSB2.13 JWDB1.1 JWDB1.5 JWDB1.6 PBATT.1 PBATT.2 PBATT.4 PBATT.10 PBATT.11 PC1.2 PC2.2 PC3.2 PC4.2 PC7.2 PC8.2 PC100.2 PC103.2 PC104.2 PC105.2 PC106.2 PC107.2 PC108.2 PC109.2 PC110.2 PC111.2 PC112.2 PC115.2 PC116.2 PC117.2 PC118.2 PC119.2 PC120.2 PC121.2 PC122.2 PC123.2 PC124.2 PC125.2 PC126.2 PC128.2 PC201.2 PC202.2 PC203.2 PC204.1 PC205.2 PC206.2 PC208.2 PC209.2 PC210.2 PC211.2 PC212.2 PC213.2 PC215.2 PC216.2 PC217.2 PC218.2 PC219.2 PC220.2 PC301.2 PC302.2 PC303.2 PC305.2 PC306.2 PC308.2 PC309.2 PC310.2 PC311.2 PC312.2 PC313.2 PC405.2 PC501.2 PC502.1 PC504.2 PC505.2 PC506.2 PC601.2 PC602.2 PC603.2 PC604.2 PC605.1 PC606.2 PC608.2 PC612.2 PC613.1 PC614.1 PC616.1 PC618.1 PC619.1 PC621.1 PC622.2 PC625.1 PC628.2 PC629.1 PC631.2 PC636.1 PC641.2 PC643.2 PC644.2 PC645.2 PC647.1 PC649.2 PC651.1 PC652.2 PC654.1 PC656.2 PC657.2 PC658.2 PC659.2 PC660.2 PC661.2 PC662.2 PC666.2 PC667.2 PC672.2 PC673.2 PC677.2 PC678.2 PC679.2 PC680.2 PC685.2 PC686.2 PC688.2 PC705.2 PC711.1 PC748.2 PC749.1 PC751.1 PC752.1 PC753.1 PC757.1 PC760.2 PC761.2 PC762.2 PC763.2 PC764.2 PC765.2 PC766.2 PC767.2 PC768.1 PC769.1 PC775.2 PC776.2 PC777.2 PC801.2 PC802.2 PC803.1 PC805.2 PC807.2 PC813.2 PC814.2 PC816.2 PC817.2 PC819.2 PC820.2 PC821.2 PC822.2 PC823.2 PC824.2 PC825.2 PC826.2 PC827.2 PC828.2 PC829.2 PC830.2 PC835.2 PC840.2 PC841.2 PC842.2 PC843.2 PC844.2 PC845.2 PC846.2 PC847.2 PC848.2 PC849.2 PC850.2 PC858.2 PC859.2 PC860.2 PC861.2 PC1001.2 PC1002.2 PC1003.2 PC1004.2 PC1005.2 PC1006.2 PC1007.2 PC1008.2 PC1009.2 PC1010.2 PC1011.2 PC1012.2 PC1013.2 PC1014.2 PC1015.2 PC1016.2 PC1017.2 PC1018.2 PC1019.2 PC1020.2 PC1021.2 PC1022.2 PC1023.2 PC1024.2 PC1025.2 PC1026.2 PC1027.2 PC1028.2 PC1029.2 PC1030.2 PC1033.2 PC1034.2 PC1036.2 PC1037.2 PC1038.2 PC1039.2 PC1040.2 PC1041.2 PC1042.2 PC1043.2 PC1044.2 PC1045.2 PC1046.2 PC1047.2 PC1048.2 PC1049.2 PC1050.2 PC1052.2 PC1053.2 PC1055.2 PC1056.2 PC1057.2 PC1058.2 PC1059.2 PC1060.2 PC1061.2 PC1062.2 PC1063.2 PC1064.2 PC1065.2 PC1066.2 PC1069.2 PC1070.2 PC1071.2 PC1072.2 PC1073.2 PC1074.2 PC1075.2 PC1076.2 PC1077.2 PC1078.2 PC1079.2 PC1080.2 PC1081.2 PC1082.2 PC1083.2 PC1084.2 PC1085.2 PC1086.2 PC1087.2 PC1088.2 PC1089.2 PC1090.2 PC1092.2 PC1093.2 PC1094.2 PC1095.2 PC1096.2 PC1097.2 PC1098.2 PC1099.2 PC1125.2 PC1126.2 PC1127.2 PC1129.2 PC1130.2 PC1131.2 PC1132.2 PC1133.2 PC1134.2 PC1135.2 PC1136.2 PC1137.2 PC1138.2 PC1139.2 PC1140.2 PC1141.2 PC1142.2 PC1143.2 PC1144.2 PC1145.2 PC1146.2 PC1147.2 PC1148.2 PC1149.2 PC1150.2 PC1151.2 PC1152.2 PC1153.2 PC1154.2 PC1155.2 PC1156.2 PC1158.2 PC1159.2 PC1161.2 PC1162.2 PC1163.2 PC1164.2 PC1173.2 PC1174.2 PC1175.2 PC1176.2 PC1177.2 PC1178.2 PC1179.2 PC1180.2 PC1181.2 PC1182.2 PC1183.2 PC1184.2 PC1221.2 PC1222.2 PC1223.2 PC1224.2 PC2118.2 PC2119.2 PC2120.2 PC2121.2 PD2.1 PD3.1 PD101.1 PH601.1 PH603.1 PJP2.1 PL4.2 PQ1.1 PQ1.4 PQ2.1 PQ2.4 PQ3.4 PQ5.3 PQ201.5 PQ201.6 PQ201.7 PQ501.5 PQ501.6 PQ501.7 PQ707.1 PQ707.4 PQ708.1 PQ708.2 PQ708.3 PQ711.3 PQ800.3 PQ800.4 PQ800.5 PQ801.3 PQ801.4 PQ801.5 PR2.2 PR9.1 PR10.1 PR29.2 PR32.2 PR33.1 PR103.2 PR110.2 PR118.2 PR203.2 PR204.2 PR302.2 PR310.2 PR311.2 PR505.2 PR506.2 PR608.2 PR611.2 PR613.1 PR629.1 PR631.1 PR637.2 PR647.1 PR651.2 PR654.2 PR655.2 PR727.2 PR731.2 PR732.2 PR738.2 PR746.1 PR751.1 PR752.1 PR753.1 PR755.1 PR779.1 PR802.2 PR810.1 PR818.2 PR824.2 PR825.2 PU100.7 PU100.8 PU100.18 PU100.21 PU102.7 PU102.8 PU102.18 PU102.21 PU200.1 PU200.3 PU200.14 PU200.21 PU301.9 PU501.2 PU602.41 PU603.7 PU603.10 PU605.7 PU605.10 PU606.4 PU606.9 PU703.33 PU801.21 QC1.3 QC4.3 QE5.4 QE8.3 QI1.1 QI1.4 QI2.1 QI2.4 QV5.1 QV5.4 QV8.1 QV8.4 QV74.3 QX3.3 RA19.2 RA29.2 RA30.2 RA31.2 RA32.2 RA81.1 RA1113.1 RC5.2 RC6.2 RC7.2 RC8.2 RC10.2 RC16.2 RC35.2 RC37.2 RC38.2 RC39.2 RC40.2 RC43.2 RC46.2 RC51.2 RC76.1 RC80.1 RC89.1 RC95.1 RC99.1 RC101.2 RC102.1 RC105.2 RC119.2 RC121.2 RC124.2 RC182.2 RC183.2 RC185.2 RC193.2 RC205.2 RC211.2 RC214.2 RC220.1 RC223.1 RC226.2 RC228.2 RC232.2 RC312.1 RC315.2 RC316.2 RC317.2 RC319.2 RC324.2 RC326.2 RC400.2 RD11.2 RD12.2 RD15.2 RD16.2 RD20.2 RD21.2 RE58.2 RE355.2 RE357.2 RE359.2 RE371.2 RE383.2 RE385.2 RE388.1 RI1.1 RI1.4 RI31.1 RI32.1 RI35.1 RI36.1 RI40.1 RI46.1 RI48.1 RI49.1 RI50.1 RI56.2 RI57.2 RI87.1 RI90.2 RL27.1 RL31.1 RL35.1 RM9.2 RPC11.6 RPC11.8 RPV3.5 RPV3.6 RPV3.7 RPV3.8 RPV6.6 RPV6.7 RPV7.5 RPV7.8 RPV8.5 RPV8.8 RPV9.5 RPV9.8 RPV10.5 RPV10.8 RPV11.5 RPV11.8 RPV12.5 RPV12.8 RPV13.5 RPV13.8 RPV14.5 RPV14.8 RPV15.5 RPV15.8 RPV16.5 RPV16.8 RPV17.5 RPV17.8 RPV18.5 RPV18.8 RS18.2 RS21.2 RS22.1 RS23.2 RS24.2 RS31.2 RS35.2 RS36.2 RS37.2 RV6.2 RV20.2 RV21.2 RV42.1 RV43.1 RV44.2 RV48.2 RV49.2 RV50.2 RV52.2 RV62.2 RV63.2 RV64.2 RV65.2 RV66.2 RV67.2 RV88.1 RV94.2 RV96.2 RV97.1 RV98.1 RV99.1 RV101.1 RV107.2 RV111.1 RV112.1 RV113.2 RV114.1 RV116.1 RV205.2 RV206.2 RV2437.1 RV2438.1 RV2439.1 RV2440.1 RV2447.1 RX9.2 RX13.2 RX14.2 RX26.2 RX34.2 RX48.2 RX49.2 SW1.1 SW1.2 SW1.5 SW1.6 U2301.11 U2301.15 U2407.6 U2409.5 U2409.9 UA1.49 UC1.A5 UC1.A67 UC1.A70 UC1.AA2 UC1.AA4 UC1.AA65 UC1.AA68 UC1.AB8 UC1.AB15 UC1.AB16 UC1.AB18 UC1.AB21 UC1.AD8 UC1.AD13 UC1.AD16 UC1.AD19 UC1.AD20 UC1.AD21 UC1.AD62 UC1.AE64 UC1.AE65 UC1.AE66 UC1.AE67 UC1.AE68 UC1.AE69 UC1.AF1 UC1.AF2 UC1.AF4 UC1.AF10 UC1.AF15 UC1.AF17 UC1.AF63 UC1.AG16 UC1.AG17 UC1.AG18 UC1.AG19 UC1.AG20 UC1.AG21 UC1.AG71 UC1.AH6 UC1.AH13 UC1.AH63 UC1.AH64 UC1.AH67 UC1.AJ4 UC1.AJ15 UC1.AJ18 UC1.AJ20 UC1.AK8 UC1.AK11 UC1.AK16 UC1.AK18 UC1.AK21 UC1.AK22 UC1.AK27 UC1.AK63 UC1.AK68 UC1.AK69 UC1.AL2 UC1.AL4 UC1.AL28 UC1.AL32 UC1.AL35 UC1.AL38 UC1.AL45 UC1.AL48 UC1.AL52 UC1.AL55 UC1.AL58 UC1.AL64 UC1.AL65 UC1.AL66 UC1.AM8 UC1.AM13 UC1.AM21 UC1.AM25 UC1.AM27 UC1.AM43 UC1.AM45 UC1.AM46 UC1.AM55 UC1.AM60 UC1.AM61 UC1.AM68 UC1.AM71 UC1.AN20 UC1.AN23 UC1.AN28 UC1.AN30 UC1.AN32 UC1.AN33 UC1.AN35 UC1.AN37 UC1.AN38 UC1.AN40 UC1.AN42 UC1.AN43 UC1.AN58 UC1.AN63 UC1.AP10 UC1.AP18 UC1.AP20 UC1.AP23 UC1.AP28 UC1.AP32 UC1.AP35 UC1.AP38 UC1.AP42 UC1.AP58 UC1.AP63 UC1.AP68 UC1.AP70 UC1.AR5 UC1.AR8 UC1.AR11 UC1.AR15 UC1.AR16 UC1.AR20 UC1.AR23 UC1.AR28 UC1.AR35 UC1.AR42 UC1.AR43 UC1.AR45 UC1.AR46 UC1.AR48 UC1.AR50 UC1.AR52 UC1.AR53 UC1.AR55 UC1.AR58 UC1.AR63 UC1.AT2 UC1.AT4 UC1.AT20 UC1.AT23 UC1.AT28 UC1.AT35 UC1.AT42 UC1.AT56 UC1.AT58 UC1.AT63 UC1.AT68 UC1.AT71 UC1.AU10 UC1.AU15 UC1.AU20 UC1.AU32 UC1.AU38 UC1.AV1 UC1.AV68 UC1.AV69 UC1.AV70 UC1.AV71 UC1.AW6 UC1.AW8 UC1.AW10 UC1.AW12 UC1.AW14 UC1.AW16 UC1.AW18 UC1.AW21 UC1.AW23 UC1.AW26 UC1.AW28 UC1.AW30 UC1.AW32 UC1.AW34 UC1.AW36 UC1.AW38 UC1.AW41 UC1.AW43 UC1.AW45 UC1.AW47 UC1.AW49 UC1.AW50 UC1.AW51 UC1.AW53 UC1.AW55 UC1.AW57 UC1.AW60 UC1.AW62 UC1.AW64 UC1.AW66 UC1.AY66 UC1.B10 UC1.B14 UC1.B18 UC1.B22 UC1.B30 UC1.B34 UC1.B39 UC1.B44 UC1.B48 UC1.B53 UC1.B58 UC1.B62 UC1.B66 UC1.B71 UC1.BA1 UC1.BA2 UC1.BA6 UC1.BA10 UC1.BA14 UC1.BA18 UC1.BA23 UC1.BA28 UC1.BA32 UC1.BA36 UC1.BA41 UC1.BA45 UC1.BA49 UC1.BA53 UC1.BA57 UC1.BA62 UC1.BA66 UC1.BA71 UC1.BB6 UC1.BB18 UC1.BB26 UC1.BB30 UC1.BB34 UC1.BB38 UC1.BB43 UC1.BB55 UC1.BB60 UC1.BB64 UC1.BB67 UC1.BB70 UC1.C1 UC1.C5 UC1.C25 UC1.D6 UC1.D10 UC1.D11 UC1.D14 UC1.D18 UC1.D22 UC1.D25 UC1.D26 UC1.D30 UC1.D34 UC1.D39 UC1.D44 UC1.D45 UC1.D47 UC1.D48 UC1.D53 UC1.D58 UC1.D62 UC1.D66 UC1.D69 UC1.E6 UC1.E11 UC1.E15 UC1.E18 UC1.E21 UC1.E46 UC1.E50 UC1.E53 UC1.E56 UC1.E65 UC1.E71 UC1.F1 UC1.F2 UC1.F4 UC1.F8 UC1.F13 UC1.F22 UC1.F23 UC1.F27 UC1.F28 UC1.F32 UC1.F33 UC1.F35 UC1.F37 UC1.F38 UC1.F40 UC1.F42 UC1.F68 UC1.G5 UC1.G6 UC1.G10 UC1.G22 UC1.G43 UC1.G45 UC1.G48 UC1.G52 UC1.G55 UC1.G58 UC1.G60 UC1.G63 UC1.G66 UC1.H15 UC1.H18 UC1.H71 UC1.J8 UC1.J11 UC1.J13 UC1.J25 UC1.J28 UC1.J32 UC1.J35 UC1.J38 UC1.J42 UC1.K16 UC1.K18 UC1.K22 UC1.K61 UC1.K63 UC1.K64 UC1.K65 UC1.K66 UC1.K67 UC1.K68 UC1.K70 UC1.K71 UC1.L2 UC1.L4 UC1.L8 UC1.L11 UC1.L16 UC1.L17 UC1.L18 UC1.L20 UC1.N6 UC1.N10 UC1.N13 UC1.N19 UC1.N21 UC1.N65 UC1.N68 UC1.P17 UC1.P19 UC1.P20 UC1.P21 UC1.R6 UC1.R13 UC1.T2 UC1.T4 UC1.T15 UC1.T17 UC1.T18 UC1.T21 UC1.U10 UC1.U63 UC1.U64 UC1.U66 UC1.U67 UC1.U69 UC1.U70 UC1.V16 UC1.V17 UC1.V18 UC1.W6 UC1.W9 UC1.W13 UC1.Y17 UC1.Y19 UC1.Y20 UC1.Y21 UC2.4 UC3.3 UC4.5 UC5.11 UC5.15 UC6.5 UC7.3 UC8.2 UC11.3 UC12.3 UC13.3 UC15.3 UE3.5 UE3.6 UE3.7 UE3.8 UE5.17 UE5.51 UE5.64 UE5.84 UE5.100 UE5.124 UE6.3 UI5.2 UI6.2 UI7.2 UI8.10 UI8.21 UI8.25 UL1.33 UL3.2 US2.3 US2.21 UV1.A2 UV1.A26 UV1.AA7 UV1.AB7 UV1.AB11 UV1.AB14 UV1.AB17 UV1.AB20 UV1.AB24 UV1.AC2 UV1.AC5 UV1.AC8 UV1.AC22 UV1.AC26 UV1.AD12 UV1.AD13 UV1.AD15 UV1.AD16 UV1.AD18 UV1.AD19 UV1.AD21 UV1.AD22 UV1.AE11 UV1.AE14 UV1.AE17 UV1.AE20 UV1.AF1 UV1.AF5 UV1.AF8 UV1.AF11 UV1.AF14 UV1.AF17 UV1.AF20 UV1.AF23 UV1.AG2 UV1.AG26 UV1.B1 UV1.B5 UV1.B8 UV1.B11 UV1.B14 UV1.B17 UV1.B20 UV1.B23 UV1.B27 UV1.E2 UV1.E5 UV1.E8 UV1.E11 UV1.E14 UV1.E17 UV1.E20 UV1.E22 UV1.E25 UV1.H2 UV1.H5 UV1.H23 UV1.H25 UV1.K11 UV1.K13 UV1.K15 UV1.K17 UV1.L2 UV1.L5 UV1.L10 UV1.L12 UV1.L14 UV1.L16 UV1.L18 UV1.L23 UV1.L25 UV1.M11 UV1.M13 UV1.M15 UV1.M17 UV1.N10 UV1.N12 UV1.N14 UV1.N16 UV1.N18 UV1.P2 UV1.P5 UV1.P11 UV1.P13 UV1.P15 UV1.P17 UV1.P23 UV1.P26 UV1.R10 UV1.R12 UV1.R14 UV1.R16 UV1.R18 UV1.T11 UV1.T13 UV1.T15 UV1.T17 UV1.U2 UV1.U5 UV1.U10 UV1.U12 UV1.U14 UV1.U16 UV1.U18 UV1.U23 UV1.U26 UV1.V11 UV1.V13 UV1.V15 UV1.V17 UV1.Y2 UV1.Y5 UV1.Y23 UV1.Y26 UV4.A9 UV4.B1 UV4.B3 UV4.B9 UV4.D1 UV4.D8 UV4.E1 UV4.E2 UV4.E8 UV4.F9 UV4.G1 UV4.G8 UV4.G9 UV4.J2 UV4.J8 UV4.M1 UV4.M9 UV4.P1 UV4.P9 UV4.T1 UV4.T9 UV5.A9 UV5.B1 UV5.B3 UV5.B9 UV5.D1 UV5.D8 UV5.E1 UV5.E2 UV5.E8 UV5.F9 UV5.G1 UV5.G8 UV5.G9 UV5.J2 UV5.J8 UV5.M1 UV5.M9 UV5.P1 UV5.P9 UV5.T1 UV5.T9 UV6.A9 UV6.B1 UV6.B3 UV6.B9 UV6.D1 UV6.D8 UV6.E1 UV6.E2 UV6.E8 UV6.F9 UV6.G1 UV6.G8 UV6.G9 UV6.J2 UV6.J8 UV6.M1 UV6.M9 UV6.P1 UV6.P9 UV6.T1 UV6.T9 UV7.A9 UV7.B1 UV7.B3 UV7.B9 UV7.D1 UV7.D8 UV7.E1 UV7.E2 UV7.E8 UV7.F9 UV7.G1 UV7.G8 UV7.G9 UV7.J2 UV7.J8 UV7.M1 UV7.M9 UV7.P1 UV7.P9 UV7.T1 UV7.T9 UV8.A9 UV8.B1 UV8.B3 UV8.B9 UV8.D1 UV8.D8 UV8.E1 UV8.E2 UV8.E8 UV8.F9 UV8.G1 UV8.G8 UV8.G9 UV8.J2 UV8.J8 UV8.M1 UV8.M9 UV8.P1 UV8.P9 UV8.T1 UV8.T9 UV9.A9 UV9.B1 UV9.B3 UV9.B9 UV9.D1 UV9.D8 UV9.E1 UV9.E2 UV9.E8 UV9.F9 UV9.G1 UV9.G8 UV9.G9 UV9.J2 UV9.J8 UV9.M1 UV9.M9 UV9.P1 UV9.P9 UV9.T1 UV9.T9 UV10.11 UV10.15 UV12.3 UV13.3 UV14.A9 UV14.B1 UV14.B3 UV14.B9 UV14.D1 UV14.D8 UV14.E1 UV14.E2 UV14.E8 UV14.F9 UV14.G1 UV14.G8 UV14.G9 UV14.J2 UV14.J8 UV14.M1 UV14.M9 UV14.P1 UV14.P9 UV14.T1 UV14.T9 UV15.A9 UV15.B1 UV15.B3 UV15.B9 UV15.D1 UV15.D8 UV15.E1 UV15.E2 UV15.E8 UV15.F9 UV15.G1 UV15.G8 UV15.G9 UV15.J2 UV15.J8 UV15.M1 UV15.M9 UV15.P1 UV15.P9 UV15.T1 UV15.T9 UV23.3 UX4.2 YC1.2 YC1.4 YL2.2 YL2.4 YV1.2 YV1.4
GNDA: CA23.1 CA33.2 CA38.2 CA39.2 CA40.2 CA51.2 CA61.2 CA62.1 CA63.1 CA71.2 CA74.2 JHP.6 JHP.7 RA12.1 RA29.1 RA30.1 RA31.1 RA32.1 RA83.2 RA84.2 UA1.25 UA1.38
PVCC_VGA: PC807.1 PR817.1 PU801.18
VCC_GT_SENSE: PC617.1 PC618.2 PC620.1 PR622.1 RC219.1 UC1.J70
VCCEOPIO_SENSE: T137.1(TP-1) UC1.AL63
VCCGTX_SENSE: T155.1(TP-1) UC1.AK62
VCCIO_SENSE: T124.1(TP-1) UC1.AM23
VCCOPC_SENSE: T132.1(TP-1) UC1.AC63
VCCSA_B+: PC608.1 PC612.1 PJP603.1 PQ501.2 PQ501.3 PQ501.4 PQ501.10
VCCSENSE: PC639.1 PC651.2 PC653.1 PR648.1 RC203.1 UC1.E32
VCCST_PWRGD: RC116.2 UC1.B65
VCCSTG_EN: DC7.1 RC67.2 RZ75.2 UC15.4
VCCSTG_EN_R: CC101.1 DC7.2 RC67.1 UC6.4
VDD_1.35V: PC209.1 PR205.1 PR206.2 PU200.11
VDD_CHG: PC768.2 PR741.1 PR749.2 PR750.2 PR760.1 PU703.19
VDDP_CHG: PC769.2 PR760.2 PU703.20
VIN_1.8VALW: PC502.2 PJP501.2 PU501.4
VSS_GT_SENSE: PC619.2 PC620.2 PU602.6 RC226.1 UC1.J69
VSSEOPIO_SENSE: T139.1(TP-1) UC1.AJ62
VSSGTX_SENSE: T219.1(TP-1) UC1.AL61
VSSIO_SENSE: T125.1(TP-1) UC1.AM22
VSSOPC_SENSE: T133.1(TP-1) UC1.AE63
VSSSENSE: PC653.2 PC654.2 PU602.18 RC205.1 UC1.E33
3D_CAM_EN: DC4.2 DX7.2 RI54.2 RI88.2 RI90.1 U2409.3
3D_CAM_EN_EC: DX7.1 UE5.23
3D_CAM_EN_R: DC4.1 UC1.AN7
+A_VCC: RA10.2 RA11.2 UA1.20
+CODEC_AVDD2: CA61.1 RA8.2 UA1.40
+FAN_POWER: CE22.1 CE23.1 JFAN.1 UE3.3
+GPU_CORE: PC816.1 PC817.1 PC821.1 PC822.1 PC823.1 PC824.1 PC825.1 PC826.1 PC827.1 PC828.1 PC829.1 PC830.1 PC835.1 PC840.1 PC841.1 PC842.1 PC843.1 PC844.1 PC845.1 PC846.1 PC847.1 PC848.1 PC849.1 PC850.1 PC858.1 PC859.1 PC860.1 PC861.1 PL802.2 PL803.2 PR813.1 UV1.K10 UV1.K12 UV1.K14 UV1.K16 UV1.K18 UV1.L11 UV1.L13 UV1.L15 UV1.L17 UV1.M10 UV1.M12 UV1.M14 UV1.M16 UV1.M18 UV1.N11 UV1.N13 UV1.N15 UV1.N17 UV1.P10 UV1.P12 UV1.P14 UV1.P16 UV1.P18 UV1.R11 UV1.R13 UV1.R15 UV1.R17 UV1.T10 UV1.T12 UV1.T14 UV1.T16 UV1.T18 UV1.U11 UV1.U13 UV1.U15 UV1.U17 UV1.V10 UV1.V12 UV1.V14 UV1.V16 UV1.V18
+INV_PWR_SRC: CX5.1 CX6.1 FX3.2 JEDP.39 JEDP.40 RX4.2
+LAN_REGOUT: CL3.1 LL1.1 RL1.2 UL1.24
+LAN_VDD10: CL4.1 CL5.1 CL6.1 CL7.1 CL8.1 CL9.1 LL1.2 RL1.1 UL1.3 UL1.8 UL1.22 UL1.30
+LAN_VDD33: CL12.1 CL13.1 CL14.1 CL15.1 CL19.1 JP3.1 RL6.1 RL39.1 UL1.11 UL1.32 UL3.1
+LAN_VDDREG: CL16.2 CL17.1 RL6.2 UL1.23
+LCDVDD: LX1.1 UX4.1
+LCDVDD_CONN: CX2.1 CX3.1 CX8.1 CX11.1 JEDP.24 JEDP.25 LX1.2
+MIC2-VREFO: RA53.2 RA1109.2 UA1.29
+RTCBATT: JRTC.1 RC192.1
+V_TS: CX51.1 FX2.1 RX28.2 RX29.2 RX30.2
+VDISPLAY_VCC: CX21.1 CX22.1 FX1.1 JHDMI.18
A_MIC_CLK: CA22.1 JEDP.30 LA1.2
A_MIC_DATA: JEDP.32 UA1.2
AC_DIS: PQ707.2 PQ707.5 UE5.69
AC_PRESENT: DC2.2 RC106.2 UC1.AY15
ACAV_IN: CE89.2 DC2.1 PR731.1 PR741.2 PU703.2 UE5.128
ACIN_CHG: PC711.2 PD706.2 PQ707.3 PR729.2 PR732.1 PU703.1
ACLIM: PR749.1 PR751.2 PU703.16
ALL_SYS_PWRGD: DC6.2 RC345.1 RC388.1 RC389.2 RC392.2 RE381.2 UC12.2 UC13.4
ALWON: PR114.1 UE5.121
ASGATE: PR762.2 PU703.30
AUD_HP_OUT_L_CN: CA39.1 DA10.3 JHP.1 LA8.1
AUD_HP_OUT_R_CN: CA33.1 DA10.2 JHP.2 LA9.1
AUD_PC_BEEP: CA65.1 RA1114.1 RA1115.2
AUD_PC_BEEP_R: RA1115.1 UA1.12
BA: PD705.2 PQ710.1 PR780.1
BAT1_LED#: QI1.5 RE358.1 UE5.1
BAT2_LED#: RE360.1 RI1.2 UE5.106
BEEP: DA8.2 UE5.45
BLON_OUT_C: JEDP.37 RX9.1 RX31.2
BLUETOOTH_EN: JNGFF.46 RC322.1 UC1.AB2
BOARD_ID: CE71.1 RE343.2 RE344.2 UE5.111
BOARD_ID2: RC324.1 RC325.2 UC1.AB3
BOARD_ID3: RC323.2 RC326.1 UC1.BA7
BS_+1VALWP: PR304.1 PU301.6
BST1_VGA: PR819.1 PU801.1
BST1_VGA_R: PC808.1 PR819.2
BST2_VGA: PR816.1 PU801.15
BST2_VGA_R: PC806.2 PR816.2
BST_1.35V: PR200.2 PU200.18
BST_1.35V_R: PC200.1 PR200.1
BST_3V: PR100.1 PU100.1
BST_5V: PR111.1 PU102.1
CAM_DETECT: JCAM3D.4 RC330.1 UC1.P2
CAP_LED: JKB.4 RE401.2
CAP_LED#: QE11.3 RE330.2 UE5.93
CAP_LED_Q: QE10.1 RE401.1
CAP_LED_R#: QE10.2 QE11.1
CCLIM: PR750.1 PR752.2 PU703.11
CFG0: T4932.1(TP-1) UC1.E68
CFG1: T4933.1(TP-1) UC1.B67
CFG2: T4935.1(TP-1) UC1.D65
CFG3: RC43.1 T4934.1(TP-1) UC1.D67
CFG4: RC193.1 T4943.1(TP-1) UC1.E70
CFG5: T4944.1(TP-1) UC1.C68
CFG6: T4945.1(TP-1) UC1.D68
CFG7: T4946.1(TP-1) UC1.C67
CFG8: T4938.1(TP-1) UC1.F71
CFG9: T4939.1(TP-1) UC1.G69
CFG10: T4940.1(TP-1) UC1.F70
CFG11: T4941.1(TP-1) UC1.G68
CFG12: T4947.1(TP-1) UC1.H70
CFG13: T4948.1(TP-1) UC1.G71
CFG14: T4949.1(TP-1) UC1.H69
CFG15: T4942.1(TP-1) UC1.G70
CFG16: T4937.1(TP-1) UC1.E63
CFG17: T4936.1(TP-1) UC1.F63
CFG18: T4951.1(TP-1) UC1.E66
CFG19: T4950.1(TP-1) UC1.F66
CFG_RCOMP: RC185.1 UC1.E60
CLK_CPU_ITP: T90.1(TP-1) UC1.E43
CLK_CPU_ITP#: T89.1(TP-1) UC1.F43
CLK_PCI_LPC_MEC: R2454.2 RC45.2 UE5.57
CLK_PCI_LPDEBUG: DB1.1 RC54.2
CLK_PCIE_LAN_N2: UC1.D41 UL1.16
CLK_PCIE_LAN_P2: UC1.C41 UL1.15
CLK_PCIE_LAN_REQ#: RPC10.2 UC1.AT8 UL1.12
CLK_PCIE_WLAN_N1: JNGFF.41 UC1.B42
CLK_PCIE_WLAN_P1: JNGFF.39 UC1.A42
CLK_PCIE_WLAN_REQ#: JNGFF.45 RPC10.1 UC1.AT7
CLK_PEG_VGA: UC1.C42 UV1.AE8
CLK_PEG_VGA#: UC1.D42 UV1.AD8
CLK_SMB: PBATT.7 PR18.1
CLK_TP_SIO: CE92.2 JTP.1 RE338.2 UE5.78
CLKREQ_PCIE#0_R: QV3.3 RV5.1 RV68.2 UV1.AC6
CLKRUN#: RC107.1 UC1.AW11 UE5.63
CMP_STRAP0: RE379.1 UE5.118
CMP_VIN0: RE375.1 RE387.1 UE5.20
CMP_VOUT0: PR116.1 QV4.1 RE384.2 RE387.2 UE5.85
CMSRC: PR763.2 PU703.29
COMP: PC751.2 PR754.2 PU703.10
COMP_IA: PC636.2 PR639.2 PU602.16
COMP_VSA: PC628.1 PR630.1 PU602.24
CORE_SNUB: PC662.1 PR663.2
CORE_SW: PL603.1 PR661.1 PR663.1 PU603.8
CPU_B+: PC606.1 PC656.1 PC657.1 PC658.1 PC659.1 PC660.1 PC680.1 PC686.1 PJP601.1 PJP602.2 PJP603.2 PL602.1 PR603.2 PU603.6 PU603.11
CPU_DPB_CTRLCLK_R: JHDMI.15 QX4.6 RX16.1
CPU_DPB_CTRLDAT_R: JHDMI.16 QX4.3 RX17.1
CPU_POPIRCOMP: RC5.1 UC1.AT16
CPU_XDP_TCK0: RC35.1 UC1.A59 UC1.B61
CS_1.35V: PR205.2 PU200.13
CSI2_COMP: RC80.2 UC1.E13
DAT_SMB: PBATT.6 PR20.1
DAT_TP_SIO: CE91.2 JTP.2 RE339.2 UE5.79
DBC_EN: RC329.1 RX23.1 UC1.AM5
DBC_EN_R: JEDP.23 RX23.2 RX49.1
DDR_A_BS0: JDIMM1.109 UC1.AU52
DDR_A_BS1: JDIMM1.108 UC1.AT48
DDR_A_BS2: JDIMM1.79 UC1.AY55
DDR_A_CAS#: JDIMM1.115 UC1.AU48
DDR_A_CKE0: JDIMM1.73 UC1.BA56
DDR_A_CKE1: JDIMM1.74 UC1.BB56
DDR_A_CLK0: JDIMM1.101 UC1.AT53
DDR_A_CLK1: JDIMM1.102 UC1.AT55
DDR_A_CLK#0: JDIMM1.103 UC1.AU53
DDR_A_CLK#1: JDIMM1.104 UC1.AU55
DDR_A_CS#0: JDIMM1.114 UC1.AU45
DDR_A_CS#1: JDIMM1.121 UC1.AU43
DDR_A_D0: JDIMM1.5 UC1.AL71
DDR_A_D1: JDIMM1.7 UC1.AL68
DDR_A_D2: JDIMM1.17 UC1.AN68
DDR_A_D3: JDIMM1.16 UC1.AN69
DDR_A_D4: JDIMM1.6 UC1.AL70
DDR_A_D5: JDIMM1.4 UC1.AL69
DDR_A_D6: JDIMM1.15 UC1.AN70
DDR_A_D7: JDIMM1.18 UC1.AN71
DDR_A_D8: JDIMM1.24 UC1.AR70
DDR_A_D9: JDIMM1.22 UC1.AR68
DDR_A_D10: JDIMM1.34 UC1.AU71
DDR_A_D11: JDIMM1.23 UC1.AU68
DDR_A_D12: JDIMM1.21 UC1.AR71
DDR_A_D13: JDIMM1.36 UC1.AR69
DDR_A_D14: JDIMM1.33 UC1.AU70
DDR_A_D15: JDIMM1.35 UC1.AU69
DDR_A_D16: JDIMM1.40 UC1.BB65
DDR_A_D17: JDIMM1.41 UC1.AW65
DDR_A_D18: JDIMM1.51 UC1.AW63
DDR_A_D19: JDIMM1.50 UC1.AY63
DDR_A_D20: JDIMM1.39 UC1.BA65
DDR_A_D21: JDIMM1.42 UC1.AY65
DDR_A_D22: JDIMM1.53 UC1.BA63
DDR_A_D23: JDIMM1.52 UC1.BB63
DDR_A_D24: JDIMM1.57 UC1.BA61
DDR_A_D25: JDIMM1.56 UC1.AW61
DDR_A_D26: JDIMM1.70 UC1.BB59
DDR_A_D27: JDIMM1.68 UC1.AW59
DDR_A_D28: JDIMM1.59 UC1.BB61
DDR_A_D29: JDIMM1.58 UC1.AY61
DDR_A_D30: JDIMM1.67 UC1.BA59
DDR_A_D31: JDIMM1.69 UC1.AY59
DDR_A_D32: JDIMM1.131 UC1.AY39
DDR_A_D33: JDIMM1.130 UC1.AW39
DDR_A_D34: JDIMM1.142 UC1.AY37
DDR_A_D35: JDIMM1.140 UC1.AW37
DDR_A_D36: JDIMM1.132 UC1.BB39
DDR_A_D37: JDIMM1.129 UC1.BA39
DDR_A_D38: JDIMM1.141 UC1.BA37
DDR_A_D39: JDIMM1.143 UC1.BB37
DDR_A_D40: JDIMM1.148 UC1.AY35
DDR_A_D41: JDIMM1.146 UC1.AW35
DDR_A_D42: JDIMM1.158 UC1.AY33
DDR_A_D43: JDIMM1.160 UC1.AW33
DDR_A_D44: JDIMM1.149 UC1.BB35
DDR_A_D45: JDIMM1.147 UC1.BA35
DDR_A_D46: JDIMM1.157 UC1.BA33
DDR_A_D47: JDIMM1.159 UC1.BB33
DDR_A_D48: JDIMM1.163 UC1.AY31
DDR_A_D49: JDIMM1.166 UC1.AW31
DDR_A_D50: JDIMM1.176 UC1.AY29
DDR_A_D51: JDIMM1.175 UC1.AW29
DDR_A_D52: JDIMM1.164 UC1.BB31
DDR_A_D53: JDIMM1.165 UC1.BA31
DDR_A_D54: JDIMM1.174 UC1.BA29
DDR_A_D55: JDIMM1.177 UC1.BB29
DDR_A_D56: JDIMM1.183 UC1.AY27
DDR_A_D57: JDIMM1.182 UC1.AW27
DDR_A_D58: JDIMM1.181 UC1.AY25
DDR_A_D59: JDIMM1.180 UC1.AW25
DDR_A_D60: JDIMM1.191 UC1.BB27
DDR_A_D61: JDIMM1.193 UC1.BA27
DDR_A_D62: JDIMM1.192 UC1.BA25
DDR_A_D63: JDIMM1.194 UC1.BB25
DDR_A_DQS0: JDIMM1.12 UC1.AM69
DDR_A_DQS1: JDIMM1.29 UC1.AT70
DDR_A_DQS2: JDIMM1.47 UC1.AY64
DDR_A_DQS3: JDIMM1.64 UC1.BA60
DDR_A_DQS4: JDIMM1.137 UC1.AY38
DDR_A_DQS5: JDIMM1.154 UC1.BA34
DDR_A_DQS6: JDIMM1.171 UC1.AY30
DDR_A_DQS7: JDIMM1.188 UC1.BA26
DDR_A_DQS#0: JDIMM1.10 UC1.AM70
DDR_A_DQS#1: JDIMM1.27 UC1.AT69
DDR_A_DQS#2: JDIMM1.45 UC1.BA64
DDR_A_DQS#3: JDIMM1.62 UC1.AY60
DDR_A_DQS#4: JDIMM1.135 UC1.BA38
DDR_A_DQS#5: JDIMM1.152 UC1.AY34
DDR_A_DQS#6: JDIMM1.169 UC1.BA30
DDR_A_DQS#7: JDIMM1.186 UC1.AY26
DDR_A_MA0: JDIMM1.98 UC1.AY50
DDR_A_MA1: JDIMM1.97 UC1.BB50
DDR_A_MA2: JDIMM1.96 UC1.AY51
DDR_A_MA3: JDIMM1.95 UC1.BA50
DDR_A_MA4: JDIMM1.92 UC1.BB52
DDR_A_MA5: JDIMM1.91 UC1.BA51
DDR_A_MA6: JDIMM1.90 UC1.BA52
DDR_A_MA7: JDIMM1.86 UC1.AW52
DDR_A_MA8: JDIMM1.89 UC1.AY52
DDR_A_MA9: JDIMM1.85 UC1.BB54
DDR_A_MA10: JDIMM1.107 UC1.AT50
DDR_A_MA11: JDIMM1.84 UC1.BA54
DDR_A_MA12: JDIMM1.83 UC1.AW54
DDR_A_MA13: JDIMM1.119 UC1.AU46
DDR_A_MA14: JDIMM1.80 UC1.AY54
DDR_A_MA15: JDIMM1.78 UC1.BA55
DDR_A_ODT0: JDIMM1.116 UC1.AT45
DDR_A_ODT1: JDIMM1.120 UC1.AT43
DDR_A_RAS#: JDIMM1.110 UC1.AU50
DDR_A_WE#: JDIMM1.113 UC1.AT46
DDR_B_BS0: JDIMM2.109 UC1.BB44
DDR_B_BS1: JDIMM2.108 UC1.BA44
DDR_B_BS2: JDIMM2.79 UC1.AP52
DDR_B_CAS#: JDIMM2.115 UC1.AY43
DDR_B_CKE0: JDIMM2.73 UC1.AN56
DDR_B_CKE1: JDIMM2.74 UC1.AP55
DDR_B_CLK0: JDIMM2.101 UC1.AP45
DDR_B_CLK1: JDIMM2.102 UC1.AP46
DDR_B_CLK#0: JDIMM2.103 UC1.AN45
DDR_B_CLK#1: JDIMM2.104 UC1.AN46
DDR_B_CS#0: JDIMM2.114 UC1.BB42
DDR_B_CS#1: JDIMM2.121 UC1.AY42
DDR_B_D0: JDIMM2.24 UC1.AF65
DDR_B_D1: JDIMM2.23 UC1.AF64
DDR_B_D2: JDIMM2.34 UC1.AK65
DDR_B_D3: JDIMM2.33 UC1.AK64
DDR_B_D4: JDIMM2.22 UC1.AF66
DDR_B_D5: JDIMM2.21 UC1.AF67
DDR_B_D6: JDIMM2.35 UC1.AK67
DDR_B_D7: JDIMM2.36 UC1.AK66
DDR_B_D8: JDIMM2.16 UC1.AF70
DDR_B_D9: JDIMM2.6 UC1.AF68
DDR_B_D10: JDIMM2.4 UC1.AH71
DDR_B_D11: JDIMM2.17 UC1.AH68
DDR_B_D12: JDIMM2.18 UC1.AF71
DDR_B_D13: JDIMM2.15 UC1.AF69
DDR_B_D14: JDIMM2.5 UC1.AH70
DDR_B_D15: JDIMM2.7 UC1.AH69
DDR_B_D16: JDIMM2.41 UC1.AT66
DDR_B_D17: JDIMM2.39 UC1.AU66
DDR_B_D18: JDIMM2.51 UC1.AP65
DDR_B_D19: JDIMM2.50 UC1.AN65
DDR_B_D20: JDIMM2.42 UC1.AN66
DDR_B_D21: JDIMM2.40 UC1.AP66
DDR_B_D22: JDIMM2.53 UC1.AT65
DDR_B_D23: JDIMM2.52 UC1.AU65
DDR_B_D24: JDIMM2.57 UC1.AT61
DDR_B_D25: JDIMM2.56 UC1.AU61
DDR_B_D26: JDIMM2.69 UC1.AP60
DDR_B_D27: JDIMM2.67 UC1.AN60
DDR_B_D28: JDIMM2.58 UC1.AN61
DDR_B_D29: JDIMM2.59 UC1.AP61
DDR_B_D30: JDIMM2.68 UC1.AT60
DDR_B_D31: JDIMM2.70 UC1.AU60
DDR_B_D32: JDIMM2.132 UC1.AU40
DDR_B_D33: JDIMM2.131 UC1.AT40
DDR_B_D34: JDIMM2.143 UC1.AT37
DDR_B_D35: JDIMM2.140 UC1.AU37
DDR_B_D36: JDIMM2.129 UC1.AR40
DDR_B_D37: JDIMM2.130 UC1.AP40
DDR_B_D38: JDIMM2.142 UC1.AP37
DDR_B_D39: JDIMM2.141 UC1.AR37
DDR_B_D40: JDIMM2.148 UC1.AT33
DDR_B_D41: JDIMM2.147 UC1.AU33
DDR_B_D42: JDIMM2.159 UC1.AU30
DDR_B_D43: JDIMM2.157 UC1.AT30
DDR_B_D44: JDIMM2.149 UC1.AR33
DDR_B_D45: JDIMM2.146 UC1.AP33
DDR_B_D46: JDIMM2.160 UC1.AR30
DDR_B_D47: JDIMM2.158 UC1.AP30
DDR_B_D48: JDIMM2.165 UC1.AU27
DDR_B_D49: JDIMM2.163 UC1.AT27
DDR_B_D50: JDIMM2.177 UC1.AT25
DDR_B_D51: JDIMM2.176 UC1.AU25
DDR_B_D52: JDIMM2.164 UC1.AP27
DDR_B_D53: JDIMM2.166 UC1.AN27
DDR_B_D54: JDIMM2.174 UC1.AN25
DDR_B_D55: JDIMM2.175 UC1.AP25
DDR_B_D56: JDIMM2.181 UC1.AT22
DDR_B_D57: JDIMM2.183 UC1.AU22
DDR_B_D58: JDIMM2.193 UC1.AU21
DDR_B_D59: JDIMM2.191 UC1.AT21
DDR_B_D60: JDIMM2.182 UC1.AN22
DDR_B_D61: JDIMM2.180 UC1.AP22
DDR_B_D62: JDIMM2.194 UC1.AP21
DDR_B_D63: JDIMM2.192 UC1.AN21
DDR_B_DQS0: JDIMM2.29 UC1.AH65
DDR_B_DQS1: JDIMM2.12 UC1.AG70
DDR_B_DQS2: JDIMM2.47 UC1.AR65
DDR_B_DQS3: JDIMM2.64 UC1.AR60
DDR_B_DQS4: JDIMM2.137 UC1.AR38
DDR_B_DQS5: JDIMM2.154 UC1.AR32
DDR_B_DQS6: JDIMM2.171 UC1.AR27
DDR_B_DQS7: JDIMM2.188 UC1.AR21
DDR_B_DQS#0: JDIMM2.27 UC1.AH66
DDR_B_DQS#1: JDIMM2.10 UC1.AG69
DDR_B_DQS#2: JDIMM2.45 UC1.AR66
DDR_B_DQS#3: JDIMM2.62 UC1.AR61
DDR_B_DQS#4: JDIMM2.135 UC1.AT38
DDR_B_DQS#5: JDIMM2.152 UC1.AT32
DDR_B_DQS#6: JDIMM2.169 UC1.AR25
DDR_B_DQS#7: JDIMM2.186 UC1.AR22
DDR_B_MA0: JDIMM2.98 UC1.BA46
DDR_B_MA1: JDIMM2.97 UC1.AY46
DDR_B_MA2: JDIMM2.96 UC1.AY47
DDR_B_MA3: JDIMM2.95 UC1.BB46
DDR_B_MA4: JDIMM2.92 UC1.BA47
DDR_B_MA5: JDIMM2.91 UC1.AY48
DDR_B_MA6: JDIMM2.90 UC1.BA48
DDR_B_MA7: JDIMM2.86 UC1.AP48
DDR_B_MA8: JDIMM2.89 UC1.BB48
DDR_B_MA9: JDIMM2.85 UC1.AP50
DDR_B_MA10: JDIMM2.107 UC1.AW46
DDR_B_MA11: JDIMM2.84 UC1.AN48
DDR_B_MA12: JDIMM2.83 UC1.AN50
DDR_B_MA13: JDIMM2.119 UC1.BA43
DDR_B_MA14: JDIMM2.80 UC1.AN52
DDR_B_MA15: JDIMM2.78 UC1.AN53
DDR_B_ODT0: JDIMM2.116 UC1.BA42
DDR_B_ODT1: JDIMM2.120 UC1.AW42
DDR_B_PAR: T23.1(TP-1) UC1.AP43
DDR_B_RAS#: JDIMM2.110 UC1.AW44
DDR_B_WE#: JDIMM2.113 UC1.AY44
DDR_DRAMRST#: CD3.1 CD30.1 JDIMM1.30 JDIMM2.30 RD1.2 UC1.AT13
DDR_VTT_CNTL: UC1.AW67 UC7.2
DEVSLP0: RS8.1 UC1.J1
DEW1: RS34.1 RS36.1 US2.16
DEW2: RS33.1 RS35.1 US2.6
DGPU_HOLD_RST#: RC214.1 UC1.P3 UV12.2
DGPU_MAIN_EN: PR823.2 RPV5.1 UV1.A3 UV10.3
DGPU_PSI: PR803.2 RPV5.2 UV1.B4
DGPU_PWR_EN: QV8.2 RC211.1 RC230.1 UC1.U1
DGPU_PWROK: PR814.2 PU801.13 QV3.2 RC217.2 RV201.1 RV210.1 UC1.C8 UV23.1
DGPU_VID: PU801.5 UV1.E7
DRMOS: PC661.1 PC677.1 PR662.1 PU603.2 PU605.2
E51_RX1: JNGFF.38 T4928.1(TP-1)
E51_TX1: JNGFF.36 RM12.1
E51_TX2: JNGFF.30 RM9.1 RM13.1
EC_AGND: C5230.2 CE71.2 CE80.2 CE83.2 CE90.2 R2453.1 RE344.1 RE385.1 UE5.112
EC_MISO_R: RC57.2 RE374.1 RPC5.8
EC_MOSI_R: RC58.2 RE373.1 RPC5.7
EC_MUTE#: RA14.2 RE365.1 RE368.1 UA1.47
EC_MUTE#_R: RE368.2 UE5.119
EC_SPI_CLK: RE372.2 UE5.32
EC_SPI_CS0#: RE377.1 UE5.27
EC_SPI_MISO: RE374.2 UE5.29
EC_SPI_MOSI: RE373.2 UE5.28
EC_SPICLK_R: RC59.2 RE372.1 RPC5.6
EC_SPICS#_R: JC1.1 RC53.1 RE377.2 UC1.AU3 UC2.1
EC_WAKE#: RC56.2 UE5.35
EDP_AUX#_C: C4322.1 JEDP.8
EDP_AUX_C: C4321.1 JEDP.7
EDP_AUX_DN: C4322.2 UC1.E45
EDP_AUX_DP: C4321.2 UC1.F45
EDP_COMP: RC1.2 UC1.E52
EDP_HPD: JEDP.10 RC220.2 UC1.L10
EDP_TX0#_C: C4311.1 JEDP.2
EDP_TX0_C: C4312.1 JEDP.1
EDP_TX0_DN: C4311.2 UC1.C47
EDP_TX0_DP: C4312.2 UC1.C46
EDP_TX1#_C: C4313.1 JEDP.5
EDP_TX1_C: C4314.1 JEDP.4
EDP_TX1_DN: C4313.2 UC1.D46
EDP_TX1_DP: C4314.2 UC1.C45
EDP_VDD_EN: DX5.2 UC1.U13
EDRAM_OPIO_RCOMP: RC7.1 UC1.H66
EMMC_RCOMP: RC89.2 UC1.AT1
EN_0.675VSP: PC203.1 PR202.2 PU200.7
EN_1.0V_VCCSTU: CC104.1 RC144.2 UC5.3
EN_1.0VS: RV210.2 UV10.5
EN_1.8VALW: PC505.1 PR504.2 PR505.1 PR507.2 PU501.1 R2460.1
EN_1.8VS: RC194.2 UC5.5
EN_1.35V: PC202.1 PR201.2 PU200.8
EN_3V: PD101.2 PR121.1 PU100.12
EN_3V_PRIM: RC174.2 RC191.2 UC8.4
EN_5V: PD101.3 PR120.1 PU102.12
EN_+1VALWP: PC405.1 PR302.1 PR312.1 PR313.2 PR314.2 PR315.2 PU301.1
ENLDO_3V5V: PR102.1 PR103.1 PU100.11 PU102.11
ENVDD_R: DX5.1 RX48.1 UX4.4
EOPIO_RCOMP: RC8.1 UC1.H65
EXT_PWR_GATE#_R: RC210.2 UC4.4
FAN1_DAC_1: UE3.4 UE5.24
FAN1_TACH: CE24.1 CE86.1 JFAN.2 RE50.2 RE353.1 UE5.40
FB_1.8VALW: PC503.2 PR501.2 PR506.1 PU501.6
FB_1.35V: PC214.1 PR204.1 PR207.1 PU200.6
FB_+1VALWP: PR306.2 PR308.2 PR311.1 PU301.4
FB_A_CLK0: RV2706.1 UV1.D24 UV4.J7 UV5.J7 UV8.J7 UV9.J7
FB_A_CLK1: RV2717.1 UV1.N22 UV6.J7 UV7.J7 UV14.J7 UV15.J7
FB_A_CLK#0: RV2706.2 UV1.D25 UV4.K7 UV5.K7 UV8.K7 UV9.K7
FB_A_CLK#1: RV2717.2 UV1.M22 UV6.K7 UV7.K7 UV14.K7 UV15.K7
FB_A_CMD0: RV2440.2 UV1.C27 UV4.K1 UV5.K1 UV8.K1 UV9.K1
FB_A_CMD1: UV1.C26 UV8.L2 UV9.L2
FB_A_CMD2: UV1.E24 UV4.L2 UV5.L2
FB_A_CMD3: RV2438.2 UV1.F24 UV4.K9 UV5.K9 UV8.K9 UV9.K9
FB_A_CMD4: RPV15.1 RPV15.2 UV1.D27 UV4.R3 UV5.R3 UV6.R3 UV7.R3 UV8.R7 UV9.R7 UV14.R7 UV15.R7
FB_A_CMD5: RPV15.3 RPV15.4 UV1.D26 UV4.R8 UV5.R8 UV6.R8 UV7.R8 UV8.R2 UV9.R2 UV14.R2 UV15.R2
FB_A_CMD6: RPV13.3 RPV13.4 UV1.F25 UV4.N2 UV5.N2 UV6.N2 UV7.N2 UV8.N8 UV9.N8 UV14.N8 UV15.N8
FB_A_CMD7: RPV16.1 RPV16.2 UV1.F26 UV4.N3 UV5.N3 UV6.N3 UV7.N3 UV8.N7 UV9.N7 UV14.N7 UV15.N7
FB_A_CMD8: RPV10.3 RPV10.4 UV1.F23 UV4.T8 UV5.T8 UV6.T8 UV7.T8 UV8.T8 UV9.T8 UV14.T8 UV15.T8
FB_A_CMD9: RPV16.3 RPV16.4 UV1.G22 UV4.N7 UV5.N7 UV6.N7 UV7.N7 UV8.N3 UV9.N3 UV14.N3 UV15.N3
FB_A_CMD10: RPV13.1 RPV13.2 UV1.G23 UV4.P7 UV5.P7 UV6.P7 UV7.P7 UV8.P3 UV9.P3 UV14.P3 UV15.P3
FB_A_CMD11: RPV9.3 RPV9.4 UV1.G24 UV4.J3 UV5.J3 UV6.J3 UV7.J3 UV8.J3 UV9.J3 UV14.J3 UV15.J3
FB_A_CMD12: RPV17.1 RPV17.2 UV1.F27 UV4.T3 UV5.T3 UV6.T3 UV7.T3 UV8.T7 UV9.T7 UV14.T7 UV15.T7
FB_A_CMD13: RPV8.3 RPV8.4 UV1.G25 UV4.N8 UV5.N8 UV6.N8 UV7.N8 UV8.N2 UV9.N2 UV14.N2 UV15.N2
FB_A_CMD14: RPV17.3 RPV17.4 UV1.G27 UV4.T7 UV5.T7 UV6.T7 UV7.T7 UV8.T3 UV9.T3 UV14.T3 UV15.T3
FB_A_CMD15: RPV9.1 RPV9.2 UV1.G26 UV4.K3 UV5.K3 UV6.K3 UV7.K3 UV8.K3 UV9.K3 UV14.K3 UV15.K3
FB_A_CMD16: RV2439.2 UV1.M24 UV6.K1 UV7.K1 UV14.K1 UV15.K1
FB_A_CMD17: UV1.M23 UV14.L2 UV15.L2
FB_A_CMD18: UV1.K24 UV6.L2 UV7.L2
FB_A_CMD19: RV2437.2 UV1.K23 UV6.K9 UV7.K9 UV14.K9 UV15.K9
FB_A_CMD20: RV2447.2 UV1.M27 UV4.T2 UV5.T2 UV6.T2 UV7.T2 UV8.T2 UV9.T2 UV14.T2 UV15.T2
FB_A_CMD21: RPV10.1 RPV10.2 UV1.M26 UV4.R2 UV5.R2 UV6.R2 UV7.R2 UV8.R8 UV9.R8 UV14.R8 UV15.R8
FB_A_CMD22: RPV18.1 RPV18.2 UV1.M25 UV4.P8 UV5.P8 UV6.P8 UV7.P8 UV8.P2 UV9.P2 UV14.P2 UV15.P2
FB_A_CMD23: RPV18.3 RPV18.4 UV1.K26 UV4.R7 UV5.R7 UV6.R7 UV7.R7 UV8.R3 UV9.R3 UV14.R3 UV15.R3
FB_A_CMD24: RPV11.3 RPV11.4 UV1.K22 UV4.P3 UV5.P3 UV6.P3 UV7.P3 UV8.P7 UV9.P7 UV14.P7 UV15.P7
FB_A_CMD25: RPV12.1 RPV12.2 UV1.J23 UV4.L7 UV5.L7 UV6.L7 UV7.L7 UV8.L3 UV9.L3 UV14.L3 UV15.L3
FB_A_CMD26: RPV8.1 RPV8.2 UV1.J25 UV4.P2 UV5.P2 UV6.P2 UV7.P2 UV8.P8 UV9.P8 UV14.P8 UV15.P8
FB_A_CMD27: RPV14.1 RPV14.2 UV1.J24 UV4.M3 UV5.M3 UV6.M3 UV7.M3
FB_A_CMD28: RPV12.3 RPV12.4 UV1.K27 UV4.L3 UV5.L3 UV6.L3 UV7.L3 UV8.L7 UV9.L7 UV14.L7 UV15.L7
FB_A_CMD29: RPV14.3 RPV14.4 UV1.K25 UV4.M2 UV5.M2 UV6.M2 UV7.M2 UV8.M2 UV9.M2 UV14.M2 UV15.M2
FB_A_CMD30: RPV11.1 RPV11.2 UV1.J27 UV8.M3 UV9.M3 UV14.M3 UV15.M3
FB_A_D0: UV1.E18 UV4.F8 UV9.F2
FB_A_D1: UV1.F18 UV4.F7 UV9.E3
FB_A_D2: UV1.E16 UV4.H7 UV9.H3
FB_A_D3: UV1.F17 UV4.H8 UV9.G2
FB_A_D4: UV1.D20 UV4.H3 UV9.H7
FB_A_D5: UV1.D21 UV4.E3 UV9.F7
FB_A_D6: UV1.F20 UV4.G2 UV9.H8
FB_A_D7: UV1.E21 UV4.F2 UV9.F8
FB_A_D8: UV1.E15 UV5.F8 UV8.F2
FB_A_D9: UV1.D15 UV5.H8 UV8.G2
FB_A_D10: UV1.F15 UV5.H7 UV8.H3
FB_A_D11: UV1.F13 UV5.F7 UV8.E3
FB_A_D12: UV1.C13 UV5.H3 UV8.H7
FB_A_D13: UV1.B13 UV5.E3 UV8.F7
FB_A_D14: UV1.E13 UV5.G2 UV8.H8
FB_A_D15: UV1.D13 UV5.F2 UV8.F8
FB_A_D16: UV1.B15 UV5.C2 UV8.C8
FB_A_D17: UV1.C16 UV5.C3 UV8.D7
FB_A_D18: UV1.A13 UV5.A2 UV8.B8
FB_A_D19: UV1.A15 UV5.A3 UV8.A7
FB_A_D20: UV1.B18 UV5.A7 UV8.A3
FB_A_D21: UV1.A18 UV5.B8 UV8.A2
FB_A_D22: UV1.A19 UV5.D7 UV8.C3
FB_A_D23: UV1.C19 UV5.C8 UV8.C2
FB_A_D24: UV1.B24 UV4.C2 UV9.C8
FB_A_D25: UV1.C23 UV4.C3 UV9.D7
FB_A_D26: UV1.A25 UV4.A3 UV9.A7
FB_A_D27: UV1.A24 UV4.A2 UV9.B8
FB_A_D28: UV1.A21 UV4.B8 UV9.A2
FB_A_D29: UV1.B21 UV4.A7 UV9.A3
FB_A_D30: UV1.C20 UV4.C8 UV9.C2
FB_A_D31: UV1.C21 UV4.D7 UV9.C3
FB_A_D32: UV1.R22 UV7.F8 UV15.F2
FB_A_D33: UV1.R24 UV7.H8 UV15.G2
FB_A_D34: UV1.T22 UV7.F7 UV15.E3
FB_A_D35: UV1.R23 UV7.H7 UV15.H3
FB_A_D36: UV1.N25 UV7.G2 UV15.H8
FB_A_D37: UV1.N26 UV7.F2 UV15.F8
FB_A_D38: UV1.N23 UV7.E3 UV15.F7
FB_A_D39: UV1.N24 UV7.H3 UV15.H7
FB_A_D40: UV1.V23 UV6.G2 UV14.H8
FB_A_D41: UV1.V22 UV6.E3 UV14.F7
FB_A_D42: UV1.T23 UV6.F2 UV14.F8
FB_A_D43: UV1.U22 UV6.H3 UV14.H7
FB_A_D44: UV1.Y24 UV6.H7 UV14.H3
FB_A_D45: UV1.AA24 UV6.F7 UV14.E3
FB_A_D46: UV1.Y22 UV6.H8 UV14.G2
FB_A_D47: UV1.AA23 UV6.F8 UV14.F2
FB_A_D48: UV1.AD27 UV6.A7 UV14.A3
FB_A_D49: UV1.AB25 UV6.D7 UV14.C3
FB_A_D50: UV1.AD26 UV6.C8 UV14.C2
FB_A_D51: UV1.AC25 UV6.B8 UV14.A2
FB_A_D52: UV1.AA27 UV6.A3 UV14.A7
FB_A_D53: UV1.AA26 UV6.A2 UV14.B8
FB_A_D54: UV1.W26 UV6.C3 UV14.D7
FB_A_D55: UV1.Y25 UV6.C2 UV14.C8
FB_A_D56: UV1.R26 UV7.A2 UV15.B8
FB_A_D57: UV1.T25 UV7.A3 UV15.A7
FB_A_D58: UV1.N27 UV7.C2 UV15.C8
FB_A_D59: UV1.R27 UV7.C3 UV15.D7
FB_A_D60: UV1.V26 UV7.B8 UV15.A2
FB_A_D61: UV1.V27 UV7.A7 UV15.A3
FB_A_D62: UV1.W27 UV7.C8 UV15.C2
FB_A_D63: UV1.W25 UV7.D7 UV15.C3
FB_A_DQM0: UV1.D19 UV4.E7 UV9.E7
FB_A_DQM1: UV1.D14 UV5.E7 UV8.E7
FB_A_DQM2: UV1.C17 UV5.D3 UV8.D3
FB_A_DQM3: UV1.C22 UV4.D3 UV9.D3
FB_A_DQM4: UV1.P24 UV7.E7 UV15.E7
FB_A_DQM5: UV1.W24 UV6.E7 UV14.E7
FB_A_DQM6: UV1.AA25 UV6.D3 UV14.D3
FB_A_DQM7: UV1.U25 UV7.D3 UV15.D3
FB_A_DQS0: UV1.E19 UV4.F3 UV9.F3
FB_A_DQS1: UV1.C15 UV5.F3 UV8.F3
FB_A_DQS2: UV1.B16 UV5.C7 UV8.C7
FB_A_DQS3: UV1.B22 UV4.C7 UV9.C7
FB_A_DQS4: UV1.R25 UV7.F3 UV15.F3
FB_A_DQS5: UV1.W23 UV6.F3 UV14.F3
FB_A_DQS6: UV1.AB26 UV6.C7 UV14.C7
FB_A_DQS7: UV1.T26 UV7.C7 UV15.C7
FB_A_DQS#0: UV1.F19 UV4.G3 UV9.G3
FB_A_DQS#1: UV1.C14 UV5.G3 UV8.G3
FB_A_DQS#2: UV1.A16 UV5.B7 UV8.B7
FB_A_DQS#3: UV1.A22 UV4.B7 UV9.B7
FB_A_DQS#4: UV1.P25 UV7.G3 UV15.G3
FB_A_DQS#5: UV1.W22 UV6.G3 UV14.G3
FB_A_DQS#6: UV1.AB27 UV6.B7 UV14.B7
FB_A_DQS#7: UV1.T27 UV7.B7 UV15.B7
FB_CLAMP: RPV7.4 UV1.F3
FB_IA: PR645.2 PR648.2 PR650.1 PU602.17
FB_VREF: T2401.1(TP-1) UV1.D23
FB_VSA: PR646.1 PR649.1 PR652.1 PU602.25
FCCM_GT: PR671.2 PU602.11
FCCM_IA: PR659.2 PU602.21
FCCM_VSA: PR679.2 PU602.29
FW_UPDATE: DC5.2 DX8.2 JCAM3D.3 RI55.2 RI89.2
FW_UPDATE_EC: DX8.1 RE403.2 UE5.113
FW_UPDATE_R: DC5.1 UC1.AP5
GC6_FB_EN: RC195.2 RV88.2 RV202.2 UV23.2
GC6_THM_DIS#: RC206.1 UC1.J3 UE5.47
GPIO0_GC6_FB_EN: RV202.1 UV1.C6
GPIO8_OVERT#: QV4.3 RV69.1 UV1.A6
GPIO9_ALERT#: RPV6.1 UV1.F8
GPU_B+: PC666.1 PC667.1 PC672.1 PC673.1 PC679.1 PC688.1 PJP602.1 PU605.6 PU605.11
GPU_BUFRST: RV67.1 UV1.D11
GPU_EVENT#: DV1.1 RC204.2
GPU_EVENT#_D: DV1.2 RPV7.3 UV1.A4
GPU_JTAG_TCK: T231.1(TP-1) UV1.AE5
GPU_JTAG_TDI: T242.1(TP-1) UV1.AE6
GPU_JTAG_TDO: T243.1(TP-1) UV1.AF6
GPU_JTAG_TMS: T232.1(TP-1) UV1.AD6
GPU_JTAG_TRST#: RPV6.2 UV1.AG4
GPU_PLLVDD: CV31.1 CV32.1 LV5.2 UV1.L6
GPU_PWR_LEVEL: RPV5.3 UE5.21 UV1.D7
GPU_TESTMODE: RPV6.3 UV1.AD9
GPU_THM_SMBCLK: Q2409.3 QC3.3 QV2.3 R2459.2 RC399.2 RE351.1 RV74.2 UE5.12
