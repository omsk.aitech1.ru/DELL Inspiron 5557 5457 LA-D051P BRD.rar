# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
PCIE_CRX_C_GTX_P3: length 9.4
  BOTTOM w0.076: UV1.AD11 67.48,66.77 67.4,66.84 67.29,66.84 67.15,66.7 67.15,66.21 66.86,65.92 65.63,65.92 65.49,65.78 65.49,63.25 65.54,63.19 65.54,63.17
  BOTTOM w0.127: 65.54,63.17 65.54,62.74 64.45,61.65 v4(64.45,61.65) 64.24,61.44 64.24,60.55 CV15.2
PCIE_CRX_C_GTX_P4: length 11.1
  BOTTOM w0.076: UV1.AC12 66.64,67.45 66.58,67.52 63.96,67.52 63.84,67.4 63.84,63.21 63.87,63.17
  BOTTOM w0.127: CV17.2 62.38,60.63 62.38,61.47 v4(62.6,61.7) 63.82,62.91 63.82,62.92 63.88,62.98 63.88,63.1 63.87,63.1 63.87,63.17
PCIE_CRX_GTX_N1: length 115.5
  IN1 w0.081: 143.07,101.98 143.64,101.4 143.64,100.89 143.86,100.67 143.86,98.67 144.05,98.48 144.29,98.48 144.41,98.36 v2(144.41,98.21)
  IN1 w0.102: 143.07,101.98 142.63,102.41 137.91,102.41 137.28,101.78 127.84,101.78 127.4,102.22 126.14,102.22 125.93,102.01 112.1,102.01 111.61,101.52 109.84,101.52 108.77,100.45 108.77,98.33 106.63,96.19 106.43,96.19 105.34,95.1 105.34,93.83 104.28,92.76 98.98,92.76 92.39,86.17 92.39,73 91.18,71.79 91.18,68 90.54,67.36 87.61,67.36 82.47,62.22 81.27,62.22 78.8,59.74 73.21,59.74 69.53,56.06 67.8,56.06 67.62,56.24 67.62,56.56 v2(67.42,56.76)
  BOTTOM w0.076: v2(144.41,98.21) UC1.H13
  BOTTOM w0.127: v2(67.42,56.76) 67.56,56.9 67.56,59.05 CV12.1
PCIE_CRX_GTX_N2: length 119.1
  IN1 w0.081: 142.17,103.94 144.78,101.33 144.78,99.3 144.96,99.11 145.27,99.11 145.41,98.97 145.41,98.86 v2(145.33,98.78)
  IN1 w0.102: v2(66.23,56.82) 66.03,57.02 66.03,57.4 66.35,57.71 70.11,57.71 72.9,60.5 78.54,60.5 81.15,63.11 82.26,63.11 87.2,68.06 88.95,68.06 89.85,68.96 89.85,71.75 91.69,73.59 91.69,88.49 96.73,93.53 103.82,93.53 104.58,94.29 104.58,95.63 106.03,97.08 106.03,97.7 107.82,99.48 107.82,100.77 110.25,103.2 111.66,103.2 112.19,102.67 124.7,102.67 124.99,102.95 127.58,102.95 127.99,102.54 136.7,102.54 138.11,103.94 142.17,103.94
  BOTTOM w0.112: v2(145.33,98.78) 145.41,98.86 145.51,98.86 UC1.G11
  BOTTOM w0.127: v2(66.23,56.82) 66.06,56.99 66.06,59.07 CV14.1
PCIE_CRX_GTX_N3: length 118
  IN1 w0.081: 142.04,100.32 142.04,98.53 142.21,98.35 142.53,98.35 142.65,98.24 v2(142.65,98.19)
  IN1 w0.102: 142.04,100.32 141.8,100.56 138.49,100.56 137.42,99.5 129.45,99.5 128.88,100.07 126.8,100.07 126.31,100.56 113.84,100.56 113.53,100.26 113.53,99.06 111.83,97.36 110.07,97.36 107.75,95.04 107.75,91.42 106.75,90.42 99.75,90.42 93.78,84.45 93.78,70.6 92.64,69.47 92.64,66.97 91.13,65.46 87.81,65.46 82.99,60.63 81.78,60.63 79.37,58.22 73.78,58.22 70.16,54.6 64.87,54.6 64.06,55.41 64.06,56.18 v2(63.89,56.35)
  BOTTOM w0.076: v2(142.65,98.19) 143.04,97.97 UC1.H16
  BOTTOM w0.127: v2(63.89,56.35) 64,56.47 64,58.98 CV16.1
PCIE_CRX_GTX_N4: length 121.1
  IN1 w0.081: v2(143.48,98.78) 143.28,98.99 143.12,98.99 142.96,99.15 142.96,99.17 142.96,99.18 142.96,99.67 142.96,99.67 142.96,99.76 143.44,100.24 143.44,100.51 143,100.96
  IN1 w0.102: 143,100.96 142.3,101.65 138.48,101.65 137.47,100.64 134.68,100.64 134.49,100.45 133.96,100.45 133.39,101.01 132.7,101.01 132.14,100.45 129.29,100.45 128.85,100.89 127.76,100.89 127.12,101.53 126.74,101.53 126.52,101.31 113.59,101.31 112.98,100.7 110.53,100.7 109.66,99.83 109.66,98.04 107.05,95.43 107.05,91.75 106.48,91.18 99.5,91.18 93.09,84.76 93.09,72.64 91.94,71.49 91.94,67.47 90.63,66.15 87.36,66.15 82.71,61.5 81.65,61.5 79.2,59.05 73.53,59.05 69.84,55.36 65.84,55.36 64.98,56.23 64.98,57.35 64.68,57.65 62.43,57.65 62.22,57.86 62.22,58.19 v2(62.03,58.39)
  BOTTOM w0.076: UC1.G15 143.77,98.78 v2(143.48,98.78)
  BOTTOM w0.127: v2(62.03,58.39) 62.16,58.52 62.16,59.05 CV18.1
PCIE_CRX_GTX_P1: length 115.5
  IN1 w0.081: v2(144.41,98.95) 144.41,98.75 144.33,98.67 144.12,98.67 144.04,98.74 144.04,100.75 143.84,100.96 143.84,101.48 143.2,102.12
  IN1 w0.102: 143.2,102.12 142.71,102.61 137.83,102.61 137.2,101.98 127.93,101.98 127.49,102.42 126.06,102.42 125.85,102.21 112.02,102.21 111.53,101.72 109.76,101.72 108.57,100.53 108.57,98.41 106.55,96.38 106.35,96.38 105.15,95.18 105.15,93.91 104.2,92.96 98.9,92.96 92.2,86.25 92.2,73.08 90.99,71.87 90.99,68.09 90.46,67.56 87.53,67.56 82.39,62.42 81.19,62.42 78.72,59.94 73.13,59.94 69.44,56.26 67.88,56.26 67.82,56.32 67.82,56.56 67.81,56.56 67.81,56.57 v2(68,56.76)
  BOTTOM w0.076: v2(144.41,98.95) 144.41,98.65 144.47,98.59 UC1.G13
  BOTTOM w0.127: v2(68,56.76) 67.84,56.92 67.84,59.02 CV11.1
PCIE_CRX_GTX_P2: length 119.1
  IN1 w0.081: 142.24,104.14 144.96,101.41 144.96,99.37 145.03,99.31 145.15,99.31 v2(145.33,99.48)
  IN1 w0.102: v2(65.65,56.82) 65.84,57.01 65.84,57.48 66.27,57.91 70.03,57.91 72.82,60.7 78.46,60.7 81.07,63.31 82.17,63.31 87.12,68.25 88.87,68.25 89.66,69.04 89.66,71.83 91.49,73.67 91.49,88.57 96.65,93.72 103.73,93.72 104.39,94.37 104.39,95.71 105.84,97.16 105.84,97.78 107.62,99.56 107.62,100.85 110.17,103.4 111.74,103.4 112.28,102.86 124.62,102.86 124.91,103.15 127.66,103.15 128.07,102.73 136.62,102.73 138.02,104.14 142.24,104.14
  BOTTOM w0.112: UC1.F11 145.57,99.24 v2(145.33,99.48)
  BOTTOM w0.127: CV13.1 65.78,58.98 65.78,56.95 v2(65.65,56.82)
PCIE_CRX_GTX_P3: length 118
  IN1 w0.081: 142.23,100.26 142.23,98.61 142.3,98.54 142.54,98.54 142.64,98.64 v2(142.64,98.87)
  IN1 w0.102: 142.23,100.26 142.23,100.4 141.88,100.76 138.41,100.76 137.34,99.69 129.53,99.69 128.96,100.26 126.88,100.26 126.39,100.76 113.76,100.76 113.34,100.34 113.34,99.15 111.75,97.56 109.99,97.56 107.56,95.12 107.56,91.5 106.67,90.61 99.67,90.61 93.59,84.53 93.59,70.68 92.45,69.55 92.45,67.05 91.05,65.66 87.73,65.66 82.91,60.83 81.7,60.83 79.29,58.42 73.7,58.42 70.08,54.8 64.96,54.8 64.26,55.49 64.26,56.14 64.32,56.2 v2(64.47,56.35)
  BOTTOM w0.076: UC1.G16 142.99,98.54 142.8,98.54 142.64,98.7 v2(142.64,98.87)
  BOTTOM w0.127: CV15.1 64.29,59.07 64.29,56.54 v2(64.47,56.35)
PCIE_CRX_GTX_P4: length 121.1
  IN1 w0.081: v2(143.5,99.47) 143.5,99.3 143.38,99.18 143.21,99.18 143.14,99.25 143.14,99.67 143.64,100.16 143.64,100.59 143.13,101.09
  IN1 w0.102: v2(62.61,58.39) 62.42,58.19 62.42,57.94 62.51,57.84 64.77,57.84 65.18,57.43 65.18,56.31 65.92,55.56 69.76,55.56 73.45,59.24 79.12,59.24 81.57,61.69 82.63,61.69 87.28,66.35 90.54,66.35 91.75,67.55 91.75,71.57 92.89,72.72 92.89,84.84 99.42,91.37 106.4,91.37 106.86,91.83 106.86,95.51 109.47,98.12 109.47,99.91 110.45,100.9 112.9,100.9 113.51,101.51 126.44,101.51 126.66,101.72 127.2,101.72 127.84,101.09 128.93,101.09 129.37,100.64 132.06,100.64 132.62,101.21 133.47,101.21 134.04,100.64 134.41,100.64 134.6,100.83 137.39,100.83 138.4,101.85 142.38,101.85 143.13,101.09
  BOTTOM w0.076: v2(143.5,99.47) 143.5,99.47 143.5,99.31 143.63,99.18 143.89,99.18 UC1.F15
  BOTTOM w0.127: CV17.1 62.44,59.01 62.44,58.56 v2(62.61,58.39)
PCIE_CTX_C_GRX_N1: length 109.4
  IN1 w0.102: v2(77.22,62.92) 77.08,63.06 77.08,63.28 77.42,63.62 79.3,63.62 85.4,69.71 87.24,69.71 87.88,70.35 87.88,72.19 89.79,74.1 89.79,88.94 97.04,96.19 101.93,96.19 103.25,97.51 103.25,99.67 103.58,100 104.58,100 109.4,104.82 126.79,104.82 127.16,105.2 127.3,105.34 129.45,105.34 129.84,104.96 136.07,104.96 137.86,106.75 145.36,106.75 146.57,107.96 v2(146.57,108.74)
  BOTTOM w0.076: UV1.AG7 71.01,63.79 71.01,63.34 71.22,63.13 71.22,63.09 71.24,63.08
  BOTTOM w0.127: 71.24,63.08 72.24,62.08 76.75,62.08 77.1,62.43 77.1,62.8 v2(77.22,62.92) ; CC17.1 146.49,108.35 146.49,108.65 v2(146.57,108.74)
PCIE_CTX_C_GRX_N2: length 114.8
  IN1 w0.102: v2(78.42,62.34) 78.23,62.54 78.23,62.71 78.43,62.91 79.58,62.91 85.67,69.01 87.83,69.01 88.71,69.89 88.71,72.05 90.49,73.82 90.49,88.62 97.36,95.5 102.25,95.5 103.95,97.19 103.95,98.4 109.8,104.25 127.11,104.25 127.49,104.64 129.2,104.64 129.52,104.32 136.52,104.32 138.17,105.97 146.55,105.97 148.39,107.81 148.39,108.68 v2(148.48,108.76)
  BOTTOM w0.076: 70.23,63.17 70.23,63.18 70.24,63.2 70.24,64.35 70.28,64.38 70.28,65.12 70.55,65.4 70.73,65.4 70.8,65.46 UV1.AE7
  BOTTOM w0.127: v2(78.42,62.34) 78.23,62.15 78.23,61.9 77.57,61.25 71.32,61.25 70.23,62.35 70.23,63.17 ; v2(148.48,108.76) 148.36,108.64 148.36,108.39 CC18.1
PCIE_CTX_C_GRX_N3: length 111.1
  IN1 w0.102: v2(144.06,108.82) 144.25,108.63 144.25,108.08 143.8,107.63 137.45,107.63 135.74,105.91 130.23,105.91 129.79,106.36 127,106.36 126.3,105.66 123.19,105.66 122.55,106.3 122.39,106.3 122.38,106.29 109.09,106.29 103.69,100.9 101.85,100.9 98.17,97.21 96.77,97.21 88.89,89.34 88.89,74.48 78.92,64.51 76.49,64.51 75.99,64.01 73.7,61.72 69.7,61.72 69.46,61.48 69.46,61.27 69.46,61.27 69.46,61.23 v2(69.29,61.05)
  BOTTOM w0.076: 69.19,63.17 69.19,63.24 69.2,63.26 69.2,63.62 69.46,63.88 69.46,65.05 69.27,65.24 69.13,65.24 69.06,65.17 69.06,64.86 UV1.AF9
  BOTTOM w0.127: 69.19,63.17 69.19,63.07 69.44,62.81 69.44,61.21 v2(69.29,61.05) ; CC20.1 144.2,108.51 144.2,108.68 v2(144.06,108.82)
PCIE_CTX_C_GRX_N4: length 105.3
  IN1 w0.102: v2(68.17,62.72) 68.38,62.93 68.38,63.17 68.64,63.43 69.29,63.43 70.31,62.41 73.38,62.41 73.65,62.68 73.65,64.57 74.35,65.27 78.67,65.27 88.19,74.79 88.19,89.61 96.5,97.92 97.9,97.92 101.58,101.6 103.38,101.6 108.77,106.99 122.95,106.99 123.58,106.36 126.01,106.36 126.02,106.35 126.72,107.06 130.18,107.06 130.56,106.68 135.48,106.68 137.12,108.31 139.89,108.31 139.96,108.39 139.96,108.54 v2(139.66,108.84)
  BOTTOM w0.076: UV1.AG10 68.51,63.81 68.51,63.69 68.4,63.58 68.4,63.3 68.38,63.28 68.38,63.2 68.36,63.18 68.36,63.17
  BOTTOM w0.127: 68.36,63.17 68.36,62.91 v2(68.17,62.72) ; v2(139.66,108.84) 139.82,108.68 139.82,108.45 CC23.1
PCIE_CTX_C_GRX_P1: length 109.4
  IN1 w0.102: v2(145.99,108.74) 146.38,108.34 146.38,108.05 145.28,106.94 137.78,106.94 135.99,105.15 129.92,105.15 129.54,105.53 127.22,105.53 127.16,105.48 126.71,105.02 109.32,105.02 104.5,100.2 103.5,100.2 103.05,99.75 103.05,97.59 101.85,96.38 96.96,96.38 89.59,89.02 89.59,74.18 87.68,72.27 87.68,70.43 87.16,69.91 85.32,69.91 79.22,63.81 77.34,63.81 76.89,63.36 76.89,63.17 v2(76.64,62.92)
  BOTTOM w0.076: 71.44,63.28 71.43,63.29 71.39,63.29 71.25,63.44 71.25,63.94 71.34,64.04 71.56,64.04 UV1.AG6
  BOTTOM w0.127: v2(76.64,62.92) 76.82,62.74 76.82,62.55 76.63,62.36 72.36,62.36 71.44,63.28 ; v2(145.99,108.74) 146.22,108.51 146.22,108.24 146.09,108.11 CC21.1
PCIE_CTX_C_GRX_P2: length 114.7
  IN1 w0.102: v2(77.84,62.34) 78.03,62.54 78.03,62.79 78.35,63.11 79.5,63.11 85.59,69.21 87.75,69.21 88.51,69.97 88.51,72.13 90.29,73.91 90.29,88.7 97.28,95.69 102.17,95.69 103.75,97.27 103.75,98.48 109.72,104.45 127.02,104.45 127.41,104.83 129.28,104.83 129.6,104.52 136.44,104.52 138.09,106.17 146.47,106.17 148.2,107.9 148.2,108.46 v2(147.89,108.76)
  BOTTOM w0.076: 70.5,63.17 70.5,63.18 70.5,63.18 70.48,63.2 70.48,65.08 70.61,65.21 71.05,65.21 71.11,65.14 71.11,64.95 70.96,64.8 UV1.AF7
  BOTTOM w0.127: v2(147.89,108.76) 148.08,108.58 148.08,108.2 147.99,108.11 CC19.1 ; v2(77.84,62.34) 77.95,62.23 77.95,62.02 77.47,61.54 71.44,61.54 70.51,62.46 70.51,63.17 70.5,63.17
PCIE_CTX_C_GRX_P3: length 111
  IN1 w0.102: v2(69.87,61.05) 69.65,61.27 69.65,61.4 69.78,61.52 73.78,61.52 76.57,64.31 79,64.31 89.09,74.4 89.09,89.25 96.85,97.02 98.25,97.02 101.93,100.7 103.78,100.7 109.17,106.09 122.46,106.09 122.47,106.1 123.1,105.46 126.38,105.46 127.08,106.16 129.71,106.16 130.15,105.72 135.82,105.72 137.53,107.43 143.88,107.43 144.45,108 144.45,108.62 v2(144.64,108.82)
  BOTTOM w0.076: UV1.AE9 69.12,65.49 69.2,65.41 69.34,65.41 69.63,65.12 69.63,63.71 69.44,63.52 69.44,63.3 69.46,63.28 69.46,63.18 69.47,63.17
  BOTTOM w0.127: CC22.1 144.49,108.45 144.49,108.66 v2(144.64,108.82) ; 69.47,63.17 69.72,62.92 69.72,61.21 v2(69.87,61.05)
PCIE_CTX_C_GRX_P4: length 105.4
  IN1 w0.102: v2(68.75,62.72) 68.57,62.9 68.57,63.09 68.72,63.24 69.21,63.24 70.23,62.22 73.46,62.22 73.84,62.6 73.84,64.48 74.43,65.07 78.75,65.07 88.39,74.71 88.39,89.53 96.58,97.72 97.98,97.72 101.66,101.4 103.46,101.4 108.86,106.8 122.87,106.8 123.5,106.16 126.09,106.16 126.15,106.22 126.15,106.22 126.8,106.86 130.1,106.86 130.48,106.48 135.57,106.48 137.2,108.12 139.97,108.12 140.16,108.31 140.16,108.75 v2(140.24,108.84)
  BOTTOM w0.076: UV1.AG9 68.91,64 68.74,63.83 68.74,63.59 68.64,63.48 68.64,63.17
  BOTTOM w0.127: CC24.1 140.1,108.51 140.1,108.7 v2(140.24,108.84) ; 68.64,63.17 68.64,62.83 v2(68.75,62.72)
PCIE_CTX_GRX_N1: length 7.9
  BOTTOM w0.076: 143.57,104.92 143.12,104.48 143.12,103.13 142.94,102.95 142.94,102.41 UC1.B17
  BOTTOM w0.127: 143.57,104.92 143.97,105.32 144.57,105.32 145.13,105.88 146.1,105.88 146.52,106.3 146.52,106.99 CC17.2
PCIE_CTX_GRX_N2: length 9.7
  BOTTOM w0.076: UC1.D16 143.34,101.56 143.34,102.76 143.55,102.97 143.55,104.03 144.3,104.79 145.51,104.79 145.76,105.04 146.6,105.04 146.64,105.08 146.67,105.08 146.72,105.14 146.75,105.14 146.76,105.15
  BOTTOM w0.127: CC18.2 148.6,107.2 148.16,106.75 148.16,106.55 147.76,106.15 v4(147.61,106) 147.04,105.43 146.76,105.15
PCIE_CTX_GRX_N3: length 7.8
  BOTTOM w0.076: 142.4,103.9 142.4,103.9 142.4,103.89 142.42,103.87 142.42,103.8 142.44,103.78 142.44,103.35 142.06,102.97 142.06,102.48 142.1,102.38 142.1,102.19 142.06,102.1 142.06,101.85 142.08,101.8 142.16,101.54 142.2,101.37 142.2,101.26 142.28,100.99 UC1.D17
  BOTTOM w0.127: 142.4,103.9 142.39,103.91 v4(142.39,104.4) 142.39,105.33 143.51,106.45 143.83,106.45 144.04,106.66 144.04,106.96 CC20.2
PCIE_CTX_GRX_N4: length 5.9
  BOTTOM w0.089: 139.73,105.34 139.73,104.73 v4(140.3,104.16) 140.84,103.62 140.84,102.35 141.14,102.05 UC1.B19
  BOTTOM w0.127: CC23.2 139.49,107.18 139.73,106.94 139.73,106.7 139.73,105.34
PCIE_CTX_GRX_P1: length 7.9
  BOTTOM w0.076: 143.38,105.12 143.37,105.11 143.37,105.08 143.32,105.03 143.32,105 142.89,104.57 142.89,103.22 142.74,103.08 142.74,102.67 142.68,102.61 UC1.A17
  BOTTOM w0.127: CC21.2 145.9,107.39 146.12,107.39 146.23,107.27 146.23,106.42 145.98,106.16 v4(145.54,106.16) 145.03,106.16 144.46,105.59 143.85,105.59 143.38,105.12
PCIE_CTX_GRX_P2: length 9.6
  BOTTOM w0.076: UC1.C16 143.06,101.5 142.97,101.41 142.86,101.41 142.74,101.53 142.74,101.78 143.11,102.15 143.11,102.86 143.31,103.07 143.31,104.13 144.2,105.02 v4(144.84,105.02) 145.41,105.02 145.66,105.27 146.5,105.27 146.55,105.33 146.55,105.34
  BOTTOM w0.127: CC19.2 147.87,106.94 147.87,106.66 146.55,105.35 146.55,105.34
PCIE_CTX_GRX_P3: length 7.7
  BOTTOM w0.076: 142.68,103.9 142.68,103.25 142.23,102.8 142.23,102.51 142.26,102.44 142.26,102.16 142.23,102.05 142.23,101.88 142.38,101.43 142.38,101.43 UC1.C17
  BOTTOM w0.127: CC22.2 144.63,107.39 144.43,107.39 144.33,107.29 144.33,106.54 143.95,106.16 143.63,106.16 v4(143.38,105.91) 142.68,105.21 142.68,103.9
PCIE_CTX_GRX_P4: length 5.9
  BOTTOM w0.089: 140,105.34 140,105.33 140,105.33 139.99,105.31 139.99,105.23 139.97,105.22 139.97,104.84 141.08,103.73 141.08,102.68 UC1.A19
  BOTTOM w0.127: CC24.2 140.25,107.45 140.09,107.45 140.01,107.37 v4(140.01,105.85) 140.01,105.34 140,105.34
PCIE_PRX_LANTX_N3_C: length 3.1
  BOTTOM w0.089: CL31.2 172.03,101.14 172.13,101.14 172.27,101.29 172.27,102.18 172.54,102.45 172.84,102.45 172.95,102.56 UL1.18
PCIE_PRX_LANTX_N6: length 33.9
  IN3 w0.089: v2(157.26,100.96) 157.42,101.12 157.42,101.26 157.28,101.4 151.7,101.4 151.45,101.65 147.69,101.65 147.57,101.53 142.87,101.53 142.22,100.88 142.22,99.23 142.04,99.05 141.86,99.05 v2(141.62,98.82)
  BOTTOM w0.076: v2(141.62,98.82) 142.08,98.59 UC1.G18
  BOTTOM w0.089: CL31.1 170.38,101.18 167.97,101.18 167.43,100.64 166.87,100.64 166.55,100.32 162.68,100.32 161.35,101.65 v4(159.95,101.65) 157.79,101.65 157.48,101.35 157.48,101.18 v2(157.26,100.96)
PCIE_PRX_LANTX_P3_C: length 3.1
  BOTTOM w0.089: CL30.2 171.96,100.96 172.21,100.96 172.46,101.21 172.46,101.4 172.49,101.43 v4(172.49,101.66) 172.49,101.91 172.46,101.94 172.46,102.1 172.62,102.26 172.9,102.26 173.01,102.16 UL1.17
PCIE_PRX_LANTX_P6: length 34
  IN3 w0.089: v2(157.85,100.96) 157.61,101.2 157.61,101.34 157.36,101.59 151.78,101.59 151.53,101.85 147.62,101.85 147.49,101.72 142.79,101.72 142.03,100.96 142.03,99.31 141.97,99.24 141.86,99.24 v2(141.62,99.48)
  BOTTOM w0.076: v2(141.62,99.48) 142.08,99.24 UC1.F18
  BOTTOM w0.089: v2(157.85,100.96) 157.67,101.14 157.67,101.27 157.86,101.46 159.63,101.46 159.66,101.43 160.3,101.43 160.33,101.46 161.28,101.46 162.6,100.14 166.63,100.14 166.95,100.45 167.51,100.45 168.05,100.99 170.38,100.99 CL30.1
PCIE_PRX_WLANTX_N5: length 86.5
  IN3 w0.089: v2(142.6,99.48) 142.6,99.75 142.49,99.86 142.49,100.72 142.85,101.08 143.76,101.08 144.1,100.74 147.53,100.74 148.25,101.46 151.02,101.46 151.53,100.96 155.71,100.96 156.16,100.51 158.41,100.51 162.15,96.77 165.22,96.77 166.3,95.68 166.3,95.11 180.43,80.99 185.76,80.99 192.05,74.69 192.05,69.55 188.87,66.37 188.87,61.94 188.27,61.33 187.64,61.33 v2(187.45,61.14)
  BOTTOM w0.076: UC1.F16 143.04,99.26 142.61,99.48 v2(142.6,99.48)
  BOTTOM w0.089: v2(187.45,61.14) 187.25,61.34 184.59,61.34 182.79,59.54 182.79,58.75 182.98,58.56 JNGFF.35
PCIE_PRX_WLANTX_P5: length 86.4
  IN3 w0.089: v2(143.04,100.38) 143.19,100.24 143.19,99.94 143.06,99.81 142.8,99.81 142.68,99.94 142.68,100.64 142.93,100.89 143.68,100.89 144.02,100.55 147.61,100.55 148.33,101.27 150.94,101.27 151.45,100.77 155.63,100.77 156.08,100.32 158.33,100.32 162.08,96.57 165.14,96.57 166.11,95.61 166.11,95.04 180.35,80.8 185.68,80.8 191.86,74.61 191.86,69.63 188.68,66.45 188.68,62.01 188.19,61.52 187.65,61.52 v2(187.45,61.72)
  BOTTOM w0.076: UC1.E16 v2(143.04,100.38)
  BOTTOM w0.089: v2(187.45,61.72) 187.25,61.52 184.52,61.52 182.61,59.61 182.61,58.72 182.48,58.58 JNGFF.33
PCIE_PTX_LANRX_N6: length 7.8
  BOTTOM w0.076: 138.33,105.34 138.33,105.12 138.46,105 138.51,105 138.97,104.53 138.97,104.49 139.14,104.32 139.75,104.32 140.61,103.46 140.61,102.28 140.87,102.01 140.87,101.71 140.88,101.68 140.88,101.55 UC1.D20
  BOTTOM w0.089: 138.33,105.34 v4(138.33,106.1) 138.33,106.93 CC135.2
PCIE_PTX_LANRX_N6_C: length 46.6
  IN3 w0.089: v2(138.31,108.84) 137.98,108.51 137.98,108.27 138.52,107.74 158.25,107.74 164.36,101.63 167.8,101.63 170.05,99.38 170.05,98.24 170.13,98.16 170.19,98.16 v2(170.49,98.46)
  BOTTOM w0.089: UL1.14 174.97,101.05 175.19,100.83 175.19,99.88 173.45,98.14 v4(172.9,98.14) 170.81,98.14 v2(170.49,98.46) ; v2(138.31,108.84) 138.11,108.63 138.11,108.32 138.31,108.11 CC135.1
PCIE_PTX_LANRX_P6: length 7.8
  BOTTOM w0.076: UC1.C20 140.7,101.76 140.7,101.94 140.43,102.21 140.43,103.39 139.68,104.15 139.06,104.15 v4(138.59,104.62) 138.16,105.05 138.16,105.26 138.15,105.26 138.15,105.32 138.15,105.33 138.15,105.34
  BOTTOM w0.089: CC136.2 137.75,107.37 138.04,107.37 138.15,107.26 138.15,106.42 138.12,106.39 138.12,105.81 138.15,105.78 138.15,105.34
PCIE_PTX_LANRX_P6_C: length 46.7
  IN3 w0.089: v2(170.49,97.88) 170.4,97.97 170.05,97.97 169.86,98.16 169.86,99.3 167.72,101.44 164.28,101.44 158.17,107.55 138.44,107.55 137.79,108.2 137.79,108.78 v2(137.73,108.84)
  BOTTOM w0.089: UL1.13 175.37,99.8 173.5,97.93 172.55,97.93 172.52,97.96 170.57,97.96 v2(170.49,97.88) ; CC136.1 137.92,108.45 137.92,108.65 v2(137.73,108.84)
PCIE_PTX_WLANRX_N5: length 7.2
  BOTTOM w0.076: UC1.C19 141.34,101.5 141.34,101.65 141.41,101.88 141.41,102.05 141.35,102.24 141.35,102.39 141.41,102.5 141.41,103.64 141.4,103.65 141.4,103.67
  BOTTOM w0.089: 141.4,103.67 141.4,105.57 141.87,106.04 141.91,106.04 142.42,106.55 142.42,107.26 142.3,107.39 142.09,107.39 CC25.2
PCIE_PTX_WLANRX_N5_C: length 107.4
  IN3 w0.089: v2(192.45,60.33) 192.78,60.65 192.78,61.66 193.73,62.62 193.73,63.48 193.93,63.68 195.68,65.43 195.68,75.76 194.82,76.62 194.82,77.63 192.68,79.77 192.68,80.78 185.27,88.19 179.91,88.19 170.89,97.21 170.89,99.09 168.46,101.53 168.46,106.66 166.47,108.64 159.77,108.64 159.27,108.13 142.02,108.13 141.76,108.39 141.76,108.78 v2(141.59,108.96)
  BOTTOM w0.089: JNGFF.29 181.48,58.75 181.32,58.9 181.32,59.21 184.27,62.16 189.72,62.16 190.64,61.24 192.3,61.24 192.65,60.88 192.65,60.53 v2(192.45,60.33) ; CC25.1 142.22,108.11 142.36,108.26 142.36,108.45 142.25,108.56 141.99,108.56 v2(141.59,108.96)
PCIE_PTX_WLANRX_P5: length 7.2
  BOTTOM w0.076: 141.59,103.67 141.59,103.65 141.58,103.64 141.58,102.46 141.52,102.33 141.52,102.26 141.54,102.19 141.58,102.1 141.58,101.85 141.56,101.8 141.53,101.71 141.5,101.59 141.5,101.48 141.36,100.99 UC1.D19
  BOTTOM w0.089: 141.59,103.67 141.59,105.45 v4(141.82,105.68) 142.61,106.48 142.61,106.89 CC26.2
PCIE_PTX_WLANRX_P5_C: length 107.4
  IN3 w0.089: v2(193.04,60.33) 192.97,60.39 192.97,61.59 193.92,62.54 193.92,63.4 194.06,63.54 195.87,65.35 195.87,75.84 195.01,76.7 195.01,77.71 192.87,79.85 192.87,80.86 185.35,88.38 179.99,88.38 171.08,97.29 171.08,99.17 168.65,101.61 168.65,106.73 166.55,108.83 159.7,108.83 159.19,108.32 142.09,108.32 141.95,108.46 141.95,108.73 v2(142.17,108.96)
  BOTTOM w0.089: JNGFF.27 180.98,58.75 181.13,58.9 181.13,59.28 184.19,62.34 189.8,62.34 190.72,61.42 192.37,61.42 192.84,60.96 192.84,60.53 v2(193.04,60.33) ; CC26.1 142.92,108.21 v2(142.17,108.96)
PCIE_RCOMPN: length 2.3
  TOP w0.076: RC120.2 149.66,98.8 v1(149.28,98.42)
  TOP w0.305: RC120.2 149.54,99.48 v2(148.98,99.48)
  BOTTOM w0.254: UC1.F5 v2(148.98,99.48)
PCIE_RCOMPP: length 1.3
  TOP w0.305: v2(148.98,100.11) 149.51,100.11 RC120.1
  BOTTOM w0.254: UC1.E5 v2(148.98,100.11)
PCIE_WAKE#: length 192.7
  TOP w0.102: v2(142.02,11.74) 142.02,9.61 142.71,8.92 143.58,8.92 145.34,7.15 145.34,6.79 145.58,6.55 UE5.4 147.79,6.55 RE352.2 ; RC66.2 155.44,69.32 v2(155.95,69.83)
  IN1 w0.102: v2(142.02,11.74) 142.16,11.6 147.86,11.6 148.62,12.36 151.41,12.36 153.11,10.66 163.42,10.66 165.23,12.47 165.23,13.4 169.48,17.64 174.13,17.64 183.9,27.42 183.9,28.65 185.95,30.7 185.95,36.41 188.65,39.12 188.65,42.35 189.2,42.89 189.2,55.68 v2(188.69,56.19) 187.76,57.12 187.76,59.79 186.82,60.73 186.82,69.07 186.24,69.66 186.24,76.79 177.51,85.51 177.51,93.6 172.68,98.44 172.68,99.35 171.57,100.46 171.57,103.59 v2(172.05,104.07)
  IN2 w0.102: v2(155.95,69.83) 158.86,69.83 164.52,64.16 164.52,60.52 166.26,58.78 166.67,58.78 167.43,58.02 170.05,58.02 170.49,58.46 178.1,58.46 180.23,56.33 v2(183.05,56.33)
  BOTTOM w0.102: v2(172.05,104.07) 172.36,103.75 172.82,103.75 172.82,103.76 UL1.21 ; v2(188.69,56.19) 188.42,55.92 184.75,55.92 184.56,55.73 RM14.1 184.56,55.06 184.41,54.91 183.31,54.91 183.05,55.16 v2(183.05,56.33)
PECI_EC: length 175.6
  TOP w0.102: DE3.1 125.39,3.87 RE364.2 125.19,4.7 v2(125.19,5.54)
  IN1 w0.089: v2(88.13,36.15) 88.54,35.75 96.11,35.75 107,24.85 108.89,24.85 v2(113.22,20.52)
  IN3 w0.102: v2(103.97,99.56) 100.14,99.56 92.16,91.57 92.16,72.84 91.43,72.11 91.43,64.82 91.62,64.63 91.62,59.28 90.98,58.64 90.98,42.4 88.03,39.45 88.03,36.25 v2(88.13,36.15)
  BOTTOM w0.076: UC1.A54 121.6,102.89 121.6,103.75 122.1,104.26 123.25,104.26 124.17,105.19 124.17,105.34
  BOTTOM w0.102: v2(113.22,20.52) v1(113.22,16.12) 113.22,13.96 115.5,11.68 115.5,7.29 117.34,5.45 118.48,5.45 120.13,3.8 121.98,3.8 122.17,3.99 123.63,3.99 125.18,5.54 v2(125.19,5.54) ; 124.17,105.34 124.17,106.5 123.48,107.2 123.48,110.33 122.24,111.57 122.23,111.57 121.86,111.94 120.8,111.94 120.44,111.57 112.38,111.57 111.25,112.7 108.71,112.7 107.58,111.57 106.05,111.57 105.78,111.31 105.78,108.77 106.86,107.69 106.86,105.91 106.99,105.78 106.99,103.56 106.01,102.58 106.01,102.2 103.97,100.16 v2(103.97,99.56)
PECI_MEC1404: length 5.4
  TOP w0.102: UE5.94 129.73,6.15 v1(129.22,5.64) 128.59,5.01 126.82,5.01 RE364.1
PEG_CLKREQ#: length 143
  TOP w0.102: v2(147.16,84.04) 146.68,83.56 146.68,83.24 147.25,82.67 147.25,80.83 148.27,79.81 v1(148.27,79.62) 148.27,79.26 151.78,75.75 152.88,75.75 153.49,75.14 RPC10.4 ; v2(82.3,72.72) 82.21,72.64 77.12,72.64 QV3.1 76.45,68.81 RV5.2
  IN3 w0.127: v2(147.16,84.04) 146.73,83.61 146.73,82.51 147.26,81.98 147.26,80.41 153.74,73.92 154.98,73.92 155.96,72.94 155.96,71.07 156.41,70.62 156.41,69.35 155.96,68.91 155.96,67.29 156.65,66.6 156.65,65.55 157.47,64.72 158.94,64.72 159.88,63.79 159.88,62.86 160.84,61.9 v2(160.84,61.68)
  BOTTOM w0.076: v2(147.16,84.04) 146.79,84.4 UC1.AR10
  BOTTOM w0.102: v2(160.84,61.68) 160.84,61.78 159.79,62.83 156.93,62.83 156.78,62.67 152.45,62.67 150.39,64.72 100.67,64.72 87.87,77.52 85.4,77.52 84.19,76.32 84.19,74.92 82.3,73.03 v2(82.3,72.72)
PEX_PLL_CLK_OUT: length 1.4
  TOP w0.102: v2(58,65.26) 57.32,65.26 RV4.2
  BOTTOM w0.102: UV1.AF22 58.4,64.88 58.02,65.26 v2(58,65.26)
PEX_PLL_CLK_OUT#: length 1.3
  TOP w0.102: v2(58,65.97) 57.42,65.97 RV4.1
  BOTTOM w0.102: v2(58,65.97) 58.38,65.6 UV1.AE22
PEX_PLLVDD_GPU: length 1.5
  BOTTOM w0.254: v2(63.77,69.35) 64.16,68.96 UV1.AA15 UV1.AA14
  vias: v1(63.24,69.46)
PEX_TERMP: length 2.3
  TOP w0.076: RV6.1 v1(54.48,65.15)
  TOP w0.102: v2(55.46,64.41) RV6.1
  BOTTOM w0.102: UV1.AF25 55.85,64.8 v2(55.46,64.41)
PHASE_CHG: length 7.3
  IN3 w1.016: 43.62,25.9 43.94,25.9 46.92,22.91 46.92,20.12
  vias: v1(41.9,28.82) v2(42.73,26.28) v2(42.73,25.65) v2(46.79,17.14) v2(46.79,16.5)
PLT_RST#_R: length 4.3
  TOP w0.102: v2(184.74,67.21) 185.31,67.21 v1(185.51,67.02) 185.6,66.92 RM6.1
  BOTTOM w0.102: JNGFF.44 185.23,66.98 184.99,67.21 v2(184.74,67.21)
PLT_RST_VGA#: length 29.2
  TOP w0.102: QV4.2 80.12,75.41 v2(80.21,75.33)
  IN1 w0.089: v2(70.35,66.81) 70.78,67.24 75.24,67.24 75.38,67.38 v2(78.8,67.38)
  IN3 w0.102: v2(80.21,75.33) 80.21,71.82 80,71.62 80,68.59 v2(78.8,67.38)
  BOTTOM w0.102: v2(70.35,66.81) 70.74,67.2 UV1.AC7 ; v2(78.8,67.38) 78.87,67.38 RV9.2 RV66.1 79.5,65.03 80.72,63.81 83.43,63.81 83.78,64.16 UV13.4 ; QV2.2 80.46,75.58 v2(80.21,75.33) 79.95,75.58 QV2.5
PLT_RST_VGA_HOLD#: length 37.8
  TOP w0.102: v2(72.91,84.22) 73.29,84.6 73.29,85.36 73.67,85.74 74.75,85.74 75.19,85.3 75.19,85.17 79.46,80.9 86.68,80.9 87.56,80.03 v1(87.56,78.27) 87.23,77.94 86.12,77.94 85.56,78.51 RPV7.2 84.71,78.51 84.59,78.38 84.59,77.46 85.46,76.59 v2(85.95,76.59)
  BOTTOM w0.102: v2(72.91,84.22) 73.3,83.82 UV1.C4 ; v2(85.95,76.59) 85.18,75.82 85.18,70.85 83.13,68.79 UV13.2
PLT_RST_VGA_MON#: length 51.7
  TOP w0.102: v2(86.8,77) 86.72,77.08 85.65,77.08 85.1,77.63 RPV7.1 85.36,78.01 85.91,77.46 87.43,77.46 88.51,78.54 v1(88.51,80.95) 88.07,81.4 87.24,81.4 86.66,81.98 UV12.4 85.43,81.98 85.29,82.12 85.29,82.81 84.29,83.81 82.35,83.81 81.78,84.38 80.57,84.38 80.26,84.7 79.43,84.7 76.96,87.18 72.13,87.18 70.99,86.03 70.99,84.95 70.54,84.51 69.4,84.51 68.66,83.77 v2(68.66,82.6)
  BOTTOM w0.102: UV1.E9 69.06,82.2 v2(68.66,82.6) ; UV13.1 82.48,66.38 82.23,66.12 81.05,66.12 RV9.1 84.7,71.05 84.7,76.06 85.64,77 v2(86.8,77)
PM_MSM#: length 1.5
  TOP w0.076: v2(119.72,84.67) 119.72,85.11 T230.1
  BOTTOM w0.076: v2(119.72,84.67) 119.75,84.69 UC1.AP56
PM_ZVM#: length 1.6
  TOP w0.076: v2(119.72,84.04) 119.66,84.04 T225.1
  BOTTOM w0.076: UC1.AR56 119.75,84.06 v2(119.72,84.04)
PME#: length 1.1
  TOP w0.076: v2(145.33,83.37) 145.53,83.37 T91.1
  BOTTOM w0.102: v2(145.33,83.37) 145.51,83.37 UC1.AU11
POK: length 238.5
  TOP w0.102: 156.27,66.73 155.82,67.17 UC11.2 154.18,67.17 CC142.1 RC95.2 ; 156.27,66.73 156.71,67.17 157.71,67.17 RC55.2 ; 156.27,66.73 156.27,65.76 RC112.2 156.27,65.02 156.27,64.13 155.89,63.75 v1(155.89,58.86) v2(156.27,58.47)
  TOP w0.254: PR113.2 60.25,28.49 v2(60.25,28.95)
  IN1 w0.254: v2(60.25,28.95) 59.56,29.65 56,29.65 55.24,28.88 55.24,22.98 57.33,20.88 57.33,20.18 59.43,18.09 60.7,18.09 61.02,17.77 61.02,16.56 60.45,15.99 v2(59.62,15.99)
  IN2 w0.254: v2(156.27,58.47) 156.27,54.35 158.43,52.19 164.92,52.19 167.13,49.99 167.13,46.98 167.89,46.22 169.76,44.35 v2(169.89,44.35)
  IN3 w0.102: v2(60.25,28.95) 60.64,28.57 62.54,28.57 62.92,28.95 62.92,31.17 63.81,32.06 76.94,32.06 79.75,29.25 79.75,28.38 v2(80.32,27.8)
  IN3 w0.254: v2(64.83,19.45) 61.37,15.99 v2(59.62,15.99)
  BOTTOM w0.102: v2(60.25,28.95) 59.3,29.9 59.3,31.04 60.7,32.44 80.38,32.44 88.35,40.41 88.35,49.86 91.19,52.71 91.19,57.71 92.7,59.22 99.53,59.22 100.28,58.47 v2(156.27,58.47)
  BOTTOM w0.254: v2(169.89,44.35) 169.93,44.31 169.93,43.21 176.45,36.69 179.79,36.69 180.75,37.65 182.4,37.65 182.99,38.24 182.99,40.43 PR315.1 ; v2(60.25,28.95) 60.66,28.54 60.66,27.65 60.86,27.45 PU102.9 ; v2(59.62,15.99) 59.91,15.71 PU100.9 ; PR507.1 80.78,27.35 v2(80.32,27.8) ; PR107.2 v2(64.83,19.45)
POWER_SW#_MB: length 156.7
  TOP w0.102: SW1.4 175.72,116.87 v2(175.7,116.84) 172.31,116.84 SW1.3 ; v2(156.13,11.1) 156.13,10.08 154.49,8.44 v3(154.49,7.87) 154.49,7.66 RE378.2
  IN1 w0.102: v2(156.13,11.1) 156.35,10.89 163.33,10.89 165,12.57 165,13.49 169.39,17.87 174.03,17.87 183.67,27.51 183.67,28.75 185.72,30.79 185.72,36.51 188.42,39.21 188.42,42.44 188.97,42.99 188.97,54.07 187.06,55.97 187.06,60.17 186.59,60.64 186.59,68.98 186.01,69.56 186.01,76.69 177.29,85.42 177.29,93.48 172.45,98.31 172.45,99.26 168.84,102.86 168.84,113.72 171.96,116.84 v2(175.7,116.84)
  BOTTOM w0.102: CE20.1 173.5,121.1 175.72,118.88 DE2.3 175.72,116.87 v2(175.7,116.84)
POWER_SW_IN#: length 11.2
  TOP w0.102: UE5.127 144.6,4.84 144.83,5.07 147.77,5.07 147.82,5.12 150.42,5.12 150.72,4.82 v1(150.95,4.82) 151.2,4.82 151.38,5 152.03,5 152.2,4.82 CE79.1 RE376.2 RE378.1
PRIMCORE_VID0: length 2.9
  TOP w0.076: v2(145.33,85.31) 145.61,85.59 147.06,85.59 T130.1
  BOTTOM w0.076: UC1.AN11 145.72,85.7 v2(145.33,85.31)
PRIMCORE_VID1: length 1.3
  TOP w0.076: T131.1 144.27,85.01 v2(144.41,85.16)
  BOTTOM w0.076: v2(144.41,85.16) 144.87,85.62 UC1.AN13
PROG: length 5
  BOTTOM w0.203: PR753.2 41.54,8.58 41.97,9.01 41.97,10.02 v1(42.54,10.6) 42.98,11.04 42.98,11.68 43.23,11.92 PU703.9
PROJECT_ID1: length 57.2
  BOTTOM w0.076: 148.15,78.87 147.49,79.53 147.49,81.33 UC1.AY8
  BOTTOM w0.102: RC319.1 RC314.2 166.49,95.7 167.43,95.7 168.4,94.73 v1(168.4,94.1) 168.4,93.26 174.85,86.81 174.85,79.02 171.84,76.01 168.27,76.01 167.37,75.12 163.94,75.12 163.32,74.5 162.98,74.5 161.92,73.44 159.73,73.44 158.98,74.18 154.97,74.18 154.11,75.05 153.09,75.05 151.74,76.4 151.22,76.4 148.83,78.79 148.23,78.79 148.15,78.87
PROJECT_ID2: length 53.3
  BOTTOM w0.076: 150.71,77.24 148.96,78.99 148.39,78.99 147.69,79.68 147.69,80.88 UC1.BA8
  BOTTOM w0.102: RC315.1 RC318.2 166.54,93.84 167.49,93.84 174.52,86.82 v1(174.52,83.18) 174.52,79.02 171.74,76.24 168.17,76.24 167.28,75.35 163.84,75.35 163.22,74.73 161.79,74.73 161.22,74.16 159.44,74.16 159.19,74.41 155.07,74.41 154.21,75.27 153.19,75.27 151.83,76.63 151.32,76.63 150.71,77.24
PS_ID: length 181.5
  TOP w0.102: v2(143.57,18.03) 143.8,18.26 UE5.36
  TOP w0.254: PR4.2 PR3.1 v1(26.73,99.69) 27.92,98.51 27.92,94.85 27.62,94.54 27.62,63.98 29.01,62.59 29.01,53.35 v2(30.78,51.58)
  IN2 w0.102: v2(30.78,51.58) 31.38,50.98 32.84,50.98 40.76,43.06 43.3,43.06 53.7,32.66 96.1,32.66 105.8,22.95 126.53,22.95 129.56,19.93 132.52,19.93 133.28,19.17 142.42,19.17 v2(143.57,18.03)
PSID: length 6.4
  TOP w0.508: v2(21.08,106.48) 20.67,106.08 PL2.2
  IN3 w0.508: v2(22.66,110.8) 21.65,110.8 21.08,110.23 v2(21.08,106.48)
  vias: v3(23.17,111.24)
PSID-1: length 4
  TOP w0.102: v1(21.76,98.29) PQ5.2
  TOP w0.508: PR6.1 PR9.2 21.47,100 PQ5.2
PSID-2: length 8.1
  TOP w0.102: v1(23.93,98.67) 22.98,98.67 22.41,99.24 PQ5.1
  TOP w0.508: PR8.2 24.1,101.31 PQ5.1 21.95,101.77 PQ6.2
PSID-3: length 3.1
  TOP w0.102: PR4.1 26.12,103.38 v1(26.72,102.79)
  TOP w0.508: PQ6.3 23.91,103.38 PR4.1
PTP_DIS#: length 143
  TOP w0.102: DE4.1 22.99,65.14 26.68,65.14 v1(27.06,64.76) 27.06,64.11 27.87,63.3 27.87,62.22 28.7,61.4 v2(28.7,51.68) ; RE367.1 124.53,7.52 RE362.1 122.99,8.37 v2(122.93,8.44)
  IN1 w0.102: v2(117.15,15.04) 112.11,15.04 107.03,20.12 106.79,20.12 94.77,32.15 52.79,32.15 51.36,33.58 51.36,34.47 44.1,41.74 38.64,41.74 v2(28.7,51.68)
  BOTTOM w0.102: v2(117.15,15.04) 117.15,7.46 120.3,4.31 121.79,4.31 122.55,5.07 122.55,6.28 123.31,7.04 123.31,8.06 v2(122.93,8.44)
PTP_DIS#_R: length 7
  TOP w0.102: RE362.2 125.12,7.84 127.31,7.84 127.76,7.4 129.19,7.4 v1(129.31,7.52) 129.54,7.75 UE5.90
PWM1_GT: length 31.8
  IN1 w0.254: v2(75.23,111.24) 77.07,113.08 83.05,113.08 83.81,112.32 85.81,112.32 v2(85.92,112.44)
  BOTTOM w0.102: v2(75.23,111.24) v1(75.23,110.42) 75.23,109.99 76.76,108.45 76.76,104.51 78.1,103.18 78.1,98.86 79.11,97.84 81.3,97.84 82.14,98.68 PU605.13
  BOTTOM w0.203: PU602.12 v2(85.92,112.44)
PWM_IA: length 20
  TOP w0.102: v2(101.72,112.77) v1(102.36,112.77)
  IN1 w0.254: v2(101.72,112.77) 101.28,112.77 99.05,114.99 96.29,114.99 93.62,117.66 92.26,117.66 92.08,117.48 91.45,117.48 90.89,116.92 87.85,116.92 87.37,117.4 v2(87.37,117.47)
  BOTTOM w0.203: PU602.22 87.96,116.81 87.37,117.4 v2(87.37,117.47)
  BOTTOM w0.254: PU603.13 102.33,113.19 101.91,112.77 v2(101.72,112.77)
PWM_VSA: length 61
  IN2 w0.254: v2(144.03,114.74) 142.93,115.83 142.93,116.67 142.17,117.43 122.4,117.43 121.02,118.8 113.23,118.8 110.24,115.82 105.28,115.82 104.7,116.39 97.85,116.39 97.02,117.21 93.59,117.21 92.89,116.51 91.94,116.51 v2(91.81,116.64)
  BOTTOM w0.203: v2(91.81,116.64) 91.75,116.7 91.18,116.7 91.16,116.68 PU602.30
  BOTTOM w0.254: v2(144.03,114.74) 144.73,115.43 v1(145.22,115.43) 145.66,115.43 146.43,114.67 PU606.3
REFADJ: length 3.9
  BOTTOM w0.102: PR805.1 76.56,46.08 v1(76.38,45.9)
  BOTTOM w0.203: PR805.1 77.48,46 77.48,43.76 77.41,43.69 PU801.6
REFIN_VGA: length 6.3
  BOTTOM w0.102: PR808.1 79.39,44.33 v1(79.62,44.57)
  BOTTOM w0.203: PU801.7 77.65,43.29 78.1,43.74 78.1,43.91 PR808.1
  BOTTOM w0.254: PR808.1 77.97,44.88 77.97,46.54 PR807.2
REMOTE1+: length 86.5
  TOP w0.254: v2(156.27,5.9) 156.14,6.02 C2502.1 156.47,6.92 U2407.2
  IN1 w0.254: v2(156.27,5.9) 156.34,5.97 156.34,6.38 155.55,7.17 154.24,7.17 152.63,5.56 143.44,5.56 142.48,6.52 137.59,6.52 136.56,7.55 131.1,7.55 129.96,8.69 127.74,8.69 126.38,10.05 124.53,10.05 123.44,11.15 123.44,11.85 123.1,12.18 110.04,12.18 108.07,14.15 108.07,14.6 106.93,15.74 106.93,17.69 99.39,25.22 95.67,25.22 95.15,25.74 95.15,26.58 v2(95.65,27.08)
  BOTTOM w0.254: v2(95.65,27.08) 95.7,27.08 96.2,27.57 v1(96.2,31.04) 96.2,32.06 Q2407.1 94.97,33.28 Q2407.2 95.17,34.72 C2500.1
REMOTE1-: length 86.1
  TOP w0.254: v2(156.91,5.9) 157.05,6.04 C2502.2 156.97,6.68 U2407.3
  IN1 w0.254: v2(96.06,26.66) 95.95,26.66 95.66,26.37 95.66,25.95 95.88,25.73 99.6,25.73 107.44,17.9 107.44,15.95 108.58,14.81 108.58,14.36 110.25,12.69 123.31,12.69 123.95,12.06 123.95,11.36 124.75,10.56 126.59,10.56 127.95,9.2 130.17,9.2 131.31,8.06 136.77,8.06 137.8,7.03 142.69,7.03 143.65,6.07 152.42,6.07 154.03,7.67 155.76,7.67 156.84,6.59 156.84,5.97 v2(156.91,5.9)
  BOTTOM w0.254: v2(96.06,26.66) 96.06,26.72 96.7,27.36 v1(96.7,29.58) 96.7,34.1 Q2407.3 96.27,35.61 C2500.2
REMOTE2+: length 111.8
  TOP w0.254: U2407.4 157.47,7.24 157.92,6.79 C2504.1 157.92,6.09 158.12,5.88 158.12,5.42 158.67,4.87 159.59,4.87 161.09,6.37 161.09,13.92 160.54,14.47 160.05,14.47 v2(160.01,14.51)
  IN1 w0.254: v2(172.85,79.66) 172.87,79.65 172.87,78.11 173.86,77.12 173.86,71.94 174.49,71.3 174.49,65.96 173.6,65.07 173.6,61.49 171.95,59.84 171.95,58.1 170.99,57.14 170.99,37.53 172.96,35.56 172.96,34.4 171.95,33.39 171.95,28.61 171.44,28.1 171.44,24.01 161.9,14.47 160.05,14.47 v2(160.01,14.51)
  BOTTOM w0.254: Q2408.2 157.9,85.83 Q2408.1 159.18,86.48 C2505.1 160.47,86.86 166.91,86.86 170.24,83.54 170.24,81.14 171.67,79.7 172.82,79.7 v2(172.85,79.66)
REMOTE2-: length 110.7
  TOP w0.254: v2(160.01,13.92) 160.05,13.96 160.33,13.96 160.58,13.71 160.58,6.58 159.38,5.37 158.88,5.37 158.63,5.63 158.63,5.88 158.83,6.09 C2504.2 158.83,6.63 157.97,7.5 U2407.5
  IN1 w0.254: v2(160.01,13.92) 160.05,13.96 162.11,13.96 171.95,23.8 171.95,27.89 172.46,28.4 172.46,33.18 173.47,34.19 173.47,35.77 171.5,37.74 171.5,56.93 172.46,57.89 172.46,59.63 174.11,61.28 174.11,64.86 175,65.75 175,71.51 174.36,72.15 174.36,77.33 173.37,78.32 173.37,79.86 172.97,80.27 172.87,80.27 v2(172.85,80.25)
  BOTTOM w0.254: v2(172.85,80.25) 172.82,80.21 171.88,80.21 170.74,81.35 170.74,83.75 167.13,87.37 160.26,87.37 159.83,86.94 C2505.2 159.44,87.13 Q2408.3
RESET_OUT#: length 128.6
  TOP w0.102: RPC11.1 158.54,64.65 158.24,64.95 157.84,64.95 v2(157.44,65.35) ; CE88.1 RE355.1 131.63,21.71 131.18,21.26 v2(130.53,21.26) v3(130.53,20.69) 130.53,20.27 131.37,19.42 131.37,18.66 131.72,18.32 132.1,18.32 133.12,17.3 133.24,17.3 133.62,16.92 133.62,16.92 134.3,16.25 134.3,13.5 133.87,13.07 133.22,13.07 131.75,14.55 UE5.73
  IN1 w0.089: v2(130.53,21.26) 130.53,20.75 131.65,19.63 134.76,19.63 135.33,20.2 135.33,20.97 135.56,21.2 135.95,21.2 136.59,20.57 136.79,20.57 137.55,21.32 139.6,21.32 141.09,19.83 146.26,19.83 148.35,21.92 157.75,21.92 162.28,26.45 162.28,35.63 162.96,36.32 162.96,44.33 162.5,44.79 162.5,49.85 159.09,53.25 159.09,59.72 160.39,61.01 160.39,61.6 160.24,61.75 160.24,63.71 159.25,64.7 158.08,64.7 157.44,65.34 157.44,65.35 v2(157.44,65.35)
  BOTTOM w0.076: UC1.BA20 141.39,80.38 141.39,79.69 141.32,79.62 141.32,79.24 141.57,78.99 141.57,77.96
  BOTTOM w0.102: v2(157.44,65.35) 157.04,65.35 156.05,64.35 154.83,64.35 154.43,64.76 154.43,65.84 153.18,67.09 145.95,67.09 143.09,69.94 143.09,74.44 142.42,75.11 142.42,77.11 141.57,77.96
RING2: length 14.3
  IN3 w1.016: 190.94,18.22 190.87,18.28 190.87,19.99 192.44,21.56 192.44,22.86 190.98,24.32 190.98,29.1 190.56,29.52
  BOTTOM w0.203: UA1.17 192.75,18.89 192.33,18.47 v2(192.33,18.28)
  vias: v2(190.49,30.41) v2(190.62,31.04) v2(191.89,17.83)
RING2_R: length 12.5
  IN3 w1.016: 199.83,37.58 199.83,36.5 198.37,35.04 197.03,35.04 196.4,34.41 196.4,32.69
  BOTTOM w0.508: LA10.1 192.52,31.55 192.72,31.75 CA40.1 194.54,31.75 194.82,31.47 DA12.2 v2(196.53,31.47) v2(197.29,31.47)
ROM_SCLK: length 5.3
  TOP w0.102: RV80.2 RV63.1 69.14,85.35 v1(69.14,84.83) 67.73,83.41 v2(67.03,83.41)
  BOTTOM w0.102: UV1.C12 v2(67.03,83.41)
ROM_SI: length 5.7
  TOP w0.102: v2(67.05,84.23) 67.42,84.23 RV65.1 68.67,85.48 v1(68.67,87.47) 68.89,87.68 RV84.2
  BOTTOM w0.102: UV1.B12 66.68,84.6 v2(67.05,84.23)
ROM_SO: length 9.8
  BOTTOM w0.102: UV1.A12 v1(66.64,88.48) 68.64,90.48 71.08,90.48 RV64.1 RV81.2
RTC_DET#: length 290.2
  TOP w0.102: v2(33.08,17.01) 32.76,16.69 32.76,13.01 34.7,11.07 QC4.1
  IN1 w0.102: v2(156.58,98.61) 158.04,100.07 161.5,100.07 162.45,99.11 165.74,99.11 173.11,91.74 173.11,82.97 174.44,81.64 174.44,78.81 176.07,77.19 176.07,65.26 175.24,64.43 175.24,60.81 174.68,60.25 174.68,58.59 172.23,56.14 172.05,56.14 171.93,56.02 171.93,37.92 174.45,35.4 174.45,27 172.97,25.52 172.97,24.2 162.21,13.45 161.89,13.45 161.49,13.05 154.7,13.05 153.19,14.56 147.54,14.56 146.68,13.69 140.68,13.69 140.52,13.53 135,13.53 133.68,14.85 132.07,14.85 130.39,16.53 129.39,16.53 128.88,17.03 128.4,17.03 127.03,18.41 123.32,18.41 122.99,18.74 111.19,18.74 110.03,19.9 110.03,21.4 108.19,23.23 106.33,23.23 95.45,34.11 84,34.11 83.17,34.94 80.97,34.94 80.14,34.11 54.27,34.11 v2(53.84,34.54)
  IN3 w0.102: v2(33.08,17.01) 35.16,17.01 38.09,14.08 40.07,14.08 42.74,11.41 46.16,11.41 46.84,10.72 47.62,10.72 48.39,9.95 48.93,9.95 53.84,14.86 v2(53.84,34.54)
  BOTTOM w0.076: 154.87,98.91 154.41,98.91 153.6,98.1 v1(153.6,97.65) 153.6,97.4 153.47,97.27 153.47,96.09 152.51,95.13 UC1.P1
  BOTTOM w0.102: v2(156.58,98.61) RC233.1 156.14,98.91 154.87,98.91
RTCRST_ON: length 81.7
  TOP w0.102: RC121.1 147.16,68.61 147.34,68.61 148.55,67.4 QC1.2 148.57,67.12 149.47,66.22 151.63,66.22 153.54,64.32 v1(153.54,60.51) 153.54,59.05 157.73,54.86 163.6,54.86 v2(164.39,55.65) ; UE5.31 147.69,17.35 147.79,17.44 v2(148.46,17.44)
  IN1 w0.089: v2(148.46,17.44) 150.34,17.44 151.39,18.5 154.65,18.5 154.99,18.84 159.58,18.84 160.96,20.22 161.87,20.22 166.56,24.91 166.56,37.02 166.8,37.25 166.8,45.54 166.09,46.24 166.09,52.46 164.39,54.16 v2(164.39,55.65)
RUNPWROK: length 4.4
  TOP w0.102: UE5.48 139,20.24 138.71,20.53 138.71,20.88 v1(138.72,20.88) 138.93,20.88 138.99,20.95 138.99,21.26 138.93,21.33 137.79,21.33 137.72,21.39 137.72,21.7 137.85,21.82 RE381.1
SA_SNUB: length 1.2
  TOP w0.102: PC622.1 v1(148.96,118.55)
SA_SW: length 64.9
  IN2 w0.254: v2(156.01,119.82) 155.5,120.32 145.66,120.32 145.34,120.01 145.34,119.07 144.57,118.29 122.84,118.29 121.51,119.63 99.24,119.63 98.55,118.93 v2(98.55,118.48)
  BOTTOM w0.254: v2(98.55,118.48) 97.85,118.48 PR624.1 ; v2(156.01,119.82) 156.2,119.63 156.2,118.1 155.82,117.72 PL601.1
  vias: v1(152.14,117.97) v2(149.79,113.59) v2(153.92,115.94) v2(154.55,115.94)
SATA3_PRX_HDDTX_N0: length 137.2
  TOP w0.089: CS33.1 190.15,12.22 190.57,12.22 v2(190.81,11.98)
  IN3 w0.089: v2(190.81,11.98) 190.11,11.98 189.73,12.36 189.73,14.79 185.6,18.91 185.6,24.05 186.18,24.62 186.18,37.28 188.64,39.75 188.64,42.86 189.3,43.52 189.3,46.19 188.54,46.95 188.54,48.85 189.27,49.58 189.27,66.2 192.45,69.39 192.45,74.86 185.93,81.38 180.72,81.38 171.06,91.03 171.06,92.43 166.28,97.21 162.54,97.21 160.71,99.04 160.71,99.92 158.47,102.16 156.33,102.16 155.7,102.8 151.95,102.8 151.63,102.48 147.38,102.48 147,102.1 142.42,102.1 141.31,100.98 141.31,100.03 v2(140.75,99.48)
  BOTTOM w0.076: UC1.F20 v2(140.75,99.48)
SATA3_PRX_HDDTX_P0: length 137.3
  TOP w0.089: v2(190.81,12.56) 190.65,12.4 190.15,12.4 CS35.1
  IN3 w0.089: v2(190.81,12.56) 190.42,12.17 190.19,12.17 189.92,12.44 189.92,14.87 185.79,18.99 185.79,23.97 186.37,24.54 186.37,37.2 188.83,39.67 188.83,42.78 189.49,43.44 189.49,46.27 188.73,47.03 188.73,48.77 189.46,49.5 189.46,66.13 192.64,69.31 192.64,74.94 186,81.57 180.8,81.57 171.25,91.11 171.25,92.51 166.36,97.4 162.62,97.4 160.9,99.11 160.9,100 158.55,102.35 156.41,102.35 155.77,102.99 151.87,102.99 151.55,102.67 147.3,102.67 146.92,102.29 142.34,102.29 141.12,101.06 141.12,100.11 141.01,100 140.87,100 v2(140.75,100.11)
  BOTTOM w0.076: UC1.E20 v2(140.75,100.11)
SATA3_PTX_HDDRX_N0: length 140
  TOP w0.089: v2(190.81,10.86) 190.57,10.63 190.15,10.63 CS36.1
  IN3 w0.089: v2(139.45,103.29) 139.63,103.11 139.63,102.91 139.87,102.67 145.09,102.67 146.23,103.81 148.22,103.81 148.31,103.9 156.04,103.9 156.15,103.79 157.8,103.79 163.24,98.35 165.97,98.35 180.25,84.07 184.84,84.07 190.34,78.56 190.34,77.79 193.03,75.1 193.03,69.14 189.85,65.96 189.85,49.21 189.12,48.48 189.12,47.2 189.88,46.43 189.88,43.27 189.22,42.61 189.22,39.44 186.87,37.09 186.87,24.24 186.24,23.6 186.24,19.17 191.26,14.15 191.26,10.8 191.11,10.66 191.01,10.66 v2(190.81,10.86)
  BOTTOM w0.076: v2(139.45,103.29) 139.46,103.27 139.46,102.76 139.66,102.57 UC1.B21
SATA3_PTX_HDDRX_P0: length 140
  TOP w0.089: CS37.1 190.15,10.44 190.65,10.44 v2(190.81,10.28)
  IN3 w0.089: v2(140.03,103.29) 139.93,103.29 139.82,103.18 139.82,102.99 139.95,102.86 145.01,102.86 146.15,104 148.14,104 148.23,104.09 156.11,104.09 156.23,103.98 157.88,103.98 163.32,98.54 166.05,98.54 180.33,84.26 184.92,84.26 190.53,78.64 190.53,77.87 193.22,75.18 193.22,69.06 190.04,65.88 190.04,49.13 189.31,48.4 189.31,47.28 190.07,46.51 190.07,43.19 189.41,42.53 189.41,39.36 187.06,37.01 187.06,24.16 186.43,23.52 186.43,19.25 191.45,14.23 191.45,10.72 191.19,10.47 191,10.47 v2(190.81,10.28)
  BOTTOM w0.076: v2(140.03,103.29) 139.95,103.29 139.64,102.97 139.64,102.84 139.86,102.61 UC1.A21
SATA_LED#: length 295.1
  TOP w0.102: R2455.1 151.09,20.86 v2(151.82,20.86) 152.38,21.42 154.07,21.42 156.27,23.61 172.13,23.61 v2(173.86,25.34) ; 15.55,41.84 15.55,42.09 15.87,42.41 16.95,42.41 17.33,42.79 17.33,48.06 20.28,51.01 30.89,51.01 31.3,51.42 v1(31.3,52.95) 31.3,54.32 31.3,54.32 v2(31.3,55.49)
  IN1 w0.076: 154.87,101.78 154.69,101.78 v2(154.16,102.31)
  IN1 w0.102: v2(31.3,55.49) 41.26,45.53 45.19,45.53 54.7,36.02 80.1,36.02 80.71,36.63 99.25,36.63 104.02,31.86 104.02,28.83 107.29,25.56 109.18,25.56 112.67,22.06 127.03,22.06 128.45,20.64 129.65,20.64 131.95,18.34 132.39,18.34 133,18.95 136.03,18.95 137.28,17.71 137.6,17.71 137.98,18.09 138.36,18.09 139.18,18.91 146.58,18.91 148.54,20.86 v2(151.82,20.86) ; v2(173.86,25.34) 174.68,26.17 174.68,35.49 172.16,38.01 172.16,53.23 172.83,53.9 172.83,56.06 175.16,58.4 175.16,59.83 175.72,60.39 175.72,64.26 176.57,65.11 176.57,77.38 174.9,79.06 174.9,81.83 173.58,83.15 173.58,91.96 165.94,99.6 162.62,99.6 160.43,101.78 154.87,101.78
  BOTTOM w0.076: 154.87,103.58 154.87,103.19 154.16,102.48 v2(154.16,102.31) 154.16,100.46 152.76,99.05 152.52,99.05 151.91,98.44 UC1.H1
  BOTTOM w0.102: 154.87,103.58 155.17,103.88 155.17,104.45 RC199.1
SATA_LED#_R: length 9.4
  TOP w0.102: UE5.30 148.65,16.95 148.96,17.26 148.96,17.58 v1(148.53,18.01) 148.51,18.04 148.51,19.36 R2455.2 150.56,21.42 151.64,21.42 R2460.2
SATA_PRX_DTX_N0: length 7.2
  TOP w0.089: v2(178.32,13.07) 178.52,12.87 178.52,12.7 178.91,12.31 179.67,12.31 CS31.2
  BOTTOM w0.089: JHDD.2 181.53,13.46 181.36,13.64 180.85,13.64 180.27,14.22 178.74,14.22 178.32,13.8 v2(178.32,13.07)
SATA_PRX_DTX_N0_R: length 2.9
  TOP w0.089: CS31.1 180.93,12.52 181.41,12.52 181.45,12.49 182.1,12.49 182.13,12.52 182.42,12.52 182.58,12.37 US2.12
SATA_PRX_DTX_N0_RC: length 2.1
  TOP w0.089: US2.4 187.69,12.37 187.85,12.52 187.92,12.52 188.26,12.19 188.56,12.19 CS33.2
SATA_PRX_DTX_P0: length 7.3
  TOP w0.089: CS34.2 179.74,13.02 179.21,12.5 178.98,12.5 178.71,12.77 178.71,12.87 v2(178.91,13.07)
  BOTTOM w0.089: v2(178.91,13.07) 178.51,13.47 178.51,13.73 178.82,14.03 179.25,14.03 179.28,14 v4(179.51,14) 179.73,14 179.76,14.03 180.19,14.03 180.77,13.45 181.28,13.45 181.35,13.38 181.35,13.18 181.24,13.07 180.84,13.07 180.73,12.96 JHDD.1
SATA_PRX_DTX_P0_R: length 2.9
  TOP w0.089: CS34.1 181.08,12.71 v4(181.75,12.71) 182.42,12.71 182.58,12.87 US2.11
SATA_PRX_DTX_P0_RC: length 2.1
  TOP w0.089: CS35.2 188.5,12.37 188.33,12.37 188,12.71 187.76,12.71 187.61,12.87 US2.5
SATA_PTX_DRX_N0: length 9.9
  TOP w0.089: v2(178.08,11.67) 178.28,11.47 178.63,11.47 179.22,10.88 179.49,10.88 CS32.2
  BOTTOM w0.089: v2(178.08,11.67) 178.27,11.48 178.39,11.48 178.69,11.78 180.18,11.78 180.92,11.04 183.18,11.04 183.62,11.48 183.62,11.82 183.51,11.93 183.22,11.93 183.13,12.01 JHDD.4
SATA_PTX_DRX_N0_R: length 2.4
  TOP w0.089: US2.2 187.63,11.37 187.76,11.23 188.08,11.23 188.27,11.04 188.27,10.72 188.4,10.6 188.5,10.6 CS36.2
SATA_PTX_DRX_N0_RC: length 2.9
  TOP w0.089: US2.14 182.69,11.37 182.53,11.21 182.33,11.21 182.06,10.94 v4(181.78,10.94) 181.5,10.94 181.47,10.91 181.08,10.91 CS32.1
SATA_PTX_DRX_P0: length 9.9
  TOP w0.089: v2(178.08,11.09) 178.28,11.29 178.55,11.29 179.15,10.69 179.49,10.69 CS30.2
  BOTTOM w0.089: v2(178.08,11.09) 178.3,11.3 178.47,11.3 178.77,11.6 180.1,11.6 180.84,10.85 183.26,10.85 183.81,11.4 183.81,11.89 183.93,12.02 JHDD.5
SATA_PTX_DRX_P0_R: length 2.4
  TOP w0.089: US2.1 187.65,10.87 187.83,11.05 188,11.05 188.09,10.96 188.09,10.65 188.32,10.41 188.56,10.41 CS37.2
SATA_PTX_DRX_P0_RC: length 2.9
  TOP w0.089: US2.15 182.71,10.87 182.56,11.02 182.41,11.02 182.11,10.72 181.13,10.72 CS30.1
SD_RCOMP: length 1.3
  TOP w0.254: v2(148.46,91.94) 148.46,92.41 RC76.2
  BOTTOM w0.254: v2(148.46,91.94) 148.46,91.7 UC1.AB7
SERIRQ: length 98.8
  TOP w0.102: v2(136.65,21.07) 136.65,20.63 136.2,20.19 UE5.55 ; RC122.1 157.59,70.74 v2(156.84,71.49)
  IN1 w0.102: v2(136.65,21.07) 137.12,21.54 139.69,21.54 141.18,20.05 146.16,20.05 148.26,22.14 157.66,22.14 162.06,26.54 162.06,35.73 162.74,36.41 162.74,44.24 162.27,44.7 162.27,49.76 158.87,53.16 158.87,59.81 160.17,61.1 160.17,61.51 160.01,61.66 160.01,63.62 159.16,64.47 157.65,64.47 156.81,65.32 156.81,67.58 156.39,68 156.39,68.66 156.84,69.1 v2(156.84,71.49)
  BOTTOM w0.076: UC1.AY11 145.65,80.83 145.54,80.72 145.54,79.78 148.18,77.14 148.18,77.14
  BOTTOM w0.102: v2(156.84,71.49) 155.52,72.81 153.71,72.81 152.35,74.17 v1(151.77,74.17) 151.15,74.17 148.18,77.14
SIO_EXT_SCI#: length 155.6
  TOP w0.076: v1(154.87,102.86) 154.71,102.7 v2(154.71,102.35)
  TOP w0.102: UE5.66 132.37,17.35 132.87,16.84 133.05,16.84 133.59,16.3 v2(133.59,14.36)
  IN1 w0.076: 154.87,102.35 v2(154.71,102.35)
  IN1 w0.102: v2(133.59,14.36) 133.85,14.36 134.9,13.31 140.62,13.31 140.78,13.47 146.77,13.47 147.64,14.33 153.1,14.33 154.61,12.82 161.58,12.82 161.98,13.22 162.31,13.22 174.91,25.82 174.91,35.59 172.39,38.11 172.39,53.14 173.06,53.8 173.06,55.97 175.42,58.33 175.42,59.71 175.95,60.24 175.95,64.16 176.8,65.01 176.8,77.48 175.13,79.15 175.13,81.93 173.81,83.25 173.81,92.05 166.03,99.83 162.71,99.83 160.19,102.35 154.87,102.35
  BOTTOM w0.076: v1(154.87,102.86) 154.71,102.7 v2(154.71,102.35) 154.71,100.77 152.82,98.88 152.62,98.88 151.93,98.19 151.86,98.19 UC1.J2
  BOTTOM w0.102: RC200.1 155.25,103.64 155.25,103.24 v1(154.87,102.86)
SIO_EXT_SMI#: length 148.6
  TOP w0.076: v2(149.09,97.6) 150.04,97.6 150.23,97.4 150.23,96.83 150.55,96.51 v1(151.25,96.51) 151.34,96.6 153.83,96.6 153.98,96.45 154.79,96.45 154.87,96.37
  TOP w0.102: 154.87,96.37 RC222.2 156.32,96.83 RC234.2 ; UE5.10 145.66,8.95 145.27,9.34 143.12,9.34 142.55,9.91 142.55,15.04 v2(143,15.49)
  IN1 w0.076: v2(149.09,97.6) 149.09,95.85 149.86,95.08 150.72,95.08 152.41,93.39 154.55,93.39 154.78,93.16 154.87,93.16
  IN1 w0.102: v2(143,15.49) 143.38,15.1 144.39,15.1 144.76,15.47 146.79,15.47 147.82,16.51 153.33,16.51 155.19,18.37 159.78,18.37 161.16,19.75 162.07,19.75 167.44,25.12 167.44,36.44 167.27,36.61 167.27,45.73 166.57,46.44 166.57,52.66 164.9,54.32 164.9,55.79 166.33,57.22 166.33,60.39 167.28,61.34 167.28,64.65 170.33,67.7 170.33,76.16 169.61,76.87 169.61,84.69 166.13,88.18 158.35,88.18 157.46,87.29 156.82,87.29 155.95,86.41 154.62,86.41 154.17,86.86 152.41,86.86 152.18,87.09 152.18,87.47 153.47,88.76 153.94,88.76 155.38,90.2 155.38,92.77 154.98,93.16 154.87,93.16
  BOTTOM w0.076: UC1.L6 149.09,96.93 v2(149.09,97.6)
SIO_EXT_WAKE#: length 132.5
  TOP w0.102: v2(140.42,15.38) 140.37,15.33 140.37,13.88 140.2,13.72 UE5.116
  IN1 w0.102: v2(140.42,15.38) 140.95,14.85 144.78,14.85 145.17,15.24 146.88,15.24 147.92,16.28 153.42,16.28 155.28,18.14 159.87,18.14 161.25,19.52 163.23,19.52 167.67,23.95 167.67,40.53 168.29,41.16 168.29,42.87 167.5,43.67 167.5,45.83 166.8,46.53 166.8,52.75 165.13,54.41 165.13,55.7 166.55,57.12 166.55,60.29 167.51,61.25 167.51,64.56 170.55,67.6 170.55,76.26 169.84,76.97 169.84,84.79 165.5,89.13 157.71,89.13 157.41,88.83 v2(157.41,87.81)
  BOTTOM w0.076: 154.87,89.4 151.91,89.4 151.87,89.41 151.76,89.53 151.34,89.53 151.05,89.82 UC1.AD3
  BOTTOM w0.102: v2(157.41,87.81) 157.6,87.81 v1(157.98,88.19) 157.98,88.42 157.21,89.2 156.65,89.2 155.94,89.91 RC64.1 155.4,89.93 154.87,89.4
SIO_PWRBTN#: length 91.1
  TOP w0.102: v2(161.72,66.23) 161,66.23 RC109.2 ; RC111.1 151.61,67.05 v2(151.61,69.28) ; UE5.52 137.4,18.16 v2(137.42,18.14)
  IN1 w0.089: v2(161.72,66.23) 162.38,65.57 162.38,61.21 160.45,59.27 160.45,52.86 163.16,50.15 163.16,45.07 163.62,44.6 163.62,36.04 163.55,35.97 163.55,25.88 161.6,23.93 160.69,23.93 158.02,21.26 148.62,21.26 146.49,19.13 139.09,19.13 138.68,18.72 138,18.72 v2(137.42,18.14)
  BOTTOM w0.102: v2(161.72,66.23) 161.02,66.23 160.27,66.98 160.27,69.07 159.22,70.12 158.1,70.12 157.89,70.34 154.93,70.34 154.07,69.47 v1(152.33,69.47) 151.8,69.47 v2(151.61,69.28)
