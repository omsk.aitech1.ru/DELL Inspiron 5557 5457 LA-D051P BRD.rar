# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
KB_LED_BL_DET: length 151.7
  TOP w0.102: RE61.1 RE58.1 124.59,18.6 v1(124.26,18.93) 124.26,20.5 124.14,20.63 v2(124.14,21.2)
  IN1 w0.076: 154.87,85.26 154.23,85.26 154.11,85.39 152.38,85.39 151.31,86.45 151.31,88.81 152.25,89.74 153.59,89.74 154.37,90.53 154.37,92.1 153.91,92.56 152.06,92.56 151.63,93 151.49,93.13 151.01,93.62 148.14,93.62 147.88,93.36 v2(147.88,91.94)
  IN1 w0.102: 154.87,85.26 156.63,85.26 157.48,86.11 157.9,86.11 158.83,87.04 165.18,87.04 168.47,83.74 168.47,76.4 168.83,76.04 168.83,73.26 169.37,72.71 169.37,68.04 166.36,65.03 166.36,61.72 165.41,60.77 165.41,58.82 163.99,57.4 163.99,57.06 163.23,56.3 163.23,53.68 164.93,51.98 164.93,45.76 165.46,45.23 165.46,37.52 165.84,37.14 165.84,27.4 165.51,27.07 165.51,24.86 161.58,20.93 160.67,20.93 159.29,19.55 154.16,19.55 153.82,19.2 149.22,19.2 146.41,16.39 140.09,16.39 139.44,15.73 136.23,15.73 135.82,16.14 135.82,16.5 135.44,16.88 133.64,16.88 133.44,17.07 133.22,17.07 132.58,17.71 131.93,17.71 129.46,20.18 128.26,20.18 127.72,20.73 124.61,20.73 v2(124.14,21.2)
  BOTTOM w0.076: v2(147.88,91.94) 148.07,92.13 UC1.W8
KB_LED_PWM: length 47.9
  TOP w0.102: QE5.3 120.57,22.23 120.41,22.08 120.41,19.24 118.85,17.68 118.85,8.74 v1(118.8,8.69) 119.25,8.25 v2(119.88,8.25) ; v2(139.63,10.18) 139.57,10.24 139.57,17.29 140.6,18.33 UE5.44
  IN3 w0.102: v2(119.88,8.25) 119.88,8.34 120.21,8.67 121.76,8.67 122.46,7.97 123.53,7.97 124.31,8.75 128.84,8.75 129.07,8.53 130.93,8.53 131.27,8.18 135,8.18 136.61,9.79 139.24,9.79 v2(139.63,10.18)
KSI0: length 84.4
  TOP w0.102: RPE1.4 153.21,8.54 v2(152.82,8.16) ; v2(132.45,5.01) 132.86,5.01 133,4.86 UE5.98 ; v2(104.66,11.5) 105.06,11.9 105.06,14.1 104.65,14.51 104.65,17.42 v1(99.09,22.98) 95.24,26.83 95.24,27.75 92.67,30.32 92.67,30.63 92.35,30.95 JKB.22
  IN3 w0.102: v2(104.66,11.5) 104.66,10.07 112.06,2.67 122.02,2.67 122.64,2.05 124.05,2.05 124.69,2.68 130.13,2.68 v2(132.45,5.01) 132.77,5.01 133.6,4.18 136.52,4.18 138.55,6.21 149.98,6.21 151.46,7.7 152.36,7.7 v2(152.82,8.16)
KSI1: length 81.5
  TOP w0.102: v2(104.66,12.09) 104.2,12.55 104.2,17.08 93.36,27.92 v1(93.36,28.84) 92.85,29.35 JKB.24 ; RPE1.3 152.71,8.62 v2(152.24,8.15) ; UE5.99 v2(133.4,5.07)
  IN3 w0.102: v2(152.24,8.15) 151.53,8.15 149.83,6.44 138.46,6.44 136.45,4.44 134.04,4.44 v2(133.4,5.07) 133.02,5.45 132.32,5.45 129.78,2.91 124.59,2.91 123.96,2.28 122.74,2.28 122.11,2.9 112.27,2.9 105.07,10.1 105.07,11.69 104.67,12.09 v2(104.66,12.09)
KSI2: length 77.9
  TOP w0.102: RPE1.2 152.21,8.69 150.86,7.35 UE5.6 145.54,7.35 144.46,8.43 v2(144.46,8.93) ; v2(108.45,7.99) 107.14,7.99 103.64,11.49 v1(103.64,13.45) 103.64,16.99 92.89,27.74 92.76,27.74 JKB.26
  IN3 w0.102: v2(144.46,8.93) 143.87,8.34 137.23,8.34 135.63,6.74 134.95,6.74 134.35,6.14 131.87,6.14 130.1,4.36 124.16,4.36 123.39,3.59 112.6,3.59 108.45,7.74 v2(108.45,7.99)
KSI3: length 80.6
  TOP w0.102: v2(104.64,12.68) 104.6,12.68 104.43,12.86 104.43,17.18 94.89,26.72 v1(94.89,27.55) 94.89,27.78 92.52,30.15 JKB.23 ; v2(145.1,8.93) 145.1,8.51 145.86,7.75 UE5.7 147.43,7.75 147.6,7.58 150.71,7.58 151.71,8.58 RPE1.1
  IN3 w0.102: v2(145.1,8.93) 144.27,8.11 137.33,8.11 135.73,6.51 135.04,6.51 134.45,5.91 131.97,5.91 130.19,4.13 126.1,4.13 125.43,3.46 124.49,3.46 124.17,3.14 123.65,3.14 123.44,3.36 112.46,3.36 107.71,8.11 107.71,12.03 107.37,12.37 104.95,12.37 v2(104.64,12.68)
KSI4: length 59.7
  TOP w0.102: UE5.104 135.4,5.17 v2(135.31,5.26) ; RPE2.4 125.88,5.59 v2(125.84,5.55) ; v2(111.25,7.74) 111.05,7.55 v1(109.28,7.55) 107.26,7.55 103.31,11.5 103.31,16.97 93.33,26.95 JKB.27
  IN1 w0.102: v2(135.31,5.26) 134.6,5.97 130.42,5.97 129.56,5.11 126.28,5.11 v2(125.84,5.55)
  IN3 w0.102: v2(125.84,5.55) 125.42,5.97 123.79,5.97 123.68,5.86 121.32,5.86 121,5.54 118.75,5.54 118.08,6.21 112.13,6.21 111.25,7.1 v2(111.25,7.74)
KSI5: length 62.1
  TOP w0.102: v2(125.15,6.98) 125.91,6.21 126.17,6.21 126.29,6.09 RPE2.3 ; v2(109.02,8.88) v1(107.31,8.88) 106.57,8.88 103.97,11.48 103.97,16.99 92.41,28.55 JKB.25 ; UE5.105 135.8,5.34 v2(135.29,5.86)
  IN1 w0.102: v2(125.15,6.98) 125.15,6.85 126.66,5.34 129.47,5.34 130.33,6.2 134.95,6.2 v2(135.29,5.86)
  IN3 w0.102: v2(109.02,8.88) 110.74,8.88 112.9,6.72 118.21,6.72 118.94,6 120.81,6 121.13,6.32 123.26,6.32 124.14,7.19 124.94,7.19 v2(125.15,6.98)
KSI6: length 61.1
  TOP w0.102: JKB.28 93.8,26.15 102.98,16.97 v1(102.98,15.8) 102.98,11.5 107.28,7.2 111.66,7.2 v2(111.72,7.26) ; v2(136.48,5.07) 136.6,4.95 UE5.107 ; v2(125.85,6.91) 125.98,6.79 126.04,6.79 126.24,6.59 RPE2.2
  IN1 w0.102: v2(125.85,6.91) 127.2,5.57 129.37,5.57 130.23,6.43 135.29,6.43 136.07,5.65 136.07,5.48 v2(136.48,5.07)
  IN3 w0.102: v2(111.72,7.26) 112.52,6.47 118.14,6.47 118.84,5.77 120.91,5.77 121.22,6.09 123.36,6.09 124.22,6.95 124.6,6.95 125.02,6.53 125.47,6.53 v2(125.85,6.91)
KSI7: length 60.7
  TOP w0.102: RPE2.1 126.27,7.09 125.93,7.43 v2(125.53,7.43) ; v2(113.4,7.17) 113.08,6.85 107.31,6.85 102.65,11.51 102.65,16.98 94.28,25.35 v1(93.53,25.35) JKB.29 ; v2(136.48,5.71) 136.89,5.3 136.89,4.81 137,4.69 UE5.108
  IN1 w0.102: v2(125.53,7.43) 125.93,7.43 126.27,7.09 126.88,7.09 127.46,6.51 129.99,6.51 130.14,6.66 135.53,6.66 v2(136.48,5.71)
  IN3 w0.102: v2(125.53,7.43) 125.39,7.57 124.2,7.57 123.17,6.54 121.18,6.54 120.74,6.98 118.34,6.98 118.14,7.17 v2(113.4,7.17)
KSO0: length 94.2
  TOP w0.102: v2(144.14,6.94) 144.14,6.6 144.99,5.75 UE5.2 ; v2(153.35,11.74) 153.21,11.88 RPE3.8 ; JKB.13 93.92,38.15 95.04,37.02 95.04,32.23 98.75,28.52 98.75,27.45 106.58,19.61 v1(106.58,18.79) 106.58,17.63 107.09,17.13 107.09,11.83 v2(107.31,11.61)
  IN3 w0.102: v2(153.35,11.74) 153.35,10.79 150.22,7.66 144.86,7.66 v2(144.14,6.94) 136.48,6.94 135.82,6.28 135.14,6.28 134.54,5.68 132.06,5.68 129.52,3.14 124.5,3.14 124.27,2.91 123.56,2.91 123.34,3.13 112.37,3.13 107.31,8.19 v2(107.31,11.61)
KSO1: length 86.5
  TOP w0.102: RPE3.7 152.71,12.62 152.71,11.87 152.25,11.41 148.88,11.41 148.02,10.55 UE5.14 145.19,10.55 v2(144.47,9.83) ; JKB.15 92.95,36.55 v1(94.15,35.35) 94.58,34.91 94.58,32.04 97.02,29.6 97.02,28.34 106.03,19.34 106.03,17.55 106.52,17.05 106.52,10.56 107.63,9.45 109.09,9.45 109.91,8.63 v2(109.91,7.99)
  IN3 w0.102: v2(144.47,9.83) 143.2,8.56 137.14,8.56 135.54,6.96 134.85,6.96 134.26,6.37 130.89,6.37 129.34,4.82 123.93,4.82 123.16,4.04 119.6,4.04 117.91,5.73 111.43,5.73 109.91,7.25 v2(109.91,7.99)
KSO2: length 86.6
  TOP w0.102: v2(143.89,9.83) 145,10.95 UE5.15 148.1,10.95 148.79,11.64 151.85,11.64 152.21,12 RPE3.6 ; v2(110.55,7.99) 110.55,8.37 109.15,9.77 107.69,9.77 106.84,10.62 106.84,17.06 106.25,17.64 106.25,19.62 97.42,28.46 v1(97.42,28.5) 97.42,29.53 94.81,32.14 94.81,36.78 94.25,37.35 93.34,37.35 JKB.14
  IN3 w0.102: v2(110.55,7.99) 110.55,7.23 111.82,5.96 118.01,5.96 119.24,4.73 121.65,4.73 121.97,5.05 123.75,5.05 123.84,5.13 129.34,5.13 130.8,6.6 134.16,6.6 134.76,7.19 135.44,7.19 137.04,8.79 142.85,8.79 v2(143.89,9.83)
KSO3: length 81.2
  TOP w0.102: RPE3.5 151.71,12.26 151.31,11.87 148.69,11.87 148.18,11.35 UE5.16 145.1,11.35 144.58,11.87 v2(144.58,12.01) ; v2(105.69,13.08) v1(106.11,13.51) 106.29,13.69 106.29,16.96 105.8,17.45 105.8,19.24 96.8,28.24 96.8,29.51 94.35,31.95 94.35,34.41 93.02,35.75 JKB.16
  IN3 w0.102: v2(105.69,13.08) 107.43,13.08 111.31,9.2 116.76,9.2 117.74,10.18 127.13,10.18 128.24,9.07 128.85,9.07 129.17,8.75 131.03,8.75 131.37,8.41 134.91,8.41 137.41,10.91 143.76,10.91 144.58,11.74 v2(144.58,12.01)
KSO4: length 72.4
  TOP w0.102: JKB.20 92.79,32.55 93.44,31.89 93.44,30.24 100.64,23.04 100.64,22.47 103.12,19.99 v1(103.43,19.99) 103.69,19.99 104.53,19.15 104.53,18.33 105.11,17.74 105.11,15.63 105.66,15.09 v2(105.66,14.6) ; RPE4.8 146.67,22.01 146.11,21.45 145.85,21.45 145.55,21.15 144.97,21.15 144.73,20.91 144.41,20.91 144.13,20.63 143.89,20.63 143.4,20.15 UE5.37 143.4,18.44 142.97,18 v2(142.97,17.9)
  IN3 w0.102: v2(142.97,17.9) 141.38,16.31 139.08,16.31 135.89,13.11 133.24,13.11 131.86,11.74 129.15,11.74 128.38,12.51 126.61,12.51 126.13,13 109.61,13 108.58,14.02 106.23,14.02 v2(105.66,14.6)
KSO5: length 69.3
  TOP w0.102: v2(105.07,15) 104.88,15.19 104.88,17.65 99.36,23.17 99.36,23.18 96.92,25.61 v1(96.92,26.03) 96.92,26.39 93.21,30.1 93.21,31.55 93.02,31.75 JKB.21 ; RPE4.7 146.17,22.02 145.85,21.71 145.78,21.71 145.45,21.38 144.88,21.38 144.63,21.14 144.31,21.14 144.03,20.86 143.72,20.86 143,20.15 UE5.38 143,18.47 142.81,18.27 142.69,18.27 v2(142.31,17.9)
  IN3 w0.102: v2(142.31,17.9) 142.3,17.9 141.89,17.49 139.94,17.49 137.63,15.18 129.29,15.18 128.14,14.02 124.58,14.02 124.26,13.71 110.61,13.71 109.31,15 v2(105.07,15)
KSO6: length 70.5
  TOP w0.102: v2(141.73,17.9) 142.15,18.32 142.32,18.32 142.6,18.61 UE5.39 142.6,20.17 143.52,21.09 143.94,21.09 144.22,21.37 144.54,21.37 144.78,21.61 145.24,21.61 145.67,22.03 RPE4.6 ; v2(105.52,15.8) 105.34,15.98 105.34,18.99 103.64,20.69 103.41,20.69 v1(101.34,22.76) 101.15,22.95 101.15,23.18 93.9,30.43 93.9,33.6 93.34,34.15 93.12,34.15 JKB.18
  IN3 w0.102: v2(105.52,15.8) 105.9,15.42 109.23,15.42 110.69,13.96 124.14,13.96 124.46,14.28 128.07,14.28 129.2,15.41 137.53,15.41 140.02,17.9 v2(141.73,17.9)
KSO7: length 66.7
  TOP w0.102: v2(104.93,18.5) 104.93,19.07 103.6,20.4 103.16,20.4 100.89,22.66 100.89,23.11 93.67,30.34 93.67,32.94 v1(93.47,33.14) 93.26,33.35 JKB.19 ; UE5.50 138.2,17.68 v2(138.11,17.58) ; RPE4.5 145.17,21.97 145.03,21.84 144.69,21.84 144.44,21.59 144.12,21.59 143.84,21.31 143.11,21.31 v2(142.87,21.07)
  IN3 w0.102: v2(142.87,21.07) 140.77,18.98 139.5,18.98 v2(138.11,17.58) 137.94,17.42 137.53,17.42 135.98,18.98 133.03,18.98 132.26,18.22 129.85,18.22 129.57,18.5 v2(104.93,18.5)
KSO8: length 71.8
  TOP w0.102: v2(129.51,10.34) 129.22,10.63 129.22,10.66 128.66,11.22 RPE6.8 ; JKB.17 92.49,34.95 92.95,34.95 94.13,33.77 94.13,30.53 105.57,19.08 105.57,17.03 v3(105.78,16.82) 106.06,16.54 106.06,14.37 v2(105.66,13.96) ; v2(138.93,14.85) 138.93,17.57 139.8,18.44 UE5.46
  IN3 w0.102: v2(105.66,13.96) 105.85,13.77 108.45,13.77 109.45,12.77 125.97,12.77 126.55,12.18 128.26,12.18 129.51,10.94 v2(129.51,10.34) 130.86,10.34 133.41,12.89 136.96,12.89 v2(138.93,14.85)
KSO9: length 59.6
  TOP w0.102: RE348.1 129.52,18.05 129.52,16.96 ; 129.52,16.96 129.94,16.55 UE5.68 ; 129.52,16.96 v2(129.53,16.96) ; v2(109.56,17.01) 109.56,20.54 104.32,25.79 v1(103.88,25.79) 103.43,25.79 96.46,32.75 96.46,38.92 92.43,42.95 JKB.7
  IN3 w0.102: v2(109.56,17.01) 109.59,17.03 120.55,17.03 121.41,16.18 123.25,16.18 124.15,17.09 128.63,17.09 128.75,16.96 v2(129.53,16.96)
KSO10: length 61.5
  TOP w0.102: RPE5.8 128.21,16.24 v2(128.52,15.93) 128.9,15.93 129.88,14.95 UE5.72 ; v2(109.75,15.8) 110.42,16.47 110.42,20.33 104.41,26.34 103.52,26.34 96.92,32.94 96.92,39.11 93.22,42.81 v1(93.22,43.99) 92.66,44.55 JKB.5
  IN3 w0.102: v2(128.52,15.93) 127.82,15.93 127.31,15.42 124.77,15.42 123.82,14.47 111.05,14.47 109.75,15.77 v2(109.75,15.8)
KSO11: length 61
  TOP w0.102: RPE5.7 128.05,15.74 v2(128.44,15.35) 128.44,15.12 128.77,14.79 129.47,14.79 130.11,14.15 UE5.74 ; JKB.6 92.38,43.75 92.74,43.39 92.74,42.97 96.69,39.01 96.69,32.85 103.42,26.12 104.31,26.12 109.98,20.45 v1(109.98,20.12) 109.98,16.74 v2(109.59,16.36)
  IN3 w0.102: v2(109.59,16.36) 109.34,16.11 109.34,15.63 110.76,14.22 124.01,14.22 124.33,14.53 127.62,14.53 v2(128.44,15.35)
KSO12: length 58.6
  TOP w0.102: UE5.75 130.13,13.75 129.85,14.02 v2(129.41,14.02) 128.9,14.53 128.64,14.53 127.94,15.24 RPE5.6 ; v2(107.5,14.49) 107.32,14.66 107.32,19.2 98.98,27.54 98.98,28.62 95.27,32.33 95.27,37.13 v1(93.45,38.95) JKB.12
  IN3 w0.102: v2(107.5,14.49) 107.71,14.28 108.77,14.28 109.82,13.22 124.58,13.22 124.87,13.52 128.64,13.52 128.74,13.61 128.99,13.61 v2(129.41,14.02)
KSO13: length 59.5
  TOP w0.102: v2(109.78,13.9) 108.9,13.9 108.45,14.34 108.45,15.36 108.07,15.74 108.07,19.42 99.87,27.62 99.87,28.7 95.95,32.61 95.95,38.63 v1(95.51,39.07) 93.24,41.35 93.18,41.35 JKB.9 ; UE5.76 130.17,13.35 129.9,13.62 129.18,13.62 v2(128.77,14.02) 128.06,14.74 RPE5.5
  IN3 w0.102: v2(109.78,13.9) 110.23,13.45 124.39,13.45 124.71,13.77 128.52,13.77 v2(128.77,14.02)
KSO14: length 66
  TOP w0.102: v2(128.45,10.34) 128.33,10.22 RPE6.6 ; JKB.8 92.77,42.15 v1(93.07,41.84) 93.26,41.65 93.4,41.65 96.21,38.85 96.21,32.68 103.44,25.45 104.33,25.45 109.09,20.7 109.09,15.68 111.5,13.26 111.5,10.72 v2(111.75,10.47) ; UE5.77 130.17,12.95 129.92,13.2 v2(129.72,13.2)
  IN3 w0.102: v2(128.45,10.34) 128.16,10.64 111.92,10.64 v2(111.75,10.47)
  BOTTOM w0.102: v2(128.45,10.34) 127.95,10.34 127.69,10.6 127.69,13.26 128.01,13.58 129.34,13.58 v2(129.72,13.2)
KSO15: length 62.3
  TOP w0.102: JKB.10 93.53,40.55 95.73,38.35 95.73,32.52 99.54,28.7 v1(99.54,28.19) 99.54,27.63 107.78,19.39 107.78,15.68 108.2,15.26 108.2,13.33 v2(108.39,13.14) ; RPE6.7 128.13,10.72 128.2,10.79 128.71,10.79 128.9,10.6 128.9,10.36 v2(129.5,9.76) 129.91,9.35 UE5.86
  IN3 w0.102: v2(108.39,13.14) 108.98,12.54 123.78,12.54 124.48,11.84 128.23,11.84 129.1,10.96 129.1,10.16 v2(129.5,9.76)
KSO16: length 69.7
  TOP w0.102: JKB.11 93.59,39.75 95.5,37.84 95.5,32.42 99.21,28.71 99.21,27.64 107.55,19.3 107.55,15.58 107.94,15.19 107.94,12.63 v1(110.07,10.5) 110.74,9.83 v2(111.75,9.83) ; UE5.92 133.32,6.95 134.74,8.37 v2(134.74,8.82) ; RPE6.5 v2(128.45,9.72)
  IN3 w0.102: v2(134.74,8.82) 134.08,9.48 131.62,9.48 131.12,8.98 129.27,8.98 128.53,9.72 v2(128.45,9.72) 127.76,10.41 117.22,10.41 116.64,9.83 v2(111.75,9.83)
L_BKLT_CTRL: length 198.9
  TOP w0.102: v1(6.41,81.14) 6.79,81.14 v2(7.04,81.4) 7.88,80.56 DX6.2 11.87,80.56 RX33.1
  IN1 w0.076: v2(154.3,103.45) 153.95,103.45 153.5,103.9 153.5,105.34
  IN1 w0.102: v2(7.04,81.4) 7.61,81.97 7.61,82.8 6.91,83.49 6.91,84.52 8.81,86.42 8.81,96.12 11.53,98.84 27.92,98.84 41.43,112.35 69.9,112.35 72.55,109.7 72.55,109.11 72.89,108.77 76.73,108.77 77.61,109.64 92.67,109.64 92.91,109.4 97.88,109.4 99.35,110.86 99.48,111 104.15,111 104.36,110.8 121.45,110.8 122.9,112.24 136.61,112.24 136.92,111.94 143.62,111.94 144.19,111.37 150.24,111.37 152.04,109.57 152.04,107.03 153.5,105.57 153.5,105.34
  BOTTOM w0.076: v2(154.3,103.45) 153.79,102.94 153.79,100.38 152.84,99.43 151.95,99.43 151.76,99.24 151.76,98.86 151.44,98.54 151.44,98.23 151.12,97.91 151.12,97.59 150.93,97.4 149.92,97.4 149.73,97.21 149.73,96.6 149.03,95.9 149.03,95.3 148.9,95.18 146.67,95.18 UC1.R11
L_BKLT_EN_EC: length 151.3
  TOP w0.076: RC223.2 145.79,95.64 v2(145.79,96.23) 145.79,96.45 145.54,96.7 v1(145.28,96.7)
  TOP w0.102: v2(135.57,15.81) 135.57,12 134.33,10.76 134.33,8.6 133.08,7.35 UE5.91
  IN1 w0.076: 154.87,85.72 152.52,85.72 151.64,86.59 151.64,88.67 152.38,89.41 153.73,89.41 154.7,90.39 154.7,92.41 154.22,92.89 152.2,92.89 150.51,94.58 147.4,94.58 145.79,96.2 v2(145.79,96.23)
  IN1 w0.102: 154.87,85.72 156.35,85.72 157.24,86.6 157.75,86.6 158.64,87.49 165.45,87.49 168.93,84.02 168.93,76.59 169.28,76.23 169.28,73.45 169.83,72.9 169.83,67.85 166.82,64.84 166.82,61.53 165.87,60.58 165.87,57.41 165.06,56.6 164.17,56.6 163.69,56.11 163.69,53.86 165.39,52.17 165.39,45.95 165.91,45.42 165.91,41.34 166.32,40.93 166.32,37.89 166.07,37.64 166.07,27.3 165.74,26.97 165.74,24.76 161.68,20.7 160.76,20.7 159.38,19.32 154.26,19.32 153.91,18.97 149.32,18.97 146.5,16.16 140.19,16.16 139.53,15.5 135.88,15.5 v2(135.57,15.81)
  BOTTOM w0.076: v2(145.79,96.23) 145.79,94.95 UC1.R12
LAN_EN: length 144.1
  TOP w0.102: v2(141.53,10.51) 141.53,9.77 142.61,8.69 143.48,8.69 145.03,7.15 145.03,6.6 145.47,6.15 UE5.3
  IN1 w0.102: v2(184.27,98.54) 184.27,97.27 185.67,95.88 185.67,80.26 189.99,75.94 189.99,60.26 190.52,59.73 190.52,49.73 192.32,47.92 192.32,41.83 189.41,38.92 189.41,38.16 186.68,35.43 186.68,30.46 185.73,29.5 185.73,25.14 179.92,19.33 176.79,19.33 174.41,16.96 169.76,16.96 165.92,13.11 165.92,12.19 163.7,9.97 152.83,9.97 151.12,11.68 148.9,11.68 147.96,10.74 141.76,10.74 v2(141.53,10.51)
  BOTTOM w0.102: UL3.4 187.57,98.73 187.19,99.11 v1(186.73,99.11) 185.73,98.11 RL27.2 184.7,98.11 v2(184.27,98.54)
LAN_WAKE#: length 33.1
  TOP w0.102: RPC11.2 158.04,63.69 158.1,63.62 158.77,63.62 v2(158.94,63.46) 159.41,63.94 RC56.1
  IN3 w0.102: v2(144.41,85.81) 144.94,85.29 144.94,80.98 148.2,77.72 148.2,74.09 153.16,69.14 153.16,67.56 155.38,65.33 155.83,65.33 157.22,63.94 158.46,63.94 v2(158.94,63.46)
  BOTTOM w0.076: v2(144.41,85.81) 143.96,86.27 UC1.AM15
  BOTTOM w0.102: v1(158.43,63.46) v2(158.94,63.46)
LCD_BRIGHTNESS: length 12.4
  TOP w0.102: RX33.2 11.82,81.53 DX6.1 7.61,81.53 7.23,81.91 6.91,81.91 6.55,81.54 4.63,81.54 RX26.1 3.66,80.57 v2(3.43,80.57) 3.43,80.95 v1(3.1,81.27)
  BOTTOM w0.102: JEDP.36 2.5,81.5 v2(3.43,80.57)
LCD_TEST: length 12.2
  TOP w0.102: v2(3.1,82.74) 3.31,82.74 v1(3.61,83.05) 3.61,83.25 3.86,83.5 4.43,83.5 4.55,83.38 4.55,83 4.89,82.67 6.15,82.67 6.6,82.22 7.04,82.22 7.3,82.48 8.69,82.48 9.42,81.75 11.49,81.75 11.88,82.15 RX32.2
  BOTTOM w0.102: v2(3.1,82.74) 2.71,82.74 2.46,83 JEDP.33
LCD_TST: length 186.5
  TOP w0.102: UE5.26 145.35,15.35 145.15,15.55 v2(145.15,17.07) ; DX6.3 11.55,82.49 RX32.1 12.6,83.54 DX5.3 13.72,84.56 14.22,84.07 14.22,81.78 v1(13.71,81.27) v2(13.07,80.64)
  IN2 w0.102: v2(13.07,80.64) 13.52,80.19 13.52,74.1 11.9,72.48 11.9,57.49 15.04,54.35 27.44,54.35 31.31,50.47 33.02,50.47 40.67,42.83 43.21,42.83 53.61,32.43 96.01,32.43 105.71,22.72 126.44,22.72 129.46,19.7 132.42,19.7 133.19,18.94 139.29,18.94 141.15,17.07 v2(145.15,17.07)
LG1_VGA: length 11.3
  TOP w0.508: v2(73.15,43.43) 73.29,43.29 PR818.1
  IN3 w1.016: 71.11,43.93 67.75,47.3 62.16,47.3
  vias: v2(61.46,47.49) v2(61.46,46.85) v2(72.51,43.43)
LG2_VGA: length 4.4
  IN3 w1.016: 70.99,42.35 69.91,42.35 68,44.25 67.37,44.25
  vias: v2(66.35,44.63) v2(66.35,44) v2(72.26,42.09) v2(72.89,42.09)
LG_1.35V: length 3.1
  IN3 w0.762: 87.37,19.8 87.37,16.69
  vias: v2(86.67,20.63) v2(86.67,15.99) v2(86.67,15.36) v2(87.27,20.63)
LGATE_CHG: length 5.6
  IN3 w1.016: 42.98,22.6 42.98,20.88 45.71,18.15
  vias: v2(42.67,23.8) v2(43.3,23.8) v2(46.16,17.14) v2(46.16,16.5)
LID_CL_SIO#: length 7.4
  TOP w0.102: UE5.41 141.8,21 141.22,21.59 CE77.1 141.73,22.33 141.73,23.22 RE363.2 RE366.2 v1(139.01,24.05)
LID_CLOSE#: length 208.3
  TOP w0.102: JLED.4 13.61,55.3 15.04,55.3 v3(15.49,55.74) 15.97,56.23 15.97,59.47 v2(16.25,59.74) ; v2(139.24,25.02) 139.3,24.96 RE366.1 ; v2(12.44,87.43) 12.44,89.26 14.48,91.3 DX9.1
  IN1 w0.102: v2(139.24,25.02) 137.54,26.72 107.86,26.72 105.15,29.43 105.15,32.37 99.51,38.02 89.49,38.02 89.16,38.35 81.4,38.35 79.79,36.73 55.07,36.73 45.59,46.22 41.79,46.22 31.93,56.08 31.93,62.92 27.11,67.75 23.55,67.75 21.39,65.59 21.39,60.54 20.25,59.4 16.59,59.4 v2(16.25,59.74)
  IN3 w0.102: v2(16.25,59.74) 15.61,60.38 15.61,63.24 16.44,64.06 19.42,64.06 20.92,65.56 21.2,65.56 24.63,68.99 24.63,79.3 22.28,81.65 18.34,81.65 12.57,87.43 v2(12.44,87.43)
LINE1-L: length 4.8
  BOTTOM w0.203: UA1.22 192.95,20.89 192.41,21.43 v1(192.41,21.96) 192.41,23.6 191.57,24.44 CA67.1
LINE1-R: length 3.9
  BOTTOM w0.203: CA68.1 192.03,22.65 192.03,21.25 192.8,20.49 UA1.21
LINE1-VREFO-L: length 13.7
  TOP w0.254: v2(189.67,30.03) 189.67,30.01 190.87,28.81 v1(193.92,28.81) 194.79,28.81 197.16,26.43 197.16,24.13 v2(196.93,23.91)
  BOTTOM w0.254: UA1.31 196.73,23.02 196.72,23.02 196.72,23.7 196.93,23.91 v2(196.93,23.91) ; RA165.1 189.11,30.03 v2(189.67,30.03)
LINE1-VREFO-R: length 13.2
  TOP w0.254: v2(196.29,23.93) 196.29,23.97 196.78,24.45 196.78,26.22 194.81,28.19 v1(191.38,28.19) 190.62,27.42 190.62,27.11 190.11,26.6 v2(190.11,26.53)
  BOTTOM w0.254: UA1.30 196.33,23.18 196.33,23.9 v2(196.29,23.93) ; v2(190.11,26.53) 189.85,26.27 RA166.1
LINE-IN-L: length 21.6
  TOP w0.254: RA80.2 188.14,28.25 v1(188.52,28.63) v2(189.73,28.63)
  BOTTOM w0.254: v2(189.73,28.63) 190.18,28.63 191.12,29.57 RA83.1 191.57,29.82 LA8.2 ; v2(189.73,28.63) 189.54,28.82 189.4,28.82 RA165.2 ; v2(189.73,28.63) 189.54,28.44 188.59,28.44 187.95,27.8 187.95,25.96 188.78,25.14 194.05,25.14 194.49,25.58 194.49,26.09 194.67,26.27 196.5,26.27 196.86,25.91 RA55.2
LINE-IN-R: length 19.5
  TOP w0.254: RA82.2 189.21,27.87 v2(189.73,27.87)
  BOTTOM w0.254: v2(189.73,27.87) 190.43,27.87 190.75,27.55 190.75,26.53 191.06,26.22 RA84.1 191.57,26.67 LA9.2 ; v2(189.73,27.87) 189.62,27.98 188.83,27.98 188.46,27.61 188.46,26.22 189.07,25.61 193.82,25.61 v1(193.99,25.77) 193.99,26.28 194.43,26.72 196.98,26.72 197.75,25.96 RA56.2 ; v2(189.73,27.87) 189.48,27.61 189.48,27.31 RA166.2
LPC_LAD0: length 113.8
  TOP w0.102: v2(135.12,17.9) 134.6,18.42 UE5.59 134.6,20.32 134.3,20.63 134.11,20.63 133.65,21.08 v2(133.65,21.28)
  IN1 w0.089: v2(154.93,71.54) 154.93,71.17 155.06,71.05 155.06,69.78 154.74,69.46 154.74,66.1 155.41,65.43 155.41,63.78 154.66,63.03 154.66,61.26 156.88,59.04 156.88,53.51 161.37,49.03 161.37,44.84 161.14,44.61 160.72,44.61 160.29,44.19 160.29,41.33 161.06,40.56 161.06,37.74 160.3,36.98 160.3,27.45 155.9,23.05 146.96,23.05 146.64,22.73 135.11,22.73 v2(133.65,21.28)
  BOTTOM w0.076: UC1.AY13 144.78,81.13 144.68,81.02 144.58,80.91 144.51,80.7 144.51,80.58 144.57,80.35 144.57,80.21 144.52,80.09 144.52,79.82 144.64,79.69 144.64,79.51 145.75,78.4 145.75,77.14
  BOTTOM w0.102: v2(135.12,17.9) 133.22,19.8 131.82,19.8 130.95,20.67 129.37,20.67 129.11,20.92 127.18,20.92 126.93,20.67 v1(125.6,20.67) 125.25,20.67 124.8,20.22 DB1.8 ; 145.75,77.14 145.75,76.97 146.89,75.83 146.89,73.12 148.01,72 151.12,72 151.31,71.81 152.2,71.81 152.9,71.11 153.72,71.11 154.1,71.49 154.88,71.49 v2(154.93,71.54)
LPC_LAD1: length 110.7
  TOP w0.102: v2(134.44,17.9) 134.2,18.13 UE5.60 134.2,20.15 133.05,21.31 v2(133.05,21.37)
  IN1 w0.089: v2(154.48,71.91) 154.48,71.31 154.81,70.98 154.81,69.84 154.49,69.52 154.49,66 154.44,65.96 154.44,61.17 156.67,58.95 156.67,53.42 160.64,49.45 160.64,46.54 160.39,46.3 160.39,45.06 160.08,44.75 160.08,41.24 160.85,40.47 160.85,37.83 159.28,36.27 159.28,27.16 157.86,25.74 156.93,25.74 154.46,23.27 146.87,23.27 146.56,22.95 141.88,22.95 140.91,23.92 137.79,23.92 136.95,23.09 134.76,23.09 v2(133.05,21.37)
  BOTTOM w0.076: UC1.BA13 144.78,80.43 145.05,80.17 145.05,79.57 146.23,78.39 146.23,77.42
  BOTTOM w0.102: v2(154.48,71.91) 154.29,71.72 154.01,71.72 153.97,71.68 153.63,71.68 153.35,71.97 153.35,71.97 152.78,71.97 152.27,72.49 152.27,72.74 151.71,73.3 149.75,73.3 149.15,72.7 148.14,72.7 147.37,73.47 147.37,76 146.23,77.14 146.23,77.42 ; DB1.7 125.3,19.46 126.28,20.44 127.02,20.44 127.28,20.69 129.02,20.69 129.27,20.44 130.55,20.44 v1(130.68,20.31) 131.42,19.57 133.07,19.57 134.44,18.2 v2(134.44,17.9)
LPC_LAD2: length 107.5
  TOP w0.102: v2(133.8,17.95) 133.8,17.95 133.8,18.39 133.8,18.4 UE5.61 133.8,20.15 133,20.95 132.7,20.95 v2(132.5,21.14)
  IN1 w0.089: v2(153.17,71.57) 153.39,71.35 153.39,67.96 153.43,67.91 153.43,64.74 154.23,63.94 154.23,61.08 155.76,59.55 155.76,54.02 160.42,49.36 160.42,46.66 160.18,46.42 160.18,45.15 159.86,44.84 159.86,41.15 160.63,40.38 160.63,37.92 159.07,36.36 159.07,27.25 157.79,25.97 156.86,25.97 154.37,23.48 146.78,23.48 146.6,23.3 144.96,23.3 144.5,23.77 143.35,23.77 143.03,23.45 141.69,23.45 141,24.14 135.2,24.14 132.5,21.44 v2(132.5,21.14)
  BOTTOM w0.076: UC1.BB13 144.78,79.8 144.88,79.7 144.88,79.51 145.98,78.41 145.98,77.98
  BOTTOM w0.102: DB1.6 125.8,19.63 126.38,20.21 127.12,20.21 127.37,20.46 128.92,20.46 129.18,20.21 130.22,20.21 131.19,19.24 v1(131.63,19.24) 133.02,19.24 133.8,18.46 133.8,17.95 v2(133.8,17.95) ; 145.98,77.98 145.98,77.06 147.12,75.92 147.12,73.27 148.14,72.25 151.19,72.25 151.38,72.06 152.37,72.06 152.87,71.57 v2(153.17,71.57)
LPC_LAD3: length 108.8
  TOP w0.102: v2(133.21,17.96) 133.21,18.21 133.4,18.4 UE5.62 133.4,20.19 132.92,20.67 132.4,20.67 131.92,21.15 v2(131.92,21.21)
  IN1 w0.089: v2(131.92,21.21) 131.92,21.43 134.85,24.36 141.09,24.36 141.78,23.66 142.94,23.66 143.26,23.98 144.59,23.98 145.05,23.52 146.51,23.52 146.69,23.7 154.28,23.7 156.8,26.22 157.73,26.22 158.85,27.34 158.85,36.45 160.41,38.01 160.41,40.3 159.65,41.06 159.65,44.93 159.96,45.24 159.96,46.55 160.2,46.79 160.2,49.27 155.54,53.93 155.54,59.46 154.01,60.99 154.01,63.85 153.22,64.65 153.22,67.81 153.17,67.85 153.17,70.94 152.71,71.4 152.71,72.14 v2(152.95,72.38)
  BOTTOM w0.076: 146.85,77.14 146.85,78 145.21,79.64 145.21,80.53 145.05,80.69 145.05,81.12 145.35,81.42 UC1.AY12
  BOTTOM w0.102: v2(152.95,72.38) 151.81,73.52 149.6,73.52 149.09,73.02 148.2,73.02 147.63,73.59 147.63,76.06 146.85,76.84 146.85,77.14 ; v2(133.21,17.96) 133.21,18.09 v1(132.77,18.53) 132.45,18.53 132.26,18.34 131.76,18.34 130.12,19.98 129.08,19.98 128.83,20.24 127.47,20.24 127.21,19.98 126.6,19.98 126.3,19.68 DB1.5
LPC_LFRAME#: length 110.3
  TOP w0.102: v2(135.71,17.9) 135.26,18.34 135.18,18.34 135,18.52 UE5.58 135,20.36 v2(134.23,21.14)
  IN1 w0.102: v2(155.44,71.24) 155.3,71.1 155.3,69.51 155,69.21 155,66.16 156.29,64.87 156.29,64.09 154.93,62.73 154.93,61.3 157.11,59.13 157.11,53.6 161.59,49.12 161.59,44.42 162.05,43.95 162.05,36.69 160.52,35.16 160.52,27.36 155.99,22.83 147.06,22.83 146.29,22.06 145.78,22.06 145.33,21.62 143.86,21.62 142.97,22.51 135.29,22.51 134.23,21.45 v2(134.23,21.14)
  BOTTOM w0.076: 147.82,77.14 147.11,77.85 147.11,77.98 145.38,79.71 145.38,80.93 UC1.BA12
  BOTTOM w0.102: DB1.4 126.8,19.61 126.94,19.75 127.31,19.75 127.56,20.01 128.74,20.01 128.99,19.75 130.03,19.75 132.26,17.52 132.52,17.52 133.15,16.88 v1(134.23,16.88) 135.44,16.88 135.71,17.15 v2(135.71,17.9) ; 147.82,77.14 151.12,73.84 152.36,73.84 153.62,72.58 155.37,72.58 155.82,72.13 155.82,71.62 v2(155.44,71.24)
LPSS_UART2_CTS#: length 15.3
  TOP w0.076: v1(149.98,89.53) 150.46,89.53 v2(150.68,89.31)
  IN3 w0.076: v2(150.68,89.31) 150.68,88.45 152.08,87.05 152.08,86.1 152.52,85.65 154.87,85.65
  IN3 w0.102: 154.87,85.65 160.58,85.65 v2(160.78,85.46)
  BOTTOM w0.076: v2(150.68,89.31) 150.17,89.82 UC1.AD4
  BOTTOM w0.102: RC65.1 161.4,86.08 v2(160.78,85.46)
LX1_VGA: length 15
  IN3 w1.016: 72.13,45.46 68.13,49.46 58.79,49.46
  vias: v2(57.7,49.71) v2(57.71,49.09) v2(72.51,44.7) v2(73.15,44.7) v3(58.6,47.93)
LX2_VGA: length 13
  IN3 w1.016: 58.6,43.3 60.19,41.71 68.51,41.71 69.27,40.95 70.67,40.95
  vias: v2(57.61,43.6) v2(57.61,42.9) v2(72.26,41.2) v2(72.89,41.2) v3(58.73,41.58)
LX_1.8VALW:
  vias: v1(89.08,31.36)
LX_1.35V: length 1
  TOP w0.508: PC207.1 v2(91.69,15.35)
  vias: v1(88.39,16.5)
LX_3V:
  vias: v2(59.87,13.83) v2(60.51,13.83) v2(63.68,13.83) v2(64.32,13.83)
LX_5V:
  vias: v1(65.11,23.97) v2(60.7,25.58) v2(61.33,25.58) v2(65.27,26.47) v2(65.91,26.47)
MAINPWON: length 4.4
  TOP w0.102: v1(159.29,11.41) 157.68,11.41 157.47,11.62 U2407.7 157.47,14.03 R2448.2
MCT0: length 3
  TOP w0.102: v2(190.81,104.7) v1(191.32,104.7)
  TOP w0.254: RL19.1 190.68,104.58 v2(190.81,104.7)
  BOTTOM w0.254: TL2.14 190.68,104.58 v2(190.81,104.7)
MCT1: length 3
  TOP w0.102: v2(190.81,108.26) v1(191.32,108.26)
  TOP w0.254: v2(190.81,108.26) 190.49,108.26 RL20.1
  BOTTOM w0.254: TL2.11 190.68,108.39 v2(190.81,108.26)
MDI0+: length 8.4
  BOTTOM w0.089: UL1.1 178.08,104.96 178.12,104.92 178.22,104.92 178.67,105.36 v4(178.67,109.21) 178.67,110.15 178.97,110.45 179.35,110.45 179.44,110.54 179.44,110.8 179.57,110.93 TL2.8
MDI0-: length 8.4
  BOTTOM w0.089: TL2.7 179.55,109.66 179.46,109.75 179.46,110.01 179.37,110.11 179.11,110.11 179.01,110.01 v4(179.01,106.23) 179.01,105.22 178.36,104.58 178.05,104.58 178.03,104.56 UL1.2
MDI1+: length 3.9
  BOTTOM w0.089: UL1.4 178.26,103.76 178.3,103.72 178.68,103.72 178.97,103.42 178.97,103.03 179.14,102.86 179.42,102.86 179.48,102.93 179.48,103.15 179.63,103.31 TL2.2
MDI1-: length 3.9
  BOTTOM w0.089: UL1.5 178.29,103.36 178.3,103.37 178.53,103.37 178.63,103.28 178.63,102.89 v4(178.81,102.7) 179,102.52 179.51,102.52 179.56,102.47 179.56,102.16 179.69,102.04 TL2.1
MDO0+: length 13.7
  BOTTOM w0.089: JLAN.1 201.1,108.32 200.99,108.22 199.96,108.22 199.33,108.85 194.94,108.85 193.67,110.12 v4(191.64,110.12) 191.09,110.12 190.28,110.93 TL2.9
MDO0-: length 13.7
  BOTTOM w0.089: JLAN.2 201.36,108.1 201.14,107.87 199.82,107.87 199.19,108.5 v4(195.26,108.5) 194.8,108.5 193.52,109.78 190.78,109.78 190.66,109.66 TL2.10
MDO1+: length 14.3
  BOTTOM w0.089: JLAN.3 201.1,106.04 200.89,105.83 200.58,105.83 199.94,105.2 195.37,105.2 193,102.83 v4(191.57,102.83) 190.67,102.83 190.19,103.31 TL2.15
MDO1-: length 14.3
  BOTTOM w0.089: JLAN.6 201,104.02 200.16,104.86 v4(196.14,104.86) 195.51,104.86 193.14,102.49 190.85,102.49 190.4,102.04 TL2.16
ME_FWP_EC: length 104.4
  TOP w0.102: RC17.1 145.54,69.73 145.54,68.53 145.93,68.14 146.7,68.14 147.25,67.59 147.25,67.49 149.09,65.65 v1(149.73,65.65) 151.42,65.65 v2(153.08,63.99) ; UE5.80 129.57,11.75 128.96,12.36 128.96,12.56 128.64,12.88 128.64,13.15 RE357.1 128.15,14.08 127.95,14.28 125.79,14.28 125.32,14.75 125.32,19.32 124.78,19.85 124.78,20.32 125.22,20.76 125.22,23.74 v2(125.47,23.99)
  IN1 w0.102: v2(153.08,63.99) 153.79,63.28 153.79,60.9 155.32,59.37 155.32,53.58 159.19,49.72 159.19,47.04 159.74,46.48 159.74,45.34 159.42,45.02 159.42,38.95 158.63,38.16 158.63,27.44 157.66,26.47 156.74,26.47 154.19,23.92 150.73,23.92 149.11,25.54 140.88,25.54 139.92,24.58 129.55,24.58 128.96,23.99 v2(125.47,23.99)
ME_SUS_PWR_ACK: length 107.9
  TOP w0.102: RC108.2 159.25,59.92 159.25,61.17 v2(159.15,61.27) ; v2(141.28,20.76) 141.4,20.63 UE5.42
  IN3 w0.102: v2(141.28,20.76) 142.26,21.73 143.15,21.73 143.85,22.43 146.19,22.43 147.29,23.54 165.95,23.54 168.29,25.87 170.14,25.87 171.14,26.87 171.14,33.67 170.19,34.62 170.19,36.47 168.2,38.45 168.2,40.51 168.58,40.89 168.58,43.11 168.05,43.63 168.05,45.79 167.29,46.55 167.29,50.15 160.75,56.69 160.75,57.17 160.2,57.72 160.2,59.05 159.15,60.1 v2(159.15,61.27) 159.15,61.3 159.06,61.39 159.06,62.73 159.34,63.01 159.34,63.63 158.81,64.16 157.32,64.16 155.92,65.56 155.48,65.56 153.38,67.66 153.38,70.25 152.55,71.09 152.55,74.2 145.73,81.02 145.73,84.26 v2(145.33,84.66)
  BOTTOM w0.076: UC1.AR13 145.07,84.4 v2(145.33,84.66)
  BOTTOM w0.102: v2(141.28,20.76) v1(140.58,20.06)
MEC_XTAL1: length 6.2
  TOP w0.102: RE382.2 144.09,1.39 147.12,1.39 v1(147.19,1.45) 147.24,1.5 C5232.1 149.21,1.5 149.49,1.79 Y1.1
MEC_XTAL1_R: length 2.2
  TOP w0.102: RE382.1 143,1.6 UE5.123
MEC_XTAL2: length 11.5
  TOP w0.102: Y1.2 151.99,3.11 C5233.1 150.86,3.23 147.82,3.23 146.51,1.92 v1(144.9,1.92) 144.56,1.92 143.8,2.67 UE5.125
MIC1-L: length 3.8
  BOTTOM w0.102: CA74.1 191.38,18.91 190.81,18.34 v1(190.56,18.34)
  BOTTOM w0.203: UA1.19 192.65,19.69 192.58,19.61 191.46,19.61 CA74.1
MIC_CLK_C: length 3.1
  BOTTOM w0.102: UA1.3 197.93,15.99 198.68,15.23 v1(198.75,15.23) 199.45,14.53 LA1.1
MIC_IN_R: length 26
  IN3 w1.016: 199.09,33.33 199.56,32.86 199.56,31.7 198.38,30.52 198.38,27.92 200.34,25.96 209.1,25.96 210.14,27.01 JHP.4
  BOTTOM w0.508: v2(198.38,33.41) v2(197.54,33.41) DA12.3 194.95,33 CA38.1 192.59,33 192.52,33.07 LA7.1
MODEL_ID: length 26.2
  TOP w0.102: C5230.1 R2453.2 118.48,2.98 118.43,3.03 R2452.2 118.43,4.28 v2(118.09,4.62) ; UE5.109 137.4,2.85 v2(136.9,2.34) 136.39,1.83 v1(136.2,1.83)
  IN1 w0.102: v2(118.09,4.62) 119.73,2.99 121.58,2.99 122.7,1.87 129.17,1.87 130.14,2.85 136.39,2.85 v2(136.9,2.34)
MONO_PC_BEEP_R: length 5.3
  TOP w0.254: RA1114.2 193.22,14.85 192.72,15.36 192.4,15.36 v1(192.08,15.68) 192.08,17.23 v2(192.49,17.63)
  BOTTOM w0.203: v2(192.49,17.63) 192.83,17.98 192.83,18.33 192.99,18.49 UA1.16
MPHYP_PWR_EN: length 52.9
  TOP w0.102: RC210.1 188.52,73.77 v2(188.52,73.27)
  IN1 w0.076: 154.87,77.52 154.68,77.52 153.85,78.35 151.5,78.35 148.43,81.43 148.43,85.49 148.33,85.59 147.7,85.59 147.51,85.77 146.37,85.77 v2(146.17,85.97)
  IN1 w0.089: 154.87,77.52 159.95,77.52 161.79,75.68 166.88,75.68 v2(167.86,74.71)
  BOTTOM w0.076: UC1.AM10 146.55,86.35 v2(146.17,85.97)
  BOTTOM w0.102: v2(188.52,73.27) 188.52,74.95 188.27,75.21 170.79,75.21 170.29,74.71 v1(169.41,74.71) v2(167.86,74.71)
MSCLK: length 2.3
  TOP w0.102: v2(120.54,7.63) 121.09,8.18 RE391.2
  BOTTOM w0.102: JDEG1.6 121.07,7.67 120.93,7.81 120.72,7.81 v2(120.54,7.63)
MSDATA: length 3.2
  TOP w0.102: v2(120.54,8.21) 120.33,8.43 v1(120.33,8.94) 120.52,9.14 RE394.2
  BOTTOM w0.102: v2(120.54,8.21) 120.72,8.04 120.93,8.04 121.07,8.17 JDEG1.7
NRB_BIT: length 17
  TOP w0.076: v2(148.07,84.51) 148.45,84.13 148.45,83.19 148.08,82.82 148.08,81.63
  TOP w0.089: 148.08,81.63 148.08,81.18 150,79.26 150,79.03 v1(151.28,77.75) 151.53,77.5
  TOP w0.102: RC118.2 157.16,75.62 155.95,76.83 152.2,76.83 151.53,77.5
  BOTTOM w0.076: UC1.AR7 148.18,84.4 v2(148.07,84.51)
NTC_IA: length 3.7
  BOTTOM w0.203: PR635.2 85.46,111.87 85.46,113.21 85.89,113.64 PU602.15
NVVDD_GND_SENSE: length 51.6
  IN3 w0.254: v2(80.86,40.36) 81.17,40.36 85.59,44.79 85.59,59.74 84.51,60.82 84.51,68.93 81.44,72 81.44,81.06 v2(80.91,81.59)
  BOTTOM w0.254: PR811.1 80.75,40.45 80.86,40.35 v2(80.86,40.36) ; UV1.F1 75.73,81.27 76.64,81.27 76.83,81.08 v1(80.4,81.08) v2(80.91,81.59)
NVVDD_GND_SENSE_R: length 10.2
  BOTTOM w0.203: PR811.2 78.4,40.45 77.78,41.08 77.78,41.77 77.46,42.09 PU801.10
  BOTTOM w0.254: PR811.2 79.2,39.55 PR810.2 79.56,39.17 79.56,37.77 79.24,37.46 v1(77.84,37.46) 76.83,37.46 76.45,37.84 PC804.1
NVVDD_SENSE: length 60.5
  IN3 w0.254: v2(75.56,37.71) 75.56,37.96 77.4,39.81 81.15,39.81 85.98,44.63 85.98,59.9 84.89,60.98 84.89,69.14 81.82,72.22 81.82,81.42 81.15,82.1 80.44,82.1 v2(79.95,81.62)
  BOTTOM w0.254: v2(79.95,81.62) v1(78.99,81.62) 77.46,81.62 77.27,81.81 75.46,81.81 74.96,81.3 UV1.F2 ; PR812.1 v2(75.56,37.71)
NVVDD_SENSE_R: length 3.8
  BOTTOM w0.203: PU801.12 75.93,40.24 75.56,39.87 PR812.2
  BOTTOM w0.254: PR813.2 PC804.2 PR812.2
ONE_DIMM#: length 9.8
  BOTTOM w0.076: UC1.M2 151.45,97.28 151.76,97.59 151.76,97.85 151.93,98.02 152,98.02 152.65,98.67 152.84,98.67 154.87,100.7
  BOTTOM w0.102: RC232.1 156.57,102.16 RC231.1 155.25,102.62 v1(155.25,101.08) 154.87,100.7
PANEL_BKEN_EC: length 188.4
  TOP w0.102: RX31.1 9.01,80.06 9.2,79.87 12.5,79.87 v2(13.04,79.33) v1(13.55,79.33) ; v2(140.46,17.02) 140.87,16.6 140.87,14.06 140.43,13.62 140.43,4.94 140.6,4.77 UE5.117
  IN2 w0.102: v2(140.46,17.02) 138.77,18.71 133.09,18.71 132.33,19.47 129.37,19.47 126.35,22.5 105.61,22.5 95.91,32.2 53.51,32.2 43.11,42.6 40.57,42.6 32.93,50.25 31.22,50.25 27.34,54.12 14.95,54.12 11.67,57.4 11.67,72.57 13.29,74.19 13.29,79.09 v2(13.04,79.33)
PBAT_CHG_SMBCLK: length 177.2
  TOP w0.102: UE5.9 147.48,8.55 147.5,8.53 147.75,8.53 v2(147.93,8.7) 148.13,8.5 149.02,8.5 RE349.1
  IN1 w0.102: v2(46.24,7.89) 46.5,8.15 46.5,8.59 46.96,9.05 47.85,9.05 53.27,14.47 53.27,30.35 54.53,31.61 94.65,31.61 108.62,17.65 108.62,15.96 111.23,13.35 125.07,13.35 127.45,10.98 130.17,10.98 131.57,9.57 134.88,9.57 135.74,8.72 141.71,8.72 142.51,7.92 146.42,7.92 147.03,8.53 147.75,8.53 v2(147.93,8.7)
  IN3 w0.102: v2(18.34,23.67) 18.09,23.42 17.77,23.42 17.52,23.17 17.52,19.61 22.15,14.98 25.64,14.98 32.12,8.5 46.22,8.5 46.41,8.3 46.41,8.06 v2(46.24,7.89)
  BOTTOM w0.102: PR770.1 46.42,8.23 46.42,8.07 v2(46.24,7.89)
  BOTTOM w0.254: v2(18.34,23.67) 18.15,23.49 17.76,23.49 PD2.3 17.58,23.83 PR18.2
PBAT_CHG_SMBDAT: length 176.2
  TOP w0.102: UE5.8 147.5,8.15 147.65,8.3 147.75,8.3 v2(147.93,8.12) 148.08,8.27 149.24,8.27 RE347.1
  IN1 w0.102: v2(147.93,8.12) 147.75,8.3 147.12,8.3 146.51,7.69 142.41,7.69 141.61,8.49 135.65,8.49 134.79,9.35 131.48,9.35 130.07,10.75 127.35,10.75 124.98,13.12 111.13,13.12 108.39,15.87 108.39,17.56 94.56,31.39 54.63,31.39 53.5,30.26 53.5,14.37 47.94,8.82 47.05,8.82 46.73,8.49 46.73,7.98 v2(46.82,7.89)
  IN3 w0.102: v2(46.82,7.89) 46.64,8.07 46.64,8.4 46.31,8.73 32.21,8.73 25.74,15.21 22.25,15.21 17.75,19.71 17.75,23.07 17.87,23.19 18.13,23.19 v2(18.34,22.98)
  BOTTOM w0.102: PR769.1 46.65,8.21 46.65,8.07 v2(46.82,7.89)
  BOTTOM w0.254: v2(18.34,22.98) 17.89,22.98 PD2.2 18.42,21.83 PR20.2
PBAT_PRES#: length 137.6
  TOP w0.102: UE5.97 132.6,2.81 132.09,2.29 v2(130.85,2.29) v1(129.66,2.29) 128.58,2.29 CE74.1
  IN3 w0.102: v2(130.85,2.29) 129.95,1.39 119.25,1.39 118.57,2.06 111.81,2.06 106.97,6.9 62.94,6.9 57.46,12.37 52.32,12.37 49.02,9.07 47.63,9.07 46.14,10.56 41.62,10.56 40.25,11.93 40.25,12.7 v2(39.74,13.21)
  BOTTOM w0.254: PR16.1 17.54,20.05 PR15.2 18.46,17.93 PD3.2 17.43,16.89 PR37.2 17.43,15.15 PC14.1 17.46,15.1 18.09,14.47 19.61,14.47 20.22,15.07 24.09,15.07 24.95,15.93 32,15.93 32.82,15.1 34.03,15.1 35.92,13.21 v2(39.74,13.21) PR764.1 41.41,12.34 PC753.2
PC_BEEP: length 4.6
  TOP w0.102: RA19.1 188.92,14.74 v1(188.59,14.41)
  TOP w0.254: DA8.1 190.65,15.66 190.56,15.57 RA79.2 RA19.1
PCH_ALW_ON: length 156.2
  TOP w0.102: RC191.1 176.59,99.18 v2(176.78,99.37) 177.03,99.37 177.31,99.09 177.96,99.09 v1(178.24,99.37) ; v2(127.31,16.68) RE361.1 128.35,17.31 128.35,16.92 129.92,15.35 UE5.71
  IN1 w0.102: v2(127.31,16.68) 127.31,15.9 128.55,14.66 131,14.66 132.85,12.81 132.85,12.04 133.7,11.19 147.77,11.19 148.71,12.13 151.31,12.13 153.01,10.43 163.52,10.43 165.46,12.38 165.46,13.3 169.57,17.42 174.22,17.42 184.13,27.32 184.13,28.56 186.17,30.6 186.17,36.32 188.88,39.02 188.88,42.25 189.43,42.8 189.43,59.1 188.18,60.34 188.18,61.99 187.64,62.54 187.64,68.91 186.7,69.85 186.7,76.98 177.97,85.7 177.97,93.93 176.78,95.12 v2(176.78,99.37)
PCH_BATLOW#: length 13.7
  TOP w0.102: v2(145.33,82.79) 145.81,82.31 v1(145.81,81.53) 145.81,81.05 151.77,75.09 151.77,73.07 152.27,72.57 RC103.2
  BOTTOM w0.076: v2(145.33,82.79) 145.02,83.1 UC1.AU13
PCH_DPWROK: length 27
  TOP w0.102: RC396.2 154.17,64.66 v2(153.99,64.83) 153.99,65.46 RC101.1 154.86,65.52 RC112.1
  BOTTOM w0.076: 141.27,78.95 141.14,79.09 UC1.BB20
  BOTTOM w0.102: 141.27,78.95 141.27,77.86 142.23,76.89 142.23,74.98 142.86,74.35 142.86,69.84 145.85,66.86 151.97,66.86 v3(152.98,65.85) v2(153.99,64.83)
PCH_HDMI_CLK: length 65.8
  TOP w0.089: v2(166.81,90.27) 166.62,90.07 166.62,89.92 166.69,89.85 172.33,89.85 172.36,89.88 173.06,89.88 173.09,89.85 175.35,89.85 177.91,87.29 187.37,87.29 193.1,81.56 193.1,79.49 193.6,78.99 194.24,78.99 194.41,79.16 194.89,79.16 195.4,78.65 QX4.1
  IN3 w0.089: v2(166.81,90.27) 166.55,90.53 166.55,90.64 163.16,94.03 162.23,94.03 160.55,95.71 159.56,95.71 158.68,96.59 158.68,97.54 158.17,98.05 154.79,98.05 154.49,98.35 150.68,98.35 149.55,97.23 145.17,97.23 144.77,96.83 144.77,96.48 v2(144.55,96.26)
  BOTTOM w0.076: UC1.L13 144.82,96.53 v2(144.55,96.26)
  BOTTOM w0.089: v2(166.81,90.27) 166.61,90.07 166.61,89.83 166.37,89.59 165.86,89.59 165.79,89.52 RPC1.6
PCH_HDMI_DATA: length 65.5
  TOP w0.089: v2(166.23,90.27) 166.43,90.07 166.43,89.85 166.62,89.66 v4(172.71,89.66) 175.28,89.66 177.83,87.1 187.29,87.1 192.91,81.48 192.91,79.42 193.63,78.7 193.63,77.28 194.1,76.81 QX4.4
  IN3 w0.089: v2(166.23,90.27) 166.36,90.4 166.36,90.56 163.08,93.84 162.15,93.84 160.47,95.52 159.48,95.52 158.49,96.51 158.49,97.46 158.09,97.86 154.71,97.86 154.41,98.16 150.76,98.16 149.63,97.04 145.25,97.04 144.96,96.75 144.96,96.38 v2(145.2,96.16)
  BOTTOM w0.076: v2(145.2,96.16) 145.47,96.43 UC1.L12
  BOTTOM w0.089: RPC1.5 165.68,90.02 165.92,89.78 166.29,89.78 166.43,89.91 166.43,90.07 v2(166.23,90.27)
PCH_JTAG_TCK1: length 5.4
  BOTTOM w0.076: 121.15,105.34 121.15,104.81 v1(121.03,104.69) 120.44,104.1 120.44,103.38 120.21,103.15 120.21,103.05 119.93,102.77 119.93,102.51 119.99,102.39 119.99,102.17 UC1.B56
  BOTTOM w0.102: RC37.1 121.15,105.34 121.15,105.34
PCH_OPIRCOMP: length 9.3
  TOP w0.254: RC6.1 v1(143.95,75.49) 143.05,76.39 143.05,78.17 142.65,80.78 142.65,81.85 142.58,82.17 v2(142.58,82.77)
  BOTTOM w0.254: UC1.AU16 142.92,83.1 v2(142.58,82.77)
PCH_PCIE_WAKE#: length 19.1
  TOP w0.102: RC66.1 RC104.2 154.43,70.79 v2(154.37,70.84)
  BOTTOM w0.076: UC1.BB15 143.47,79.9 143.47,78.71 144.62,77.56 144.62,77.14
  BOTTOM w0.102: v2(154.37,70.84) 154.11,70.58 151.42,70.58 150.47,71.52 147.54,71.52 v1(147.44,71.62) 146.36,72.7 146.36,75.18 144.62,76.92 144.62,77.14
PCH_PLTRST#: length 35
  TOP w0.102: UC3.1 163.32,61.85 163.32,61.59 163.44,61.46 163.76,61.46 163.89,61.59 UC3.2 163.89,62.22 163.7,62.41 163.7,63.04 v2(163.89,63.23)
  IN1 w0.076: v2(146.23,85.19) 146.8,84.62 146.8,83.05 147.28,82.57 147.28,81.62 151.76,77.14
  IN1 w0.089: 151.76,77.14 153.23,75.68 156.63,75.68 161.51,70.8 161.51,68.46 164.13,65.83 164.13,63.87 163.89,63.63 v2(163.89,63.23)
  BOTTOM w0.076: UC1.AN10 146.7,85.65 v2(146.23,85.19)
PCH_PLTRST#_EC: length 401.2
  TOP w0.102: v2(163.25,64.53) 163.54,64.25 164.14,64.25 164.35,64.04 UC3.4 165.65,63.81 RC99.2 166.24,64.39 v1(168.33,64.39) v2(169.55,64.39) ; RX24.1 5.21,90.87 v2(5.58,91.24) ; v2(87.75,80.8) 87.14,80.8 86.73,81.21 85.52,81.21 84.81,81.92 84.81,82.61 84.14,83.28 UV12.1 ; RM6.2 186.92,63.55 v2(187.23,63.55) ; v2(130.12,18.95) 130.12,21.52 130.31,21.71 130.87,21.71 131.12,21.96 131.12,23.61 131.44,23.93 132.17,23.93 132.44,24.2 134.78,24.2 134.97,24.01 134.97,22.29 CE85.1 136.2,21.07 136.2,20.62 135.8,20.23 UE5.56
  IN1 w0.102: v2(187.23,63.55) 187.23,68.99 186.47,69.75 186.47,76.88 177.74,85.61 177.74,93.84 175.63,95.94 175.63,98.29 172.65,101.27 v2(172.65,103.05)
  IN2 w0.102: v2(84.54,35.93) 81.69,35.93 80.14,34.38 55.95,34.38 45.49,44.85 42.14,44.85 32.04,54.95 32.04,61.92 24.86,69.1 24.86,79.08 23.97,79.97 23.97,87.53 23.38,88.12 18.99,88.12 18.02,89.08 8.63,89.08 6.47,91.24 v2(5.58,91.24)
  IN3 w0.102: v2(87.75,80.8) 89.45,79.1 89.45,73.64 89.07,73.26 89.07,43.6 84.54,39.07 v2(84.54,35.93) 84.54,35.33 86.97,32.91 89.78,32.91 94.38,28.31 95.37,28.31 104.28,19.4 106.51,19.4 106.95,18.95 v2(130.12,18.95)
  BOTTOM w0.102: v2(130.12,18.95) 129.54,19.53 128.89,19.53 128.64,19.78 127.66,19.78 127.3,19.42 DB1.3 ; v2(187.23,63.55) 184.52,63.55 183.21,62.25 174.75,62.25 172.89,64.1 169.85,64.1 v2(169.55,64.39) ; UL1.19 172.74,102.96 v2(172.65,103.05) ; v2(163.25,64.53) 162.75,64.53 162.65,64.43 161.04,64.43 160.6,64.88 158.4,64.88 157.65,64.13 156.52,64.13 156.29,63.9 154.03,63.9 151.61,66.32 101.35,66.32 89.4,78.28 89.4,79.15 v2(87.75,80.8)
PCH_RSMRST#: length 103
  TOP w0.102: v2(156.9,68.51) 156.74,68.51 156.05,67.82 UC11.1 ; v2(136.52,16.44) 135.38,16.44 134.97,16.03 134.97,13.49 134.3,12.82 134.3,11.73 133.47,10.9 133.47,9.14 132.88,8.55 UE5.88 129.55,8.55 v1(129.25,8.85) 128.96,9.14 125.6,9.14 124.96,9.77 124.12,9.77 RE359.1
  IN1 w0.089: v2(136.52,16.44) 136.96,16.88 139.44,16.88 140.98,18.43 146.78,18.43 148.73,20.38 153.33,20.38 153.67,20.73 158.16,20.73 160.88,23.46 161.79,23.46 164.02,25.68 164.02,35.78 164.09,35.85 164.09,44.8 163.63,45.26 163.63,50.34 160.92,53.06 160.92,57.41 161.56,58.05 161.56,59.72 162.85,61.02 162.85,65.76 161.19,67.43 157.8,67.43 156.9,68.32 v2(156.9,68.51)
PCH_RSMRST#_Q: length 35.9
  TOP w0.102: RC396.1 154.68,63.22 154.68,64.44 v2(155,64.76) ; RPC11.3 157.54,64.57 157.03,65.08 157.03,65.75 v2(157.22,65.94) 157.5,65.94 157.85,65.59 T4962.1 RC55.1 157.98,66.52 UC11.4
  BOTTOM w0.076: UC1.AY17 142.36,81.13 142.26,81.02 142.16,80.91 142.09,80.7 142.09,80.58 142.15,80.35 142.15,80.21 142.1,80.11 142.1,78.67 141.98,78.54 141.98,77.92 142.68,77.22
  BOTTOM w0.102: v2(157.22,65.94) 156.18,65.94 v2(155,64.76) 154.68,65.08 154.68,65.97 153.29,67.36 151.07,67.36 149.35,69.08 145.34,69.08 143.35,71.08 143.35,74.57 142.68,75.24 142.68,77.22
PCH_RTCRST#: length 21
  TOP w0.102: QC1.1 149.54,71.11 v1(149.35,71.3) 149.35,72.08 RC93.2 148.25,73.17 CC11.2 148.25,75.23 v2(148.65,75.62) 148.65,76.5 143.68,81.47 143.68,81.88 143.93,82.13 143.93,85.51 143.55,85.89 v2(143.5,85.89)
  BOTTOM w0.076: UC1.AM16 143.04,86.35 v2(143.5,85.89)
  BOTTOM w0.102: CLRP2.2 148.39,75.37 v2(148.65,75.62)
PCH_RTCX1: length 21
  IN1 w0.076: v2(153.16,84) 153.03,83.87 151.63,83.87 149.49,86.01 149.49,86.31 148.72,87.08 145.09,87.08 144.97,86.95 143.41,86.95 142.66,86.2 v2(142.66,86)
  BOTTOM w0.076: UC1.AM18 142.26,86.35 v2(142.66,86) ; 154.87,84.88 RC98.1 154.03,84.88 v2(153.16,84)
  BOTTOM w0.102: 154.87,84.88 154.92,84.93 CC15.1 155.67,84.51 156.54,84.51 v1(156.72,84.33) 157.84,83.2 158.43,83.2 158.87,82.76 YC2.1
PCH_RTCX2: length 22
  IN1 w0.076: v2(152.58,84.26) 151.5,84.26 149.66,86.1 149.66,86.37 148.79,87.24 145.02,87.24 144.9,87.12 143.34,87.12 142.7,86.48 142.18,86.48 v2(141.7,85.99)
  BOTTOM w0.076: 154.87,85.77 154.32,85.77 RC98.2 154.12,85.79 v2(152.58,84.26) ; UC1.AM20 141.33,86.35 v2(141.7,85.99)
  BOTTOM w0.102: YC2.2 158.87,83.94 158.62,83.68 158.04,83.68 156.65,85.08 156.25,85.08 CC16.1 154.87,85.77
PCH_SMBCLK: length 100.4
  IN1 w0.102: v2(160.65,93.27) 160.65,92.64 161.05,92.23 164.29,92.23 164.51,92.02 166.04,92.02 171.21,86.84 171.21,77.54 172.28,76.47 172.28,67.71 168.65,64.08 168.65,60.8 169.86,59.6 169.86,58.28 167.7,56.13 167.7,53.58 168.64,52.64 168.64,48.42 168.39,48.18 168.2,48.18 v2(167.98,47.96)
  BOTTOM w0.102: v2(160.65,93.27) 160.65,93.67 RC390.2 161.02,93.65 161.08,93.59 QC2.1 ; JDIMM2.202 171.25,27.69 171.06,27.88 171.06,31.61 173.26,33.81 173.26,35.89 171.32,37.84 158.81,37.84 158.66,37.98 158.66,38.16 158.85,38.35 JDIMM1.202 158.85,40.65 158.66,40.84 158.66,41.25 159.72,42.31 161.56,42.31 167.39,48.13 167.8,48.13 v2(167.98,47.96)
PCH_SMBDAT: length 98.6
  IN1 w0.102: v2(167.98,48.54) 168.11,48.41 168.3,48.41 168.41,48.52 168.41,52.54 167.47,53.48 167.47,56.22 169.63,58.38 169.63,59.5 168.42,60.71 168.42,64.18 172.05,67.81 172.05,76.38 170.99,77.44 170.99,86.75 165.94,91.79 164.41,91.79 164.2,92 163.32,92 163.06,91.75 v2(162.93,91.75)
  BOTTOM w0.102: v2(162.93,91.75) 162.93,89.97 162.62,89.65 RC391.2 162.12,90.48 QC2.4 ; JDIMM2.200 170.65,27.69 170.84,27.88 170.84,31.71 173.03,33.9 173.03,35.8 171.22,37.61 158.71,37.61 158.44,37.89 158.44,38.16 158.25,38.35 JDIMM1.200 158.25,40.65 158.44,40.84 158.44,41.35 159.63,42.54 161.47,42.54 167.29,48.36 167.8,48.36 v2(167.98,48.54)
PCH_SPI_CLK: length 8.7
  BOTTOM w0.076: 153.03,81.91 153.03,82.47 152.75,82.76 151.41,82.76 UC1.AV2
  BOTTOM w0.102: 153.03,81.91 154.49,80.45 157.06,80.45 157.25,80.26 157.78,80.26 RC59.1
PCH_SPI_CLK_R: length 7.7
  TOP w0.102: RPC5.3 181.79,22.15 181.22,21.58 CC9.1 181.97,21.28 v3(182.37,20.88) 182.75,20.5 v2(182.87,20.5)
  BOTTOM w0.102: UC2.6 182.87,19.74 183,19.87 183.44,19.87 183.57,19.99 183.57,20.25 183.44,20.37 183,20.37 v2(182.87,20.5)
PCH_SPI_D0: length 9
  BOTTOM w0.076: UC1.AV3 150.51,82.47 150.51,81.82 150.66,81.67 151.75,81.67 151.95,81.47 152.45,81.47 152.52,81.4 152.52,80.58
  BOTTOM w0.102: RC58.1 RC44.1 155.21,78.69 154.4,78.69 152.52,80.58
PCH_SPI_D0_R: length 9.1
  TOP w0.102: RPC5.2 181.29,22.65 v2(180.96,22.32) 180.96,22.08 180.71,21.84 180.21,21.84 v3(179.95,21.58)
  BOTTOM w0.102: v2(180.96,22.32) 182.64,22.32 184.14,20.82 UC2.5
PCH_SPI_D1: length 8.7
  BOTTOM w0.076: UC1.AW3 151.09,82.21 152.29,82.21 153.22,81.27
  BOTTOM w0.102: 153.22,81.27 153.34,81.27 153.47,81.15 153.47,80.89 153.33,80.75 153.33,80.59 153.45,80.47 153.62,80.47 153.75,80.6 153.9,80.6 154.04,80.46 154.04,80.31 153.84,80.12 153.84,79.95 153.96,79.83 154.13,79.83 154.33,80.03 154.81,80.03 154.93,79.9 154.93,79.34 155.03,79.24 155.24,79.24 155.34,79.34 155.34,79.84 155.44,79.94 RC57.1
PCH_SPI_D1_R: length 9.5
  TOP w0.102: v3(178.49,22.53) 179.13,22.53 179.36,22.3 v2(180.38,22.3) 180.38,22.45 180.79,22.86 RPC5.1
  BOTTOM w0.102: UC2.2 181.6,23.49 181.73,23.36 182.11,23.36 182.24,23.23 182.24,22.98 182.11,22.85 180.5,22.85 180.38,22.72 v2(180.38,22.3)
PCH_SPI_D2: length 9.9
  BOTTOM w0.076: UC1.AW2 151.58,82.04 152.22,82.04 152.71,81.55 152.71,80.76 154.55,78.92 154.87,78.92
  BOTTOM w0.102: 154.87,78.92 RC21.1 156.38,79.43 157.16,79.43 157.66,78.92 RC52.1 RC47.1
PCH_SPI_D2_R: length 7.4
  TOP w0.102: RC61.2 184.27,25.12 184.4,25 v1(184.4,24.12) 184.4,23.04 184.27,22.91 183,22.91 182.87,23.04 v2(182.87,24.5)
  BOTTOM w0.102: JC1.3 UC2.3 v2(182.87,24.5)
PCH_SPI_D3: length 10.7
  BOTTOM w0.076: 154.87,81.86 154.68,81.86 154.61,81.78 154.61,81.42 154.52,81.33 154.39,81.33 154.3,81.42 154.3,82.22 154.21,82.31 154.09,82.31 154,82.22 154,81.55 153.91,81.46 153.78,81.46 153.69,81.55 153.69,82.1 153.57,82.22 153.33,82.22 153.21,82.35 153.21,82.53 152.81,82.93 151.25,82.93 151.12,82.8 150.16,82.8 150.04,82.91 150.04,83.09 UC1.AU4
  BOTTOM w0.102: 154.87,81.86 RC60.1 155.82,81.86 RC48.1 RC51.1
PCH_SPI_D3_R: length 7.5
  TOP w0.102: v2(182.87,21.2) 182.87,21.71 182.29,22.29 v1(182.29,22.47) RPC5.4
  BOTTOM w0.102: UC2.7 181.6,19.93 181.48,20.06 181.22,20.06 181.1,20.18 181.1,21.07 181.22,21.2 v2(182.87,21.2)
PCI_CLK_LPC1: length 20.8
  TOP w0.102: RC54.1 RC45.1 v2(160.27,70.78)
  BOTTOM w0.076: UC1.AY9 147.2,81.29 146.87,80.95 146.87,79.86 148.19,78.54 148.76,78.54 150.16,77.14
  BOTTOM w0.102: v2(160.27,70.78) 160.27,71.75 v1(159.95,72.07) 158.29,73.73 154.09,73.73 151.64,76.17 151.13,76.17 150.16,77.14
PCIE_CRX_C_GTX_N1: length 9.2
  BOTTOM w0.076: UV1.AB9 69.12,67.91 69.04,67.83 68.87,67.83 68.64,67.6 68.64,64.57 68.55,64.48 67.98,64.48 67.62,64.12 67.62,63.65 67.31,63.34 67.31,63.3 67.29,63.28 67.29,63.2 67.28,63.18 67.28,63.17
  BOTTOM w0.127: CV12.2 67.56,60.56 67.56,61.08 67.28,61.36 67.28,63.17
PCIE_CRX_C_GTX_N2: length 9.3
  BOTTOM w0.076: 66.65,63.17 66.65,63.2 67.15,63.71 67.15,65.72 67.35,65.92 67.74,65.92 68,66.18 68,67.56 68.1,67.66 68.24,67.66 68.32,67.59 UV1.AC10
  BOTTOM w0.127: CV14.2 66,60.57 66,61.66 66.69,62.35 66.69,63.06 66.67,63.08 66.67,63.15 66.65,63.17 66.65,63.17
PCIE_CRX_C_GTX_N3: length 9.4
  BOTTOM w0.076: UV1.AC11 67.48,67.09 67.4,67.01 67.22,67.01 66.99,66.77 66.99,66.28 66.79,66.08 65.56,66.08 65.32,65.85 65.32,63.25 65.27,63.19 65.27,63.17
  BOTTOM w0.127: 65.27,63.17 65.27,62.86 63.96,61.55 63.96,60.55 CV16.2
PCIE_CRX_C_GTX_N4: length 11.2
  BOTTOM w0.076: UV1.AB12 66.28,67.68 63.87,67.68 63.68,67.49 63.68,63.27 63.6,63.19 63.6,63.17
  BOTTOM w0.114: 63.6,63.17 63.6,63.1
  BOTTOM w0.127: 63.6,63.1 62.1,61.59 62.1,60.46 CV18.2
PCIE_CRX_C_GTX_P1: length 9.2
  BOTTOM w0.076: 67.56,63.17 67.55,63.19 67.55,63.31 67.85,63.61 67.85,64.12 68.05,64.32 68.62,64.32 68.8,64.5 68.8,67.53 68.94,67.66 69.04,67.66 69.12,67.59 UV1.AC9
  BOTTOM w0.127: CV11.2 67.85,60.57 67.85,61.2 67.56,61.48 v4(67.56,61.84) 67.56,63.17
PCIE_CRX_C_GTX_P2: length 9.3
  BOTTOM w0.076: UV1.AB10 68.32,67.91 68.24,67.83 68.04,67.83 67.84,67.63 67.84,66.25 67.67,66.08 67.28,66.08 66.99,65.79 66.99,63.87 66.41,63.3 66.41,63.17
  BOTTOM w0.127: 66.41,63.17 66.41,62.48 65.72,61.78 v4(65.72,61.33) 65.72,60.53 CV13.2
