# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_DQS0: length 66.9
  IN1 w0.102: v2(107.34,85.82) 107.18,85.98 107.18,86.22 106.89,86.51 100.4,86.51 96.99,83.09 96.99,79.1 99.39,76.7 99.39,55.28 99.62,55.05 99.62,54.55 99.39,54.32 99.39,53.83 99.62,53.61 99.71,53.61 99.82,53.5 99.82,53.2 99.71,53.1 99.62,53.1 99.39,52.87 99.39,52.39 99.62,52.16 99.71,52.16 99.82,52.06 99.82,51.75 99.71,51.65 99.62,51.65 99.39,51.42 99.39,47.3 98.81,46.72 98.81,43.46 98.66,43.31 98.41,43.31 v2(98.29,43.43)
  BOTTOM w0.076: UC1.AM69 112.97,86.24 112.81,86.4 112.8,86.42 112.74,86.51 112.65,86.55 112.56,86.59 112.34,86.59 112.2,86.53 112.06,86.53 111.88,86.59 111.7,86.59 111.57,86.54 111.56,86.53 111.31,86.53 111.16,86.69 110.18,86.69 109.85,86.36 109.49,86.36 108.52,85.38 107.18,85.38 106.98,85.58 106.98,85.75 107.05,85.82 v2(107.34,85.82)
  BOTTOM w0.102: JDIMM1.12 99.45,40.47 99.1,40.82 99.1,42.67 98.71,43.06 98.46,43.06 98.29,43.22 v2(98.29,43.43)
DDR_A_DQS1: length 52.4
  IN1 w0.102: v2(107.25,81.18) 107.31,81.24 107.31,81.42 107.21,81.53 106.92,81.53 106.61,81.22 106.61,77.51 105.13,76.04 105.13,53.37 104.9,53.14 104.55,53.14 104.45,53.04 104.45,52.73 104.55,52.63 104.9,52.63 105.13,52.4 105.13,51.91 104.87,51.65 104.6,51.65 104.45,51.5 104.45,46.5 104.26,46.3 104.26,44.81 103.97,44.52 103.64,44.52 103.53,44.41 v2(103.53,44.19)
  BOTTOM w0.076: v2(107.25,81.18) 107.42,81.35 107.42,81.94 107.88,82.39 108.51,82.39 108.72,82.6 109.2,82.6 110.02,83.41 110.95,83.41 111.11,83.58 111.6,83.58 111.61,83.56 111.73,83.51 111.83,83.51 112.02,83.57 112.25,83.57 112.39,83.5 112.51,83.5 112.68,83.58 112.7,83.6 112.7,83.75 112.66,83.79 UC1.AT70
  BOTTOM w0.102: v2(103.53,44.19) 103.76,44.42 104.43,44.42 104.66,44.65 104.66,46.3 104.55,46.41 JDIMM1.29
DDR_A_DQS2: length 49.4
  IN1 w0.102: v2(110.04,74.49) 109.45,74.49 109.25,74.28 109.25,53.44 108.98,53.17 108.98,52.62 109.24,52.36 109.24,51.98 108.98,51.72 108.98,51.17 109.24,50.91 109.24,50.53 108.98,50.27 108.98,49.88 109.24,49.62 109.24,49.09 108.98,48.83 108.98,48.27 109.24,48.01 109.24,47.64 108.98,47.38 108.98,46.82 109.24,46.57 109.24,46.19 108.98,45.93 108.98,44.19 109.19,43.98 109.54,43.98 v2(109.64,43.88)
  BOTTOM w0.076: 113.27,78.06 114.48,78.06 115.37,78.96 115.37,79.69 115.5,79.82 115.5,80.09 115.44,80.2 115.44,80.4 115.5,80.56 115.5,80.7 115.46,80.8 115.46,81.1 115.54,81.27 115.65,81.38 115.75,81.38 115.79,81.42 UC1.AY64
  BOTTOM w0.102: 113.27,78.06 111.45,78.06 111.01,77.62 111.01,76.07 110.68,75.73 110.68,74.49 110.39,74.21 110.2,74.21 110.04,74.36 v2(110.04,74.49) ; JDIMM1.47 109.95,46.08 110.32,45.71 110.32,44.34 110.08,44.11 109.87,44.11 v2(109.64,43.88)
DDR_A_DQS3: length 48.4
  IN1 w0.102: v2(115.98,76.3) 115.78,76.1 115.11,76.1 114.48,75.48 114.48,72.2 113.4,71.12 113.4,50.24 115.53,48.11 115.53,45.29 115.43,45.19 115.26,45.19 115.04,44.98 115.04,44.47 115.26,44.25 115.43,44.25 115.53,44.15 115.53,43.13 115.42,43.02 115.08,43.02 v2(114.98,43.12)
  BOTTOM w0.076: UC1.BA60 118.16,81.05 118.16,81.24 118.23,81.31 118.34,81.31 118.45,81.2 118.54,81.02 118.54,80.91 118.47,80.75 118.47,80.56 118.52,80.38 118.53,80.33 118.53,80.24 118.47,80.11 118.47,79.75 118.64,79.58 118.64,79.29 118.32,78.98 118.32,78.79 116.35,76.82 116.35,76.15 116.24,76.03 116.09,76.03 115.98,76.15 v2(115.98,76.3)
  BOTTOM w0.102: v2(114.98,43.12) 114.98,42.89 115.14,42.73 115.37,42.73 115.61,42.49 115.61,41.12 115.05,40.56 JDIMM1.64
DDR_A_DQS4: length 49.8
  IN1 w0.102: v2(130.66,74.79) 130.89,75.01 131.02,75.01 131.13,74.9 131.13,72.12 130.95,71.93 130.95,70.49 130.43,69.98 130.43,63.07 137.9,55.6 137.9,47.96 138.12,47.73 138.42,47.73 138.52,47.63 138.52,47.32 138.42,47.22 138.12,47.22 137.9,46.99 137.9,46.51 138.12,46.28 138.42,46.28 138.52,46.18 138.52,45.88 138.42,45.77 138.12,45.77 137.9,45.55 137.9,44.17 138.12,43.95 138.4,43.95 v2(138.72,43.63)
  BOTTOM w0.076: v2(130.66,74.79) 130.46,74.99 130.29,74.99 130.02,75.27 130.02,78.07 130.27,78.32 130.27,78.93 130.08,79.12 130.08,79.54 130.22,79.68 130.22,80.08 130.17,80.22 130.17,80.4 130.23,80.55 130.23,80.72 130.18,80.83 130.18,81.08 130.23,81.21 130.31,81.35 UC1.AY38
  BOTTOM w0.102: JDIMM1.137 139.35,46.1 139.57,45.89 139.57,44.06 139.34,43.83 138.93,43.83 v2(138.72,43.63)
DDR_A_DQS5: length 50.2
  IN1 w0.102: v2(134.22,72.84) 134.22,73.03 134.13,73.12 134.07,73.12 133.97,73.22 133.85,73.22 133.77,73.13 133.77,69.99 134.93,68.82 134.93,64.03 143.27,55.69 143.27,53.23 143.86,52.64 143.86,42.43 143.95,42.35 144.05,42.35 144.21,42.51 144.33,42.51 144.38,42.56 v2(144.38,42.87)
  BOTTOM w0.076: UC1.BA34 132.97,81.17 133.03,81.23 133.12,81.23 133.16,81.21 133.21,81.13 133.25,81.03 133.25,80.89 133.19,80.75 133.19,80.55 133.26,80.36 133.26,80.24 133.2,80.12 133.2,79.01 133.4,78.81 133.4,73.25 133.66,72.99 134.07,72.99 v2(134.22,72.84)
  BOTTOM w0.102: v2(144.38,42.87) 144.38,42.7 144.51,42.57 144.86,42.57 145.06,42.38 145.06,40.98 144.45,40.37 JDIMM1.154
DDR_A_DQS6: length 49.8
  IN1 w0.102: v2(149.95,43.76) 149.95,43.89 149.79,44.05 149.33,44.05 148.97,44.41 148.97,46.27 148.1,47.13 148.1,53.56 147.31,54.36 147.31,57.02 138.36,65.96 138.36,68.64 136.68,70.33 136.68,74.81 136.48,75.02 136.32,75.02 v2(136.1,74.79)
  BOTTOM w0.076: UC1.AY30 135.39,81.47 135.34,81.41 135.3,81.35 135.21,81.21 135.16,81.09 135.16,80.83 135.2,80.73 135.2,80.53 135.15,80.42 135.15,80.2 135.2,80.09 135.2,79.48 135.17,79.45 135.17,78.91 135.44,78.65 135.44,75.23 135.72,74.95 135.94,74.95 v2(136.1,74.79)
  BOTTOM w0.102: v2(149.95,43.76) 150.15,43.96 150.3,43.96 150.61,44.26 150.61,45.36 149.55,46.41 JDIMM1.171
DDR_A_DQS7: length 52.4
  IN1 w0.102: v2(139.68,72.84) 139.9,73.06 140.36,73.06 140.44,72.98 140.44,71.12 141.95,69.61 141.95,68.78 142.37,68.36 143.59,67.14 143.59,66.58 144.1,66.07 144.67,66.07 144.95,65.78 144.95,64.53 151.75,57.74 151.75,51.06 154.44,48.36 154.44,42.62 154.65,42.41 155.16,42.41 155.31,42.27 v2(155.31,42.1)
  BOTTOM w0.076: v2(139.68,72.84) 139.52,73 139.19,73 138.65,73.54 138.65,77.93 138.39,78.19 138.39,79.52 138.18,79.73 138.18,80.11 138.24,80.24 138.24,80.36 138.17,80.54 138.17,80.75 138.23,80.88 138.23,81.04 138.19,81.13 138.14,81.21 138.1,81.23 138.01,81.23 137.95,81.17 UC1.BA26
  BOTTOM w0.102: v2(155.31,42.1) 155.03,42.38 154.39,42.38 154.18,42.17 154.18,41 154.65,40.53 JDIMM1.188
DDR_A_DQS#0: length 66.9
  IN1 w0.102: v2(98.29,42.67) 98.29,42.97 98.35,43.02 98.46,43.02 98.53,43.1 98.75,43.1 99.03,43.37 99.03,46.63 99.61,47.21 99.61,51.33 99.71,51.43 99.8,51.43 100.03,51.66 100.03,52.15 99.8,52.37 99.71,52.37 99.61,52.47 99.61,52.78 99.71,52.88 99.8,52.88 100.03,53.11 100.03,53.59 99.8,53.82 99.71,53.82 99.61,53.92 99.61,54.23 99.84,54.46 99.84,55.14 99.61,55.37 99.61,76.79 97.2,79.19 97.2,83.01 100.49,86.3 106.8,86.3 106.97,86.13 106.97,85.67 106.88,85.58 106.7,85.58 106.54,85.73 v2(106.54,85.82)
  BOTTOM w0.076: v2(106.54,85.82) 106.69,85.82 106.79,85.72 106.79,85.51 107.1,85.2 108.59,85.2 109.57,86.18 109.93,86.18 110.28,86.52 111.09,86.52 111.24,86.37 111.59,86.37 111.63,86.38 111.74,86.43 111.85,86.43 112.03,86.36 112.23,86.36 112.38,86.43 112.53,86.43 112.63,86.38 112.68,86.3 112.68,86.21 112.61,86.14 UC1.AM70
  BOTTOM w0.102: JDIMM1.10 98.85,40.78 98.89,40.82 98.89,42.58 98.63,42.85 98.47,42.85 v2(98.29,42.67)
DDR_A_DQS#1: length 52.4
  IN1 w0.102: v2(103.53,44.95) 103.75,44.73 103.88,44.73 104.04,44.9 104.04,46.39 104.24,46.59 104.24,51.59 104.51,51.87 104.78,51.87 104.91,52 104.91,52.31 104.81,52.41 104.46,52.41 104.24,52.64 104.24,53.13 104.46,53.35 104.81,53.35 104.91,53.45 104.91,76.13 106.39,77.6 106.39,81.31 106.83,81.74 107.3,81.74 107.54,81.5 v2(107.84,81.5)
  BOTTOM w0.076: v2(107.84,81.5) 107.61,81.73 107.61,81.86 107.96,82.21 108.59,82.21 108.79,82.41 109.28,82.41 110.09,83.23 111.02,83.23 111.19,83.4 111.58,83.4 111.69,83.34 111.86,83.34 112.04,83.4 112.21,83.4 112.35,83.34 112.55,83.34 112.78,83.45 112.87,83.53 112.87,83.73 112.92,83.79 UC1.AT69
  BOTTOM w0.102: JDIMM1.27 103.95,46.35 104.02,46.28 104.32,46.28 104.45,46.16 104.45,44.74 104.34,44.63 103.64,44.63 103.53,44.74 v2(103.53,44.95)
DDR_A_DQS#2: length 49.4
  IN1 w0.102: v2(109.64,44.64) 109.64,44.34 109.59,44.28 109.48,44.28 109.39,44.2 109.28,44.2 109.2,44.28 109.2,45.84 109.45,46.1 109.45,46.65 109.2,46.91 109.2,47.29 109.45,47.55 109.45,48.1 109.2,48.36 109.2,48.74 109.45,49 109.45,49.71 109.2,49.97 109.2,50.18 109.45,50.44 109.45,51 109.2,51.26 109.2,51.63 109.45,51.89 109.45,52.45 109.2,52.71 109.2,53.08 109.46,53.35 109.46,74.19 109.54,74.28 109.74,74.28 109.89,74.13 109.97,74.13 110.04,74.05 v2(110.04,73.84)
  BOTTOM w0.076: 113.36,77.86 114.51,77.86 115.54,78.89 115.54,79.62 115.66,79.75 115.66,80.13 115.61,80.24 115.61,80.37 115.67,80.53 115.67,80.74 115.63,80.83 115.63,81.07 115.67,81.17 115.72,81.21 115.85,81.21 115.9,81.17 UC1.BA64
  BOTTOM w0.102: v2(110.04,73.84) 110.21,74.01 110.47,74.01 110.87,74.41 110.87,75.65 111.21,75.99 111.21,77.54 111.53,77.86 113.27,77.86 113.27,77.86 113.36,77.86 ; v2(109.64,44.64) 109.64,44.52 109.85,44.31 110,44.31 110.11,44.43 110.11,45.63 109.74,45.99 109.74,46.49 109.67,46.56 109.41,46.56 109.35,46.62 JDIMM1.45
DDR_A_DQS#3: length 48.4
  IN1 w0.102: v2(114.98,42.35) 114.98,42.63 115.06,42.71 115.15,42.71 115.24,42.8 115.51,42.8 115.75,43.04 115.75,44.24 115.52,44.47 115.35,44.47 115.26,44.56 115.26,44.89 115.35,44.98 115.52,44.98 115.75,45.2 115.75,48.2 113.62,50.33 113.62,71.04 114.7,72.11 114.7,75.39 115.2,75.89 115.74,75.89 v2(115.98,75.65)
  BOTTOM w0.076: v2(115.98,75.65) 116.19,75.87 116.3,75.87 116.52,76.08 116.52,76.75 118.49,78.72 118.49,78.91 118.8,79.23 118.8,79.65 118.63,79.82 118.63,80.07 118.7,80.21 118.7,80.36 118.68,80.43 118.63,80.59 118.63,80.71 118.7,80.88 118.7,81.05 118.59,81.3 118.35,81.54 UC1.AY60
  BOTTOM w0.102: JDIMM1.62 114.45,40.39 114.67,40.61 114.8,40.61 115.4,41.2 115.4,42.41 115.29,42.52 115.14,42.52 v2(114.98,42.35)
DDR_A_DQS#4: length 49.8
  IN1 w0.102: v2(130.66,75.44) 130.9,75.21 131.1,75.21 131.32,74.98 131.32,72.04 131.16,71.88 131.16,70.4 130.65,69.89 130.65,63.16 138.11,55.69 138.11,48.05 138.21,47.95 138.51,47.95 138.74,47.72 138.74,47.23 138.51,47.01 138.21,47.01 138.11,46.9 138.11,46.6 138.21,46.5 138.51,46.5 138.74,46.27 138.74,45.79 138.51,45.56 138.21,45.56 138.11,45.46 138.11,44.26 138.21,44.16 138.52,44.16 138.72,44.36 v2(138.72,44.39)
  BOTTOM w0.076: v2(130.66,75.44) 130.66,75.3 130.52,75.16 130.36,75.16 130.18,75.34 130.18,78.01 130.43,78.26 130.43,78.99 130.24,79.18 130.24,79.47 130.39,79.61 130.39,80.11 130.33,80.25 130.33,80.37 130.4,80.52 130.4,80.75 130.34,80.87 130.34,81.05 130.38,81.13 130.43,81.21 130.48,81.29 130.63,81.32 130.7,81.28 130.7,81.14 UC1.BA38
  BOTTOM w0.102: JDIMM1.135 138.75,46.41 139.36,45.8 139.36,44.15 139.25,44.04 138.8,44.04 138.72,44.12 v2(138.72,44.39)
DDR_A_DQS#5: length 50.3
  IN1 w0.102: v2(134.22,73.49) 134.14,73.41 133.74,73.41 133.55,73.22 133.55,69.9 134.72,68.73 134.72,63.94 143.06,55.6 143.06,53.14 143.65,52.55 143.65,42.34 143.86,42.13 144.35,42.13 v2(144.38,42.1)
  BOTTOM w0.076: UC1.AY34 133.07,81.48 133.16,81.4 133.23,81.37 133.24,81.36 133.27,81.34 133.3,81.3 133.36,81.21 133.42,81.07 133.42,80.85 133.35,80.71 133.35,80.58 133.42,80.39 133.42,80.21 133.36,80.08 133.36,79.08 133.56,78.88 133.56,73.34 133.73,73.17 134.04,73.17 134.22,73.35 v2(134.22,73.49)
  BOTTOM w0.102: v2(144.38,42.1) 144.64,42.37 144.78,42.37 144.85,42.29 144.85,41.07 144.5,40.71 144.02,40.71 143.85,40.54 JDIMM1.152
DDR_A_DQS#6: length 49.8
  IN1 w0.102: v2(136.1,75.44) 136.33,75.21 136.56,75.21 136.9,74.87 136.9,70.42 138.58,68.73 138.58,66.05 147.52,57.11 147.52,54.45 148.32,53.65 148.32,47.22 149.18,46.36 149.18,44.5 149.42,44.26 149.69,44.26 v2(149.95,44.52)
  BOTTOM w0.076: UC1.BA30 135.65,81.14 135.64,81.23 135.56,81.31 135.48,81.31 135.43,81.25 135.36,81.13 135.33,81.06 135.33,80.86 135.37,80.77 135.37,80.49 135.31,80.38 135.31,80.24 135.37,80.13 135.37,79.41 135.34,79.38 135.34,78.98 135.6,78.72 135.6,75.3 135.79,75.11 135.9,75.11 136.1,75.31 v2(136.1,75.44)
  BOTTOM w0.102: JDIMM1.169 148.95,46.69 149.03,46.61 149.23,46.61 149.3,46.54 149.3,46.37 150.4,45.27 150.4,44.35 150.22,44.17 150.01,44.17 149.95,44.23 v2(149.95,44.52)
DDR_A_DQS#7: length 52.4
  IN1 w0.102: v2(155.31,42.87) 155.06,42.63 154.74,42.63 154.66,42.71 154.66,48.45 151.96,51.15 151.96,57.83 145.17,64.62 145.17,65.87 144.76,66.28 144.19,66.28 143.81,66.67 143.81,67.23 142.52,68.52 142.17,68.87 142.17,69.7 140.66,71.21 140.66,73.07 140.45,73.27 139.9,73.27 v2(139.68,73.49)
  BOTTOM w0.076: v2(139.68,73.49) 139.68,73.38 139.47,73.17 139.26,73.17 138.82,73.61 138.82,77.99 138.56,78.25 138.56,79.59 138.34,79.8 138.34,80.08 138.4,80.21 138.4,80.39 138.34,80.57 138.34,80.72 138.39,80.85 138.39,81.07 138.34,81.21 138.26,81.34 138.21,81.36 138.21,81.37 138.13,81.4 138.05,81.48 UC1.AY26
  BOTTOM w0.102: v2(155.31,42.87) 155.02,42.58 154.31,42.58 153.98,42.25 153.98,40.91 154.05,40.84 JDIMM1.186
DDR_A_MA0: length 46.8
  IN1 w0.089: v2(122.09,72.02) 122.09,68.75 121.66,68.32
  IN1 w0.132: v2(128,41.03) 127.62,41.03 127.18,41.46 127.18,42.47 126.51,43.15 126.51,50.38 123.27,53.62 123.27,53.97 121.35,55.88 121.35,56.01 121.66,56.32 121.66,56.55 121.09,57.12 121.09,67.75 121.66,68.32
  BOTTOM w0.076: v2(122.09,72.02) 123.06,72.98 123.06,76.32 123.5,76.76 123.5,78.1 124.33,78.93 124.33,80.37 124.13,80.58 124.13,80.83 123.99,80.97 123.99,81.16 UC1.AY50
  BOTTOM w0.165: JDIMM1.98 127.65,40.68 v2(128,41.03)
DDR_A_MA1: length 47
  IN1 w0.089: 122.55,67.62 122.87,67.94 122.87,74.44 v2(122.09,75.22)
  IN1 w0.132: v2(127.96,46.24) 128.28,46.56 128.28,51.57 128.12,51.73 127.93,51.73 127.47,51.26 127.28,51.26 127.1,51.45 127.1,51.64 127.56,52.1 127.56,52.29 127.37,52.47 127.19,52.47 126.72,52.01 126.54,52.01 126.35,52.2 126.35,52.38 126.81,52.85 126.81,53.03 126.63,53.22 126.44,53.22 125.98,52.76 125.79,52.76 125.6,52.94 125.6,53.13 126.07,53.59 126.07,53.78 125.88,53.97 125.69,53.97 125.23,53.5 125.04,53.5 124.85,53.69 124.85,53.88 125.32,54.34 125.32,54.53 125.13,54.72 124.94,54.72 124.85,54.62 124.67,54.62 124.47,54.81 124.47,54.99 124.57,55.09 124.57,55.28 122.25,57.6 122.25,67.32 122.55,67.62
  BOTTOM w0.076: 123.01,77.22 123.12,77.33 123.12,78.35 123.95,79.18 123.95,79.9 UC1.BB50
  BOTTOM w0.089: 123.01,77.22 v1(122.74,76.95) 122.48,76.7 122.48,75.61 v2(122.09,75.22)
  BOTTOM w0.165: JDIMM1.97 127.35,46.65 127.17,46.47 127.17,46.12 127.35,45.94 127.66,45.94 v2(127.96,46.24)
DDR_A_MA2: length 49.1
  IN1 w0.076: v2(122.1,73.21) 122.45,72.86 122.45,68.54 122.07,68.16
  IN1 w0.132: 122.07,68.16 121.48,67.56 121.48,57.28 122.27,56.48 122.27,56.29 121.98,56 121.98,55.81 122.16,55.62 122.35,55.62 122.65,55.92 122.83,55.92 123.02,55.73 123.02,55.55 122.72,55.25 122.72,55.06 122.91,54.88 123.1,54.88 123.39,55.17 123.58,55.17 123.66,55.1 123.66,53.78 126.89,50.54 126.89,43.4 v2(127.96,42.34)
  BOTTOM w0.076: 121.51,76.22 121.51,76.73 122.77,77.99 122.77,79.56 122.97,79.76 122.97,80.12 122.97,80.12 122.94,80.21 122.94,80.41 122.97,80.5 122.97,80.5 122.97,80.5 122.98,80.51 122.98,80.64 122.97,80.64 122.97,80.76 122.91,80.95 122.91,81.18 123.24,81.52 UC1.AY51
  BOTTOM w0.102: 121.51,76.22 121.51,75.37 121.67,75.21 121.67,73.64 v2(122.1,73.21)
  BOTTOM w0.165: v2(127.96,42.34) 127.48,42.34 127.05,41.91 JDIMM1.96
DDR_A_MA3: length 48.2
  IN1 w0.089: 122.17,67.75 122.67,68.24 122.67,73.88 v2(122.09,74.46)
  IN1 w0.132: 122.17,67.75 121.86,67.44 121.86,57.44 124.04,55.26 124.04,53.94 127.32,50.66 127.32,50.52 127.46,50.39 127.75,50.39 127.88,50.26 127.88,49.99 127.75,49.86 127.46,49.86 127.32,49.73 127.32,49.46 127.46,49.33 127.75,49.33 127.88,49.2 127.88,48.94 127.75,48.8 127.46,48.8 127.32,48.67 127.32,48.41 127.46,48.27 127.75,48.27 127.88,48.14 127.88,47.88 127.75,47.75 127.46,47.75 127.32,47.61 127.32,47.35 127.46,47.22 127.75,47.22 127.88,47.09 127.88,46.82 127.75,46.69 127.46,46.69 127.32,46.56 127.32,44.48 127.45,44.36 127.83,44.36 127.96,44.48 v2(127.96,44.72)
  BOTTOM w0.076: 123.29,77.04 123.29,78.27 124.17,79.15 124.17,80.09 123.87,80.39 UC1.BA50
  BOTTOM w0.089: v2(122.09,74.46) 122.74,75.11 122.74,76.48 123.29,77.04
  BOTTOM w0.165: JDIMM1.95 126.75,44.97 127,44.72 v2(127.96,44.72)
DDR_A_MA4: length 47.5
  IN1 w0.089: v2(120.63,75.67) 121.33,74.97 121.33,70.35 120.62,69.64
  IN1 w0.132: v2(125.87,41.57) 125.87,41.18 126.17,40.88 126.17,40.63 126.05,40.5 125.19,40.5 125.07,40.63 125.07,46.41 124.53,46.95 124.53,49.28 119.93,53.88 119.93,68.96 120.62,69.64
  BOTTOM w0.076: v2(120.63,75.67) 121.09,76.13 121.09,76.28 121.08,76.29 121.08,76.77 122.44,78.13 122.44,79.89 UC1.BB52
  BOTTOM w0.165: v2(125.87,41.57) 125.85,41.54 JDIMM1.92
DDR_A_MA5: length 48.7
  IN1 w0.089: v2(122.08,76.49) 121.73,76.14 121.73,69.78 121.12,69.18 121.12,69.05 120.7,68.64 120.7,68.47
  IN1 w0.132: v2(125.87,46.14) 125.99,46.14 126.12,46.27 126.12,47.67 125.99,47.8 125.47,47.8 125.34,47.93 125.34,48.19 125.47,48.33 125.74,48.33 125.87,48.46 125.87,48.63 125.3,49.2 125.3,49.95 125.43,50.09 125.65,50.09 125.79,50.22 125.79,50.48 125.65,50.61 125.43,50.61 125.3,50.75 125.3,51.04 125.22,51.12 125.03,51.12 124.57,50.67 124.39,50.67 124.2,50.86 124.2,51.04 124.65,51.5 124.65,51.69 124.47,51.87 124.28,51.87 123.83,51.42 123.64,51.42 123.45,51.6 123.45,51.79 123.91,52.25 123.91,52.43 123.72,52.62 123.54,52.62 123.08,52.16 122.89,52.16 122.7,52.35 122.7,52.54 123.16,53 123.16,53.18 122.97,53.37 122.79,53.37 122.33,52.91 122.14,52.91 121.96,53.1 121.96,53.28 122.59,53.92 122.59,54.1 122.4,54.29 122.22,54.29 122.12,54.19 121.94,54.19 121.75,54.39 121.75,54.57 121.85,54.67 121.85,54.84 120.97,55.72 120.97,56.69 120.7,56.96 120.7,68.47
  BOTTOM w0.076: UC1.BA51 123.42,80.75 123.42,80.58 123.48,80.36 123.48,80.24 123.42,80.1 123.42,79.77 123.61,79.59 123.61,79.24 122.94,78.56 122.94,77.87 122.08,77.01 v2(122.08,76.49)
  BOTTOM w0.165: v2(125.87,46.14) 125.67,46.14 125.55,46.26 JDIMM1.91
DDR_A_MA6: length 47.9
  IN1 w0.089: 120.62,69.1 121.52,70 121.52,75.39 v2(120.66,76.26)
  IN1 w0.132: v2(125.87,43.09) 125.45,43.51 125.45,46.41 125.73,46.69 125.73,47.3 125.63,47.41 125.32,47.41 124.92,47.81 124.92,49.44 121.24,53.12 121.24,53.3 121.67,53.73 121.67,53.91 121.48,54.11 121.3,54.11 120.87,53.68 120.68,53.68 120.32,54.04 120.32,54.52 120.45,54.65 120.7,54.65 120.83,54.78 120.83,55.05 120.7,55.18 120.45,55.18 120.32,55.31 120.32,68.8 120.62,69.1
  BOTTOM w0.076: UC1.BA52 122.54,80.41 122.27,80.15 122.27,78.2 120.66,76.58 v2(120.66,76.26)
  BOTTOM w0.165: JDIMM1.90 125.25,42.47 v2(125.87,43.09)
DDR_A_MA7: length 50.3
  IN1 w0.089: v2(120.62,73.96) 120.62,73.95 120.96,73.61 120.96,70.78 120.68,70.5 120.38,70.5 120.16,70.29
  IN1 w0.132: 120.16,70.29 119.16,69.29 119.16,53.56 123.76,48.96 123.76,48.78 123.63,48.65 123.25,48.65 123.12,48.52 123.12,48.26 123.25,48.12 123.63,48.12 123.76,47.99 123.76,47.73 123.63,47.6 123.38,47.6 123.25,47.47 123.25,47.19 123.38,47.07 123.63,47.07 123.76,46.94 123.76,46.63 124.29,46.09 124.29,42.95 124.08,42.73 123.77,42.73 123.65,42.85 v2(123.65,43.09)
  BOTTOM w0.076: UC1.AW52 122.64,81.75 122.32,81.42 122.32,80.94 122.11,80.73 122.11,78.26 120.16,76.32 120.16,74.43 v2(120.62,73.96)
  BOTTOM w0.165: v2(123.65,43.09) 123.12,42.56 123.12,41.48 124.05,40.55 JDIMM1.86
DDR_A_MA8: length 50.8
  IN1 w0.089: 120.48,70.05 121.15,70.72 121.15,74 v2(120.62,74.53)
  IN1 w0.132: 120.48,70.05 119.55,69.12 119.55,53.72 124.14,49.12 124.14,46.79 124.68,46.25 124.68,42.59 v2(123.65,41.57)
  BOTTOM w0.076: UC1.AY52 122.74,81.18 122.74,80.92 122.78,80.82 122.78,80.82 122.81,80.74 122.81,80.53 122.77,80.44 122.77,80.19 122.77,80.18 122.81,80.09 122.81,79.83 122.61,79.63 122.61,78.06 121.3,76.76 121.3,76.18
  BOTTOM w0.102: 121.3,76.18 121.3,75.22 v2(120.62,74.53)
  BOTTOM w0.165: v2(123.65,41.57) 124.95,42.86 JDIMM1.89
DDR_A_MA9: length 47.3
  IN1 w0.132: v2(120.55,70.91) 119.81,70.91 118.77,69.88 118.77,69.64 118.64,69.51 118.43,69.51 118.29,69.37 118.29,69.11 118.43,68.98 118.64,68.98 118.77,68.85 118.77,68.58 118.64,68.45 118.43,68.45 118.29,68.32 118.29,68.05 118.43,67.92 118.64,67.92 118.77,67.79 118.77,67.52 118.64,67.39 118.43,67.39 118.29,67.26 118.29,67 118.43,66.86 118.64,66.86 118.77,66.73 118.77,66.47 118.64,66.34 118.43,66.34 118.29,66.2 118.29,65.94 118.43,65.81 118.64,65.81 118.77,65.68 118.77,65.41 118.64,65.28 118.43,65.28 118.29,65.15 118.29,64.88 118.43,64.75 118.64,64.75 118.77,64.62 118.77,64.35 118.64,64.22 118.43,64.22 118.29,64.09 118.29,63.83 118.43,63.69 118.64,63.69 118.77,63.56 118.77,63.3 118.64,63.17 118.43,63.17 118.29,63.03 118.29,62.77 118.43,62.64 118.64,62.64 118.77,62.51 118.77,62.24 118.64,62.11 118.43,62.11 118.29,61.98 118.29,61.71 118.43,61.58 118.64,61.58 118.77,61.45 118.77,61.18 118.64,61.05 118.43,61.05 118.29,60.92 118.29,60.66 118.43,60.52 118.64,60.52 118.77,60.39 118.77,60.13 118.64,60 118.43,60 118.29,59.86 118.29,59.6 118.43,59.47 118.64,59.47 118.77,59.34 118.77,59.07 118.64,58.94 118.43,58.94 118.29,58.81 118.29,58.54 118.43,58.41 118.64,58.41 118.77,58.28 118.77,53.4 122.73,49.44 122.73,46.7 123.29,46.14 v2(123.65,46.14)
  BOTTOM w0.076: UC1.BB54 121.61,79.88 121.61,79.08 121.32,78.79 121.32,78.18 119.53,76.39 119.53,71.93 v2(120.55,70.91)
  BOTTOM w0.165: JDIMM1.85 123.75,46.24 v2(123.65,46.14)
DDR_A_MA10: length 49
  IN1 w0.089: v2(123.38,83.4) 123.75,83.04 123.75,80.9 124.58,80.06 124.58,78.73 125.22,78.09 125.22,70.42 124.45,69.65 124.45,68.56
  IN1 w0.132: v2(131.25,49.85) 130.99,49.6 130.99,49.43 130.87,49.3 130.61,49.3 130.48,49.43 130.48,51.02 130.61,51.15 131.17,51.15 131.3,51.28 131.3,51.55 131.17,51.68 130.61,51.68 130.48,51.8 130.48,52.08 130.61,52.21 131.11,52.21 131.24,52.33 131.24,52.61 131.11,52.73 130.96,52.73 130.83,52.87 130.83,53.02 126.09,57.75 126.09,57.94 126.28,58.13 126.28,58.31 126.09,58.51 125.91,58.51 125.72,58.31 125.53,58.31 125.34,58.5 125.34,58.69 126.14,59.48 126.14,59.66 125.94,59.85 125.76,59.85 124.97,59.06 124.78,59.06 124.45,59.39 124.45,59.94 124.59,60.07 125.2,60.07 125.33,60.2 125.33,60.47 125.2,60.6 124.59,60.6 124.45,60.73 124.45,68.56
  BOTTOM w0.076: UC1.AT50 v2(123.38,83.4)
  BOTTOM w0.165: JDIMM1.107 130.35,49.31 130.89,49.85 v2(131.25,49.85)
DDR_A_MA11: length 49.8
  IN1 w0.132: v2(121.73,44.61) 121.73,44.45 122.25,43.93 122.55,43.93 122.79,44.18 122.79,45.54 121.96,46.38 121.96,49.12 117.52,53.56 117.52,69.81 119.88,72.17 119.88,72.95 120.02,73.09 120.31,73.09 120.55,72.86 v2(120.55,72.63)
  BOTTOM w0.076: v2(120.55,72.63) 120.36,72.63 119.72,73.27 119.72,76.35 120.51,77.14 121.51,78.14 121.51,78.7 121.78,78.97 121.78,80.16 121.51,80.42 UC1.BA54
  BOTTOM w0.165: JDIMM1.84 123.45,40.56 122.55,41.46 122.55,43.8 v2(121.73,44.61)
DDR_A_MA12: length 49.5
  IN1 w0.132: v2(120.55,72.04) 119.93,71.42 119.68,71.42 117.91,69.65 117.91,58.05 118.04,57.92 118.26,57.92 118.39,57.79 118.39,57.52 118.26,57.39 118.04,57.39 117.91,57.26 117.91,57 118.04,56.86 118.23,56.86 118.36,56.73 118.36,56.47 118.23,56.34 118.04,56.34 117.91,56.2 117.91,55.94 118.04,55.81 118.26,55.81 118.39,55.68 118.39,55.41 118.26,55.28 118.04,55.28 117.91,55.15 117.91,54.88 118.04,54.75 118.26,54.75 118.39,54.62 118.39,54.35 118.26,54.22 118.04,54.22 117.91,54.09 117.91,53.72 122.35,49.28 122.35,46.54 123.18,45.71 123.18,44.38 123.31,44.25 123.53,44.25 123.65,44.38 v2(123.65,44.61)
  BOTTOM w0.076: UC1.AW54 121.41,81.72 121.72,81.41 121.72,80.86 121.94,80.64 121.94,78.86 121.71,78.63 121.71,78.1 119.91,76.3 119.91,73.49 120.38,73.02 120.77,73.02 120.96,72.82 120.96,72.45 v2(120.55,72.04)
  BOTTOM w0.165: v2(123.65,44.61) 123.15,45.12 JDIMM1.83
DDR_A_MA13: length 51.4
  IN1 w0.089: 127.05,76.67 127.05,81.32 127.24,81.51 127.24,81.94 126.1,83.07 v2(126.1,83.46)
  IN1 w0.132: v2(133.64,46.24) 133.69,46.29 133.69,54.07 133.6,54.16 133.41,54.16 133.01,53.76 132.82,53.76 130.46,56.12 130.46,56.3 130.93,56.78 130.93,56.96 130.74,57.15 130.56,57.15 130.08,56.68 129.9,56.68 129.71,56.86 129.71,57.05 130.5,57.85 130.5,58.03 130.31,58.22 130.13,58.22 129.34,57.42 129.15,57.42 128.96,57.61 128.96,57.8 129.76,58.59 129.76,58.77 129.56,58.97 129.38,58.97 128.59,58.17 128.4,58.17 128.21,58.36 128.21,58.55 129.01,59.34 129.01,59.52 126.38,62.14 126.38,68.22 126.88,68.71 126.88,76.5 127.05,76.67
  BOTTOM w0.076: v2(126.1,83.46) 125.67,83.14 UC1.AU46
  BOTTOM w0.165: v2(133.64,46.24) 133.65,46.24 133.95,46.54 JDIMM1.119
DDR_A_MA14: length 49
  IN1 w0.132: v2(118.48,72.07) 118.48,71.87 116.75,70.14 116.75,53.24 120.93,49.06 120.93,41.08 121.05,40.95 122.29,40.95 122.42,41.08 122.42,41.44 122.29,41.57 v2(121.73,41.57)
  BOTTOM w0.076: UC1.AY54 121.31,81.18 121.31,80.93 121.24,80.71 121.24,80.58 121.3,80.35 121.3,80.21 121.24,80.09 121.24,79.83 121.45,79.63 121.45,79.15 121.14,78.84 121.14,78.23 119.35,76.44 119.35,76.19
  BOTTOM w0.102: 119.35,76.19 119.35,72.94 v2(118.48,72.07)
  BOTTOM w0.165: v2(121.73,41.57) 121.73,41.25 122.25,40.74 JDIMM1.80
DDR_A_MA15: length 47.8
  IN1 w0.132: v2(118.67,76.15) 118.67,76.37 118.99,76.7 119.46,76.7 119.69,76.47 119.69,74.35 119.31,73.97 119.31,72.1 117.14,69.92 117.14,53.4 121.31,49.22 121.31,43.51 v2(121.73,43.09)
  BOTTOM w0.076: UC1.BA55 120.62,80.73 120.62,80.5 120.56,80.37 120.56,80.26 120.62,80.12 120.62,79.71 120.48,79.57 120.48,79.25 120.74,78.99 120.74,78.38 118.67,76.31 v2(118.67,76.15)
  BOTTOM w0.165: JDIMM1.78 121.65,40.58 121.19,41.04 121.19,42.6 121.68,43.09 v2(121.73,43.09)
DDR_A_ODT0: length 53.1
  IN1 w0.089: 128.49,72.29 128.79,72.59 128.79,76.55 128.7,76.65 128.7,81.98 128.3,82.37 128.3,83.07 127.93,83.45 v2(127.08,83.45)
  IN1 w0.132: v2(132.72,38.13) 134.85,40.25 134.85,55.32 127.54,62.62 127.54,71.34 128.49,72.29
  BOTTOM w0.076: UC1.AT45 126.77,83.75 v2(127.08,83.45)
  BOTTOM w0.165: JDIMM1.116 133.05,38.46 v2(132.72,38.13)
DDR_A_ODT1: length 54.1
  IN1 w0.089: 129.05,73.72 129.05,76.55 128.91,76.69 128.91,82.09 128.52,82.48 128.52,83.18 128.01,83.68 127.52,83.68 v2(127.06,84.15)
  IN1 w0.132: 129.05,73.72 129.05,72.47 127.93,71.35 127.93,62.78 135.23,55.48 135.23,40.09 134.55,39.41 134.55,38.35 134.77,38.13 v2(135.18,38.13)
  BOTTOM w0.076: UC1.AT43 127.46,83.75 v2(127.06,84.15)
  BOTTOM w0.165: JDIMM1.120 134.25,38.45 134.58,38.13 v2(135.18,38.13)
DDR_A_RAS#: length 49.5
  IN1 w0.089: 125.61,68.7 125.61,69.6 125.81,69.8 125.81,78.69 126.13,79.01 126.13,82.01 125.53,82.6 125.53,82.85 125.28,83.1 124.71,83.1 124.38,82.77 v2(124.38,82.77)
  IN1 w0.132: v2(131.26,41.67) 132.83,43.24 132.83,48.36 132.46,48.74 132.46,53.02 127.44,58.04 127.44,59.99 125.61,61.82 125.61,68.7
  BOTTOM w0.076: v2(124.38,82.77) 124.17,82.77 UC1.AU50
  BOTTOM w0.165: JDIMM1.110 131.26,39.51 v2(131.26,41.67)
DDR_A_WE#: length 50.4
  IN1 w0.089: 125.23,68.63 125.23,69.6 125.64,70.01 125.64,78.79 125.95,79.1 125.95,81.92 125.36,82.51 v2(125.14,82.72)
  IN1 w0.132: 125.23,68.63 125.23,61.66 127.06,59.83 127.06,57.88 132.07,52.86 132.07,48.58 132.45,48.2 132.45,43.4 132.24,43.19 v2(131.26,43.19)
  BOTTOM w0.076: UC1.AT46 125.56,83.75 125.14,83.34 v2(125.14,82.72)
  BOTTOM w0.165: v2(131.26,43.19) 132.15,44.08 JDIMM1.113
DDR_B_BS0: length 69.3
  IN3 w0.089: 126.17,68.38 126.03,68.52 126.03,72.49 v2(126.46,72.92)
  IN3 w0.165: 126.17,68.38 126.23,68.32 126.23,62.2 130.47,57.97 130.47,57.73 129.96,57.23 129.96,57.02 130.22,56.76 130.43,56.76 130.93,57.27 131.17,57.27 131.4,57.03 131.4,56.8 130.9,56.3 130.9,56.08 131.15,55.83 131.36,55.83 131.87,56.33 132.1,56.33 132.34,56.1 132.34,55.87 131.85,55.38 131.85,55.14 132.08,54.91 132.31,54.91 132.8,55.4 133.04,55.4 133.27,55.17 133.27,54.93 132.77,54.43 132.77,54.21 133.02,53.96 133.23,53.96 133.74,54.47 133.97,54.47 134.2,54.23 134.2,54 133.7,53.49 133.7,53.28 133.95,53.03 134.17,53.03 134.67,53.53 134.9,53.53 135.14,53.3 135.14,53.06 134.63,52.56 134.63,52.34 134.89,52.09 135.1,52.09 135.61,52.6 135.84,52.6 136.07,52.36 136.07,52.13 135.57,51.63 135.57,51.41 135.82,51.16 136.04,51.16 136.2,51.32 136.42,51.32 136.67,51.07 136.67,50.86 136.52,50.71 136.52,50.46 140.25,46.72 140.36,46.72 140.63,46.45 140.63,40.55 142.98,38.21 142.98,37.36 143.5,36.84 143.5,35.24 144.27,34.47 144.27,33.25 v2(144.26,33.25)
  BOTTOM w0.076: 127.23,76.01 127.23,76.14 126.93,76.44 126.93,78.6 127.12,78.78 127.12,79.44 127.25,79.57 127.25,79.88 UC1.BB44
  BOTTOM w0.102: 127.23,76.01 127.23,74.97 126.93,74.67 126.93,73.39 v2(126.46,72.92)
  BOTTOM w0.165: JDIMM2.109 143.35,33.08 143.5,32.92 144.13,32.92 144.26,33.05 v2(144.26,33.25)
DDR_B_BS1: length 70
  IN3 w0.089: v2(126.49,74.86) 127.18,74.16 127.18,68.44 127.07,68.33 127.07,67.92
  IN3 w0.165: v2(144.26,27.91) 144.26,27.96 144.06,28.16 143.03,28.16 142.87,27.99 142.87,26.53 143.02,26.38 143.41,26.38 143.57,26.53 143.57,27.26 143.72,27.41 144.62,27.41 144.77,27.56 144.77,29.09 145.12,29.43 145.12,34.81 144.34,35.59 144.34,37.18 143.81,37.71 143.81,38.56 141.47,40.9 141.47,47.21 139.88,48.8 139.88,49.74 127.07,62.55 127.07,67.92
  BOTTOM w0.076: UC1.BA44 127.09,80.37 127.09,79.64 126.95,79.51 126.95,78.85 126.76,78.66 126.76,76.34 127.04,76.06 127.04,75.79
  BOTTOM w0.102: 127.04,75.79 127.04,75.41 v2(126.49,74.86)
  BOTTOM w0.165: v2(144.26,27.91) 143.36,27.91 143.05,27.61 JDIMM2.108
DDR_B_BS2: length 70.7
  IN3 w0.089: v2(122.47,85.31) 122.13,84.97 122.13,82.48 121.32,81.68 121.32,79.24 119.71,77.63 119.4,77.63 118.04,76.28 118.04,75.07
  IN3 w0.165: v2(133.53,31.72) 133.53,31.57 133.29,31.33 132.97,31.33 132.86,31.44 132.86,32.6 133.31,33.05 133.31,33.27 133.06,33.52 132.85,33.52 132.62,33.29 132.39,33.29 132.15,33.53 132.15,33.76 132.38,33.99 132.38,34.2 132.13,34.46 131.91,34.46 131.65,34.19 131.49,34.19 131.39,34.29 131.39,35.97 129.95,37.41 129.21,37.41 128.71,37.91 128.71,38.15 128.83,38.27 128.83,38.5 128.6,38.74 128.36,38.74 128.24,38.61 128.01,38.61 125.44,41.19 125.44,48.19 117.23,56.39 117.23,70.79 118.04,71.61 118.04,75.07
  BOTTOM w0.076: UC1.AP52 122.72,85.05 v2(122.47,85.31)
  BOTTOM w0.165: v2(133.53,31.72) 134.35,32.55 JDIMM2.79
DDR_B_CAS#: length 71.3
  IN3 w0.165: v2(127.91,73.33) 128.31,72.94 128.31,72.49 127.91,72.09 127.91,64.13 128.24,63.8 128.24,63.63 127.91,63.3 127.91,62.9 128.07,62.73 128.31,62.73 128.69,63.11 128.92,63.11 129.16,62.88 129.16,62.65 128.78,62.27 128.78,62.03 129.01,61.8 129.24,61.8 129.62,62.18 129.86,62.18 130.09,61.94 130.09,61.71 129.71,61.33 129.71,61.1 129.94,60.86 130.18,60.86 130.56,61.24 130.79,61.24 131.02,61.01 131.02,60.78 130.64,60.4 130.64,60.16 130.88,59.93 131.11,59.93 131.49,60.31 131.72,60.31 131.96,60.08 131.96,59.84 131.58,59.46 131.58,59.23 131.81,59 132.05,59 132.42,59.38 132.66,59.38 132.89,59.14 132.89,58.91 132.51,58.53 132.51,58.3 132.75,58.06 132.98,58.06 133.36,58.44 133.59,58.44 133.83,58.21 133.83,57.97 133.45,57.59 133.45,57.36 133.68,57.13 133.91,57.13 134.29,57.51 134.53,57.51 134.76,57.27 134.76,57.04 134.38,56.66 134.38,56.43 134.61,56.19 134.85,56.19 135.23,56.57 135.46,56.57 135.69,56.34 135.69,56.11 135.31,55.73 135.31,55.49 140.72,50.09 140.72,49.17 143.21,46.68 143.21,40.35 145.18,38.38 145.18,37.87 145.29,37.75 145.47,37.75 145.59,37.63 145.59,37.29 145.43,37.13 145.43,36.82 145.75,36.5 145.75,35.96 145.9,35.81 146.19,35.81 146.34,35.65 146.34,35.47 146.02,35.14 146.02,34.81 146.34,34.48 146.34,34.18 146.08,33.92 145.96,33.8 145.96,33.47 v2(146.18,33.24)
  BOTTOM w0.076: UC1.AY43 127.82,81.32 127.82,81.22 127.75,81.06 127.75,80.88 127.8,80.72 127.8,80.58 127.74,80.36 127.74,80.24 127.78,80.13 127.78,79.78 127.58,79.58 127.58,79.44 127.45,79.3 127.45,78.65 127.29,78.49 127.29,76.56 127.61,76.24 127.61,75.98
  BOTTOM w0.102: 127.61,75.98 127.61,74.58 127.5,74.47 127.5,73.74 v2(127.91,73.33)
  BOTTOM w0.165: JDIMM2.115 145.15,33.65 145.55,33.25 146.18,33.25 v2(146.18,33.24)
DDR_B_CKE0: length 67.3
  IN3 w0.089: v2(120.6,85.3) 120.94,84.86 121.02,84.71 121.02,82.62 120.61,82.21 120.61,80.84 120.01,80.24 120.01,79.68 119.12,78.79 119.12,78.41 117.07,76.36 117.07,75.85
  IN3 w0.165: 117.07,75.85 117.07,71.85 116.35,71.13 116.35,56.08 124.6,47.84 124.6,40.84 128.87,36.57 129.6,36.57 130.55,35.63 130.55,33.16 v2(132,31.7)
  BOTTOM w0.076: UC1.AN56 120.19,85.7 120.59,85.3 v2(120.6,85.3)
  BOTTOM w0.165: v2(132,31.7) 131.72,31.7 131.5,31.92 131.5,32.88 131.72,33.1 132.29,33.1 132.55,33.37 JDIMM2.73
DDR_B_CKE1: length 67.3
  IN3 w0.089: 116.56,75.82 116.56,76.08 116.67,76.45 118.39,78.18 118.71,78.95 118.9,79.15 119.23,79.99 119.71,80.48 120.03,82.07 120.13,82.95 120.13,83.1 120.24,83.99 120.28,84.14 v2(120.64,84.61)
  IN3 w0.165: v2(132,30.18) 130.13,32.05 130.13,34.71 124.18,40.67 124.18,47.66 115.93,55.91 115.93,71.25 116.56,71.87 116.56,75.82
  BOTTOM w0.076: UC1.AP55 v2(120.64,84.61)
  BOTTOM w0.165: JDIMM2.74 132.85,29.33 v2(132,30.18)
DDR_B_CLK0: length 70.1
  IN3 w0.102: v2(141.9,31.34) 141.99,31.44 142.36,31.44 142.6,31.68 142.6,32.53 142.37,32.76 141.67,32.76 141.57,32.86 141.57,33.16 141.67,33.27 142.4,33.27 142.63,33.49 142.63,33.98 142.4,34.21 141.73,34.21 141.62,34.31 141.62,34.61 141.73,34.71 141.89,34.71 142.12,34.94 142.12,35.43 141.89,35.65 141.73,35.65 141.62,35.75 141.62,37.65 138.31,40.96 138.31,46.67 124.83,60.16 124.83,67.41 125.27,67.85 125.27,77.95 126.47,79.15 126.47,83 126.69,83.22 126.69,84.3 126.71,84.33 126.71,85.05 v2(127.04,85.38)
  BOTTOM w0.076: v2(127.04,85.38) 126.8,85.38 126.58,85.15 UC1.AP45
  BOTTOM w0.102: JDIMM2.101 140.95,32.1 141.48,31.58 141.67,31.58 v2(141.9,31.34)
DDR_B_CLK1: length 69.2
  IN3 w0.102: v2(141.9,29.82) 141.66,29.58 141.4,29.58 141.33,29.52 140.99,29.52 140.87,29.64 140.87,36.54 140.65,36.76 140.65,37.63 137.61,40.67 137.61,46.38 124.07,59.93 124.07,67.5 124.82,68.25 124.82,79.35 125.73,80.26 125.73,84.88 125.8,84.95 126,84.95 126.11,84.84 v2(126.11,84.69)
  BOTTOM w0.076: v2(126.11,84.69) 125.66,85.05 UC1.AP46
  BOTTOM w0.102: JDIMM2.102 141.25,27.88 141.17,27.96 141.17,29.14 141.42,29.39 141.79,29.39 141.96,29.56 141.96,29.76 v2(141.9,29.82)
DDR_B_CLK#0: length 70.1
  IN3 w0.102: v2(141.9,32.11) 141.83,32.03 141.83,31.88 141.96,31.75 142.07,31.75 142.17,31.65 142.27,31.65 142.39,31.77 142.39,32.44 142.28,32.54 141.58,32.54 141.35,32.77 141.35,33.25 141.58,33.48 142.31,33.48 142.41,33.58 142.41,33.89 142.31,33.99 141.64,33.99 141.41,34.22 141.41,34.7 141.64,34.93 141.8,34.93 141.9,35.03 141.9,35.34 141.8,35.44 141.64,35.44 141.41,35.66 141.41,37.56 138.1,40.87 138.1,46.58 124.61,60.07 124.61,67.5 125.05,67.94 125.05,78.04 126.25,79.24 126.25,83.09 126.47,83.31 126.47,84.39 126.5,84.42 126.5,85.2 126.38,85.31 v2(126.12,85.31)
  BOTTOM w0.076: UC1.AN45 126.19,85.31 v2(126.12,85.31)
  BOTTOM w0.102: v2(141.9,32.11) 141.9,31.95 141.74,31.79 141.57,31.79 141.17,32.19 141.17,33.18 141.55,33.56 JDIMM2.103
DDR_B_CLK#1: length 69.2
  IN3 w0.102: v2(125.21,85.31) 125.55,84.97 125.55,84.96 125.54,84.96 125.54,80.38 124.6,79.44 124.6,68.34 123.86,67.59 123.86,59.84 137.4,46.29 137.4,40.58 140.44,37.54 140.44,36.67 140.65,36.45 140.65,29.55 140.9,29.3 141.42,29.3 141.48,29.37 141.75,29.37 141.91,29.21 v2(141.91,29)
  BOTTOM w0.076: UC1.AN46 v2(125.21,85.31)
  BOTTOM w0.102: v2(141.91,29) 141.73,29.18 141.51,29.18 141.39,29.05 141.39,28.05 141.85,27.58 JDIMM2.104
DDR_B_CS#0: length 66.5
  IN3 w0.089: v2(127.94,77.35) 129.16,76.12 129.16,68.66
  IN3 w0.165: v2(146.2,28.7) 145.61,28.11 145.61,27.89 146.04,27.46 146.26,27.46 147.18,28.38 147.18,36.16 147.29,36.27 147.29,38.7 145.27,40.72 145.27,45.84 145.1,46 144.67,46 144.51,46.17 144.51,49.31 129.16,64.65 129.16,68.66
  BOTTOM w0.076: UC1.BB42 128.68,79.76 128.69,79.75 128.69,79.04 128.61,78.96 128.61,77.67 128.28,77.35 v2(127.94,77.35)
  BOTTOM w0.165: v2(146.2,28.7) 145.99,28.7 144.85,27.56 JDIMM2.114
DDR_B_CS#1: length 68.8
  IN3 w0.089: 128.75,69.27 128.75,71.78 128.89,71.93 128.89,75.07 v2(128.23,75.73)
  IN3 w0.165: 128.75,69.27 128.75,64.47 143.56,49.66 143.56,49.43 142.74,48.61 142.74,48.38 142.98,48.14 143.21,48.14 143.74,48.67 143.9,48.67 144.06,48.51 144.06,45.64 144.23,45.47 144.68,45.47 144.85,45.31 144.85,44.98 144.68,44.81 144.23,44.81 144.06,44.65 144.06,44.32 144.23,44.15 144.68,44.15 144.85,43.99 144.85,40.54 146.87,38.52 146.87,37.85 146.23,37.22 146.23,36.39 146.76,35.86 146.76,30.23 146.59,30.06 146.36,30.06 v2(146.2,30.22)
  BOTTOM w0.076: UC1.AY42 128.95,81.02 128.95,80.53 129.01,80.37 129.1,80.16 129.11,80.13 129.11,79.64 129.03,79.56 129.03,78.89 128.94,78.8 128.94,76.56 128.8,76.42
  BOTTOM w0.102: 128.8,76.42 128.8,76.3 v2(128.23,75.73)
  BOTTOM w0.165: JDIMM2.121 146.95,30.97 v2(146.2,30.22)
DDR_B_D0: length 84.1
  IN3 w0.089: 113.46,89.31 115.07,89.31 v2(115.69,88.7)
  IN3 w0.102: v2(115.01,28.17) 113.08,30.1 113.08,33.32 112.47,33.92 112.47,34.81 110.28,37 110.28,38.18 108.29,40.18 108.29,46.15 102.44,51.99 102.44,75.61 98.37,79.68 98.37,82.68 100.94,85.25 108.54,85.25 110.08,86.78 110.93,86.78 113.46,89.31
  BOTTOM w0.076: UC1.AF65 v2(115.69,88.7)
  BOTTOM w0.102: JDIMM2.24 115.45,27.72 v2(115.01,28.17)
DDR_B_D1: length 82.4
  IN3 w0.089: 113.78,88.32 115.95,88.32 v2(116.32,88.7)
  IN3 w0.102: 113.78,88.32 109.53,84.07 108.1,84.07 107.83,83.8 107.04,83.8 106.97,83.74 105.52,83.74 104.92,84.33 104.54,84.33 104.1,83.89 104.1,83.65 105.23,82.52 105.23,82.24 105.33,82.14 105.62,82.14 105.72,82.03 105.72,81.83 105.62,81.73 105.33,81.73 105.23,81.63 105.23,81.42 105.33,81.32 105.62,81.32 105.72,81.22 105.72,81.02 105.62,80.92 105.33,80.92 105.23,80.81 105.23,80.61 105.33,80.51 105.62,80.51 105.72,80.41 105.72,80.2 105.62,80.1 105.33,80.1 105.23,80 105.23,79.68 104.34,78.79 104.34,78.65 104.65,78.34 104.65,78.2 104.51,78.06 104.36,78.06 104.06,78.36 103.91,78.36 103.77,78.22 103.77,78.08 104.33,77.52 104.33,77.37 104.18,77.23 104.04,77.23 103.48,77.79 103.34,77.79 103.19,77.64 103.19,77.5 103.75,76.94 103.75,76.8 103.61,76.66 103.46,76.66 102.91,77.21 102.76,77.21 102.62,77.07 102.62,76.72 103.36,75.99 103.36,52.37 109.2,46.53 109.2,40.56 111.19,38.56 111.19,38.1 113.39,35.91 113.39,34.36 114.07,33.68 114.07,32.82 114.15,32.74 v2(115.01,32.74)
  BOTTOM w0.076: UC1.AF64 v2(116.32,88.7)
  BOTTOM w0.102: JDIMM2.23 115.15,32.88 v2(115.01,32.74)
DDR_B_D2: length 82.7
  IN3 w0.089: 112.63,84.67 112.63,85 113.91,86.28 114.83,86.28 114.96,86.41 115.29,86.41 v2(115.77,86.9)
  IN3 w0.102: v2(118.28,28.17) 119.15,28.17 119.28,28.3 119.28,28.59 119.18,28.69 118.87,28.69 118.76,28.79 118.76,28.99 118.87,29.1 119.18,29.1 119.28,29.2 119.28,32.92 118.71,33.49 118.04,33.49 115.96,35.57 115.96,37.11 112.99,40.08 112.99,47.27 106.5,53.76 106.5,54.32 106.6,54.42 107.08,54.42 107.18,54.52 107.18,54.72 107.08,54.82 106.6,54.82 106.5,54.93 106.5,55.13 106.6,55.23 107.08,55.23 107.18,55.33 107.18,55.54 107.08,55.64 106.6,55.64 106.5,55.74 106.5,55.94 106.6,56.04 107.08,56.04 107.18,56.15 107.18,56.35 107.08,56.45 106.6,56.45 106.5,56.55 106.5,56.75 106.6,56.86 107.08,56.86 107.18,56.96 107.18,57.16 107.08,57.26 106.6,57.26 106.5,57.36 106.5,57.57 106.6,57.67 107.08,57.67 107.18,57.77 107.18,57.97 107.08,58.08 106.6,58.08 106.5,58.18 106.5,58.38 106.6,58.48 107.08,58.48 107.18,58.58 107.18,58.79 107.08,58.89 106.6,58.89 106.5,58.99 106.5,59.19 106.6,59.29 107.08,59.29 107.18,59.4 107.18,59.6 107.08,59.7 106.6,59.7 106.5,59.8 106.5,60.01 106.6,60.11 106.92,60.11 107.02,60.21 107.02,60.41 106.92,60.51 106.6,60.51 106.5,60.62 106.5,67.94 105.7,68.74 105.7,74.68 106.93,75.91 106.93,77.97 110.01,81.05 110.01,81.27 110.45,81.72 111.05,81.72 111.56,82.22 111.56,82.54 112.63,83.61 112.63,84.67
  BOTTOM w0.076: UC1.AK65 115.37,87.3 v2(115.77,86.9)
  BOTTOM w0.102: JDIMM2.34 118.45,28 v2(118.28,28.17)
DDR_B_D3: length 84
  IN3 w0.089: v2(115.74,87.77) 115.34,87.37 114.99,87.37 114.85,87.23 114.3,87.23 114,86.93 113.53,86.93
  IN3 w0.102: 113.53,86.93 111.35,84.75 111.35,83.47 110.93,83.05 109.91,83.05 109.68,82.82 109.02,82.16 107.69,82.16 106.88,81.36 106.88,79.16 106.1,78.38 106.1,77.13 104.78,75.81 104.78,54.07 112.07,46.78 112.07,39.7 115.05,36.73 115.05,35.2 117.44,32.8 117.44,29.74 117.34,29.64 115.69,29.64 115.56,29.51 115.56,29.26 115.69,29.13 117.34,29.13 117.44,29.03 117.44,27.87 117.57,27.74 117.74,27.74 117.87,27.87 117.87,31.09 118,31.22 v2(118.28,31.22)
  BOTTOM w0.076: UC1.AK64 116.04,87.31 115.74,87.6 v2(115.74,87.77)
  BOTTOM w0.102: v2(118.28,31.22) 117.79,31.71 117.79,33.16 118.15,33.52 JDIMM2.33
DDR_B_D4: length 83.1
  IN3 w0.089: 113.63,89.06 114.69,89.06 v2(115.05,88.7)
  IN3 w0.102: 113.63,89.06 111.04,86.47 110.22,86.47 108.7,84.94 101.07,84.94 98.68,82.55 98.68,79.81 102.75,75.73 102.75,52.12 108.59,46.27 108.59,40.3 110.58,38.31 110.58,37.85 112.78,35.65 112.78,34.05 113.38,33.44 113.38,31.32 v2(115.01,29.69)
  BOTTOM w0.076: UC1.AF66 v2(115.05,88.7)
  BOTTOM w0.102: v2(115.01,29.69) 114.66,29.69 114.57,29.61 114.57,27.75 114.85,27.47 JDIMM2.22
DDR_B_D5: length 82.4
  IN3 w0.089: 113.84,88.7 v2(114.42,88.7)
  IN3 w0.102: v2(115.01,31.22) 113.69,32.54 113.69,33.57 113.08,34.17 113.08,35.78 110.89,37.98 110.89,38.44 108.9,40.43 108.9,46.4 103.05,52.24 103.05,75.86 102.32,76.6 102.32,77.63 102.69,78 103.12,78 104.92,79.81 104.92,82.39 103.09,84.23 101.19,84.23 101.09,84.33 101.09,84.54 101.19,84.64 105.05,84.64 105.64,84.04 107.73,84.04 108.01,84.32 109.47,84.32 113.84,88.7
  BOTTOM w0.076: UC1.AF67 v2(114.42,88.7)
  BOTTOM w0.102: JDIMM2.21 114.55,31.67 v2(115.01,31.22)
DDR_B_D6: length 81.4
  IN3 w0.089: 113.69,86.73 114.31,86.73 v2(114.43,86.84)
  IN3 w0.102: v2(118.28,32.74) 117.93,32.74 115.35,35.32 115.35,36.85 112.38,39.83 112.38,47.02 105.89,53.51 105.89,53.97 105.78,54.07 105.21,54.07 105.11,54.18 105.11,54.38 105.21,54.48 105.78,54.48 105.89,54.58 105.89,54.79 105.78,54.89 105.21,54.89 105.11,54.99 105.11,55.19 105.21,55.29 105.78,55.29 105.89,55.39 105.89,55.62 105.78,55.72 105.19,55.72 105.09,55.83 105.09,56.03 105.19,56.13 105.78,56.13 105.89,56.23 105.89,56.44 105.78,56.54 105.19,56.54 105.09,56.64 105.09,56.84 105.19,56.94 105.78,56.94 105.89,57.05 105.89,57.25 105.78,57.35 105.19,57.35 105.09,57.45 105.09,57.65 105.19,57.76 105.78,57.76 105.89,57.86 105.89,58.06 105.78,58.16 105.19,58.16 105.09,58.26 105.09,58.47 105.19,58.57 105.78,58.57 105.89,58.67 105.89,58.87 105.78,58.98 105.19,58.98 105.09,59.08 105.09,59.28 105.19,59.38 105.78,59.38 105.89,59.48 105.89,59.69 105.78,59.79 105.19,59.79 105.09,59.89 105.09,60.09 105.19,60.19 105.78,60.19 105.89,60.3 105.89,60.5 105.78,60.6 105.19,60.6 105.09,60.7 105.09,60.91 105.19,61.01 105.78,61.01 105.89,61.11 105.89,61.31 105.78,61.41 105.19,61.41 105.09,61.52 105.09,61.72 105.19,61.82 105.78,61.82 105.89,61.92 105.89,62.13 105.78,62.23 105.19,62.23 105.09,62.33 105.09,75.44 106.36,76.7 106.36,78.2 107.52,79.36 107.52,80.49 108.03,81 108.18,81 110.04,82.86 111.12,82.86 111.69,83.43 111.69,84.73 113.69,86.73
  BOTTOM w0.076: UC1.AK67 114.07,87.2 v2(114.43,86.84)
  BOTTOM w0.102: JDIMM2.35 118.75,33.21 v2(118.28,32.74)
DDR_B_D7: length 82.2
  IN3 w0.089: 112.26,84.07 112.26,84.92 113.81,86.46 114.65,86.46 v2(115.11,86.92)
  IN3 w0.102: v2(118.28,29.69) 118.5,29.47 118.79,29.47 118.98,29.66 118.98,30.05 118.78,30.26 118.78,30.8 118.98,31 118.98,32.79 118.58,33.19 117.92,33.19 115.65,35.45 115.65,36.98 112.68,39.95 112.68,47.14 106.19,53.63 106.19,62.44 106.06,62.57 105.49,62.57 105.39,62.67 105.39,62.87 105.49,62.97 106.06,62.97 106.17,63.08 106.17,63.28 106.06,63.38 105.49,63.38 105.39,63.48 105.39,63.69 105.49,63.79 106.06,63.79 106.17,63.89 106.17,64.09 106.06,64.19 105.49,64.19 105.39,64.3 105.39,64.5 105.49,64.6 106.06,64.6 106.17,64.7 106.17,64.9 106.06,65.01 105.49,65.01 105.39,65.11 105.39,65.31 105.49,65.41 106.06,65.41 106.17,65.51 106.17,65.72 106.06,65.82 105.49,65.82 105.39,65.92 105.39,66.12 105.49,66.23 106.06,66.23 106.17,66.33 106.17,66.53 106.06,66.63 105.49,66.63 105.39,66.73 105.39,66.94 105.49,67.04 106.06,67.04 106.17,67.14 106.17,67.34 106.06,67.44 105.49,67.44 105.39,67.55 105.39,67.75 105.49,67.85 105.75,67.85 105.85,67.95 105.85,68.16 105.75,68.26 105.49,68.26 105.39,68.36 105.39,75.06 106.61,76.28 106.61,78.02 109.75,81.16 109.75,81.8 110.58,82.64 111.34,82.64 112.26,83.56 112.26,84.07
  BOTTOM w0.076: v2(115.11,86.92) 114.72,87.3 UC1.AK66
  BOTTOM w0.102: JDIMM2.36 119.05,28.92 v2(118.28,29.69)
DDR_B_D8: length 84.1
  IN3 w0.102: v2(107.59,89.36) 107.59,87.86 106.85,87.13 100.84,87.13 96.97,83.26 96.97,78.27 101.05,74.2 101.05,51.41 105.81,46.64 105.81,39.84 107.45,38.2 107.45,37.96 107.55,37.86 107.77,37.86 107.87,37.76 107.87,37.55 107.77,37.45 107.55,37.45 107.45,37.35 107.45,36.97 107.66,36.76 107.8,36.76 108.05,37.01 108.19,37.01 108.34,36.87 108.34,36.72 108.09,36.47 108.09,36.33 111.52,32.89 111.52,31.42 111.67,31.27 111.67,29.09 v2(112.59,28.17)
  BOTTOM w0.076: UC1.AF70 111.91,89.46 111.39,89.98 110.63,89.98 110.39,90.22 108.64,90.22
  BOTTOM w0.102: v2(107.59,89.36) 108.45,90.22 108.64,90.22 ; v2(112.59,28.17) 113.05,27.71 JDIMM2.16
DDR_B_D9: length 86.4
  IN3 w0.102: v2(109.22,28.42) 108.2,29.44 108.2,32.78 103.23,37.75 103.23,39.72 101.77,41.18 101.77,45.41 98.71,48.47 98.71,73.23 94.63,77.3 94.63,84.23 100.48,90.08 105.28,90.08 v2(105.75,89.6)
  BOTTOM w0.076: 108.64,90.61 110.41,90.61 110.84,90.18 111.62,90.18 112.03,89.77 112.46,89.77 112.58,89.65 112.82,89.65 112.88,89.63 UC1.AF68
  BOTTOM w0.102: v2(105.75,89.6) 106.18,90.03 107.75,90.03 108.32,90.61 108.64,90.61 ; JDIMM2.6 110.05,27.59 v2(109.22,28.42)
DDR_B_D10: length 84.6
  IN3 w0.102: v2(109.22,29.95) 108.9,29.95 108.5,30.34 108.5,32.91 103.54,37.88 103.54,39.85 102.07,41.31 102.07,45.54 99.01,48.6 99.01,73.35 94.94,77.43 94.94,84.1 100.61,89.77 104.49,89.77 v2(104.92,89.34)
  BOTTOM w0.076: 104.95,88.52 105.6,87.88 107.22,87.88 107.6,88.25 111.14,88.25 111.25,88.13 UC1.AH71
  BOTTOM w0.102: v2(104.92,89.34) 104.92,88.55 104.95,88.52 ; JDIMM2.4 109.45,27.51 108.6,28.36 108.6,29.33 v2(109.22,29.95)
DDR_B_D11: length 86.4
  IN3 w0.102: v2(110.03,89.13) 110.03,88.87 107.37,86.21 101.22,86.21 97.89,82.88 97.89,79.48 101.96,75.41 101.96,51.79 107.44,46.31 107.44,46.15 107.34,46.05 106.84,46.05 106.74,45.95 106.74,45.74 106.84,45.64 107.34,45.64 107.44,45.54 107.44,45.34 107.34,45.24 106.84,45.24 106.74,45.14 106.74,44.93 106.84,44.83 107.34,44.83 107.44,44.73 107.44,44.53 107.34,44.42 106.84,44.42 106.74,44.32 106.74,44.12 106.84,44.02 107.34,44.02 107.44,43.92 107.44,43.71 107.34,43.61 106.84,43.61 106.74,43.51 106.74,43.31 106.84,43.2 107.34,43.2 107.44,43.1 107.44,42.9 107.34,42.8 106.84,42.8 106.74,42.7 106.74,42.49 106.84,42.39 107.34,42.39 107.44,42.29 107.44,42.09 107.34,41.99 106.84,41.99 106.74,41.88 106.74,41.68 106.84,41.58 107.34,41.58 107.44,41.48 107.44,41.27 107.34,41.17 106.84,41.17 106.74,41.07 106.74,40.87 106.84,40.77 107.34,40.77 107.44,40.66 107.44,40.34 109.25,38.53 109.25,37.35 110.26,36.34 110.26,36.2 110.19,36.13 110.19,35.98 110.33,35.84 110.48,35.84 110.55,35.91 110.69,35.91 111.99,34.61 111.99,33.72 112.59,33.12 v2(112.59,32.74)
  BOTTOM w0.076: v2(110.03,89.13) 110.3,89.39 110.88,89.39 111.25,89.03 111.61,89.03 111.61,89.03 111.7,89.06 111.9,89.06 111.98,89.03 111.99,89.03 111.99,89.02 112,89.02 112.23,89.02 112.35,89.06 112.67,89.06 112.77,88.99 113.22,88.99 113.42,88.79 UC1.AH68
  BOTTOM w0.102: v2(112.59,32.74) 113.35,33.5 JDIMM2.17
DDR_B_D12: length 84.1
  IN3 w0.102: v2(108.21,89.41) 108.21,88.01 107.02,86.82 100.97,86.82 97.28,83.13 97.28,78.4 101.35,74.33 101.35,51.54 106.12,46.77 106.12,40.62 106.28,40.46 106.28,40.31 106.12,40.15 106.12,40.01 106.26,39.86 106.41,39.86 106.57,40.03 106.72,40.03 106.86,39.88 106.86,39.74 106.67,39.55 106.67,39.41 106.82,39.27 106.96,39.27 107.15,39.45 107.29,39.45 107.43,39.31 107.43,39.16 107.25,38.98 107.25,38.84 107.39,38.69 107.54,38.69 107.72,38.88 107.87,38.88 108.01,38.73 108.01,38.59 107.82,38.4 107.82,38.26 107.97,38.12 108.11,38.12 108.3,38.3 108.44,38.3 108.64,38.1 108.64,36.21 111.83,33.02 111.83,31.55 111.98,31.4 111.98,30.31 v2(112.59,29.69)
  BOTTOM w0.076: 108.64,89.84 108.7,89.91 110.31,89.91 110.46,89.76 111.17,89.76 UC1.AF71
  BOTTOM w0.102: v2(112.59,29.69) 113.65,28.64 JDIMM2.18 ; 108.64,89.84 v2(108.21,89.41)
DDR_B_D13: length 85.7
  IN3 w0.102: v2(109.37,89.39) 109.37,88.75 107.14,86.52 101.1,86.52 97.58,83 97.58,79.35 97.88,79.06 97.88,78.92 97.61,78.65 97.61,78.5 97.75,78.36 97.89,78.36 98.16,78.63 98.31,78.63 98.45,78.48 98.45,78.34 98.18,78.07 98.18,77.93 98.32,77.78 98.47,77.78 98.74,78.05 98.88,78.05 99.03,77.91 99.03,77.77 98.76,77.5 98.76,77.35 98.9,77.21 99.04,77.21 99.31,77.48 99.46,77.48 99.6,77.33 99.6,77.19 99.33,76.92 99.33,76.78 99.47,76.63 99.62,76.63 99.89,76.9 100.03,76.9 100.18,76.76 100.18,76.62 99.91,76.35 99.91,76.2 100.05,76.06 100.19,76.06 100.46,76.33 100.61,76.33 100.75,76.18 100.75,76.04 100.64,75.93 100.64,75.79 100.78,75.64 100.93,75.64 101.04,75.75 101.18,75.75 101.66,75.28 101.66,51.66 106.42,46.89 106.42,40.75 108.95,38.23 108.95,36.33 112.13,33.15 112.13,31.68 v2(112.59,31.22)
  BOTTOM w0.076: UC1.AF69 112.59,89.36 112.49,89.26 112.41,89.26 112.22,89.19 112.02,89.19 111.93,89.23 111.68,89.23 111.67,89.23 111.57,89.19 111.32,89.19 110.91,89.6 109.58,89.6 v2(109.37,89.39)
  BOTTOM w0.102: JDIMM2.15 112.75,33.67 112.07,32.98 112.07,31.87 112.59,31.34 v2(112.59,31.22)
DDR_B_D14: length 85.3
  IN3 w0.102: v2(109.22,32.88) 109.22,33.06 105.09,37.19 105.09,37.96 104.96,38.09 104.27,38.09 104.15,38.22 104.15,38.42 104.27,38.55 104.68,38.55 104.8,38.67 104.8,38.84 104.68,38.96 104.29,38.96 104.19,39.06 104.19,46.05 104.08,46.16 103.73,46.16 103.69,46.12 103.55,46.12 103.4,46.26 103.4,46.41 103.65,46.65 103.65,46.79 103.5,46.94 103.36,46.94 103.07,46.65 102.93,46.65 102.79,46.8 102.79,46.94 103.07,47.23 103.07,47.37 102.93,47.51 102.78,47.51 102.5,47.23 102.35,47.23 102.21,47.37 102.21,47.51 102.5,47.8 102.5,47.94 102.35,48.09 102.21,48.09 101.92,47.8 101.72,47.8 101.32,48.2 101.32,48.4 101.45,48.53 101.45,48.7 101.34,48.82 101.17,48.82 100.59,48.24 100.39,48.24 99.62,49 99.62,73.61 95.55,77.68 95.55,83.85 100.25,88.55 103.41,88.55 103.69,88.83 v2(103.69,89.36)
  BOTTOM w0.076: 104.38,88.52 105.4,87.49 107.31,87.49 107.9,88.08 111.07,88.08 111.23,87.92 111.29,87.87 111.58,87.87 111.83,87.99 111.83,87.99 111.83,87.99 111.97,88.13 UC1.AH70
  BOTTOM w0.102: v2(109.22,32.88) 109.75,33.42 JDIMM2.5 ; 104.38,88.52 103.69,89.21 v2(103.69,89.36)
