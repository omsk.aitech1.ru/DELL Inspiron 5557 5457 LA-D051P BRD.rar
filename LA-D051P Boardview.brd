# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+1.35V_VDDQC: length 0.5
  BOTTOM w0.254: UC1.AM40 129.23,86.35 v2(128.92,86.04)
+1.35VP: length 68.8
  TOP w0.102: v2(82.67,9.9) v3(82.11,9.9)
  IN3 w0.254: v2(82.67,9.9) 85.46,9.9 85.85,10.28 87.5,10.28 89.85,7.93 100.92,7.93 102.15,9.17 102.15,18.17 100.01,20.31 v2(97.08,20.31)
  IN3 w0.508: v2(88.39,12.37) 88.39,10.15 90.1,8.44 100.7,8.44 101.64,9.38 101.64,17.85 99.88,19.61 v2(97.08,19.61)
  BOTTOM w0.203: PU200.19 87.36,13.14 88.13,12.37 v2(88.39,12.37)
+1.35VS_VRAM: length 152.4
  TOP w0.254: v2(40.49,71.61) 40.88,71.23 UV6.H2 ; UV6.F1 v2(42.92,72.43) ; UV7.E9 v2(42.92,79.7) ; v2(72.95,104.78) 72.55,104.38 UV5.R1 ; 45.72,85.7 UV7.B2 45.32,86.1 v2(45.32,86.1) ; v2(44.52,79.7) 44.12,80.1 UV7.D9 ; UV9.C9 v2(51.27,94.38) ; UV5.C9 v2(65.75,94.38) ; v2(51.25,105.54) 51.25,104.8 UV9.R9 ; UV9.A8 v2(52.07,92.78) ; UV6.B2 45.72,71.23 v2(46.12,70.83) ; UV9.H9 v2(51.27,98.38) ; UV5.R9 66.03,104.38 v2(65.74,104.09) ; UV6.H9 40.92,65.63 v2(40.52,66.03) ; RPV15.7 41.34,102.4 CV78.2 41.55,102.39 41.84,102.1 RPV15.6 ; UV7.A1 v2(46.12,86.1) ; v2(46.83,80.51) 46.55,80.79 46.55,80.81 46.52,80.81 UV7.A8 ; UV5.H9 66.15,98.79 v2(66.56,99.21) ; UV5.A8 v2(66.55,92.78) ; UV5.K8 67.04,100.38 v2(67.35,100.07) ; UV9.E9 v2(51.27,96.78) ; UV6.E9 43.32,65.62 v2(42.92,66.02) ; UV7.F1 v2(42.92,86.91) ; UV7.C9 44.92,80.1 v2(45.32,79.7) ; UV7.C1 v2(45.32,86.91) ; UV7.K8 39.72,80.5 40.52,80.5 v2(40.52,80.5) 40.92,80.1 UV7.H9 ; UV5.K2 v2(72.15,99.98) ; v2(39.62,70.83) 39.32,71.13 UV6.K2 ; RPV14.6 40.97,91.36 CV82.2 40.54,90.86 RPV14.7 ; v2(41.98,83.81) 41.46,83.29 41.46,81.96 UV7.G7 ; v2(72.95,103.18) 72.55,102.78 UV5.N1 ; UV5.F1 72.55,97.18 v2(72.95,96.78) ; UV5.E9 v2(65.75,96.78) ; UV9.D9 v2(52.07,95.98) ; v2(72.95,94.38) 72.55,94.78 UV5.C1 ; UV5.H2 v2(72.15,99.18) ; UV6.G7 41.72,67.23 v2(42.12,66.83) ; UV7.R1 35.31,86.5 34.89,86.92 v2(34.16,86.92) ; v2(46.92,71.63) 46.52,72.03 UV6.A1 ; v2(36.13,79.37) 36.86,80.1 UV7.N9 ; UV7.N1 36.77,86.65 v2(36.77,87.05) ; v2(44.52,65.22) 44.12,65.62 UV6.D9 ; CV81.2 44.79,101.08 44.63,100.93 RPV13.6 ; UV9.D2 57.27,95.58 v2(57.67,95.18) ; v2(45.32,65.22) 44.92,65.62 UV6.C9 ; UV6.C1 v2(45.32,72.43) ; UV9.H2 v2(57.67,99.18) 57.67,99.18 57.67,99.98 UV9.K2 ; UV7.K2 v2(39.72,85.3) 39.72,85.3 40.52,85.3 UV7.H2 ; v2(34.92,65.22) 35.32,65.62 UV6.R9 ; UV7.D2 44.11,85.7 v2(43.72,86.1) ; RPV12.7 48.09,91.05 CV74.2 47.66,90.55 RPV12.6 ; RPV16.7 45.27,98.29 45.65,98.67 CV80.2 46.12,98.44 45.77,98.09 RPV16.6 ; v2(34.89,79.74) 35.25,80.1 UV7.R9 ; v2(66.55,95.18) 66.15,95.58 UV5.D9 ; RPV11.7 39.91,93.91 CV77.2 40.21,94.41 RPV11.6 ; UV6.R1 35.32,72.14 v2(35.61,72.43) ; UV5.B2 v2(72.15,94.38) ; UV5.G7 67.75,97.98 v2(67.35,97.58) ; UV5.A1 v2(72.15,92.78) ; UV6.D2 v2(44.52,71.63) ; UV6.K8 v2(39.72,66.03) ; UV6.N9 36.92,65.62 v2(36.52,65.22) ; v2(71.35,95.98) 71.75,95.58 UV5.D2 ; UV5.N9 66.02,102.65 65.56,102.65 65.22,103 v2(65.22,103.19) ; v2(36.51,72.96) 36.72,72.96 37.03,72.64 37.03,72.14 UV6.N1 ; UV9.G7 v2(52.87,97.58) ; UV6.A8 46.52,66.43 v2(46.92,66.03)
  TOP w0.305: CV164.1 v2(64.01,94.54) ; CV198.1 63.62,93.96 v2(64.01,93.96)
  TOP w0.356: CV78.2 v2(41.55,103.15) ; v2(49.65,96.57) 49.33,96.89 CV247.1 ; v2(43.3,77.84) 43.77,77.37 CV257.1 ; CV250.1 v2(49.84,95.5)
  TOP w0.508: v2(49.71,97.46) 49.52,97.65 CV248.1 ; CV265.1 v2(35.36,63.55) ; CV270.1 v2(36.38,63.55) ; CV162.1 v2(63.89,92.84) ; CV251.1 49.78,99.43 v2(49.97,99.62)
  IN1 w0.254: v2(42.12,66.83) 42.12,66.82 v2(42.92,66.02) v2(43.72,66.83)
  IN3 w0.508: v2(41.98,83.81) 41.78,83.81 40.28,85.3 v2(39.72,85.3)
  BOTTOM w0.21: 55.08,79.64 53.78,79.64
  BOTTOM w0.215: 53.78,79.64 v2(53.76,79.66) ; UV1.H26 55.08,79.64
  BOTTOM w0.25: UV1.E26 54.71,82.54 v2(54.02,82.54) ; v2(54.56,77.2) 54.58,77.18 UV1.L26
  BOTTOM w0.254: UV7.R1 34.9,86.92 v2(34.16,86.92) ; v2(36.77,87.05) 36.92,86.9 UV7.N1 ; v2(72.95,104.78) 72.55,104.38 UV5.R1 ; v2(58.47,94.38) 58.07,94.78 UV9.C1 ; UV4.D2 52.47,95.58 v2(52.07,95.98) ; UV6.C9 v2(44.52,65.22) ; UV8.F1 v2(65.75,96.78) ; UV15.A8 v2(46.12,86.1) ; UV1.L22 58.64,77.48 59.17,77.48 ; v2(72.15,99.18) 72.55,98.78 UV8.H9 ; UV4.E9 v2(58.47,96.78) ; UV5.K2 v2(72.15,99.98) ; UV8.G7 70.89,98.04 v2(70.41,98.04) ; UV8.A8 71.75,93.18 v2(72.15,92.78) ; v2(35.61,72.43) 35.32,72.14 UV6.R1 ; v2(42.92,79.7) 42.52,80.1 UV15.F1 ; v2(72.95,94.38) 72.55,94.78 UV5.C1 ; v2(58.79,103.53) 58.07,102.81 UV9.N1 ; v2(67.35,100.07) 67.04,100.38 UV5.K8 ; UV15.H2 v2(40.52,80.5) 40.52,80.5 39.72,80.5 UV7.K8 ; UV14.D2 44.12,66.43 v2(43.72,66.83) ; UV14.H9 40.9,72.03 v2(40.49,71.61) ; UV15.B2 45.72,80.9 v2(45.32,81.3) ; UV9.K8 v2(52.87,99.98) 52.87,99.98 52.87,99.18 UV4.H2 ; UV7.K2 39.32,85.7 v2(39.72,85.3) ; v2(66.56,99.21) 66.95,98.82 UV8.H2 ; UV4.A8 v2(57.67,92.78) ; v2(46.83,80.51) 46.52,80.2 UV15.A1 ; UV4.F1 v2(51.27,96.78) ; v2(36.13,79.37) 36.86,80.1 UV7.N9 ; v2(72.95,95.18) 72.55,95.58 UV8.D9 ; UV14.G7 41.72,70.43 v2(42.12,70.82) ; UV5.N1 72.55,102.78 v2(72.95,103.18) ; UV9.C9 v2(51.27,94.38) ; UV9.N9 51.52,102.92 v2(51.12,102.92) ; UV8.A1 66.15,93.18 v2(66.55,92.78) ; UV15.G7 41.81,84.81 41.81,83.98 v2(41.98,83.81) ; UV4.D9 58.07,95.58 v2(58.47,95.18) ; UV9.R1 58.07,104.42 v2(58.48,104.83) ; UV7.R9 35.25,80.1 v2(34.89,79.74) ; UV14.H2 v2(40.52,66.03) ; UV7.C1 v2(45.32,86.91) ; v2(72.95,96.78) UV8.E9 ; v2(36.52,65.22) 36.92,65.62 UV6.N9 ; UV8.B2 66.95,93.98 v2(67.35,93.58) ; UV4.G7 55.64,97.98 v2(55.38,97.72) ; v2(34.92,65.22) 35.32,65.62 UV6.R9 ; UV7.C9 44.92,80.1 v2(45.32,79.7) ; UV1.H24 57.12,79.24 59.25,79.24 ; 52.47,93.98 UV4.B2 v2(52.07,93.58) ; v2(65.74,104.09) 66.03,104.38 UV5.R9 ; v2(44.52,86.91) UV15.D9 v2(43.72,86.1) 43.32,86.5 UV15.E9 ; UV8.D2 v2(66.55,95.18) ; UV14.E9 v2(42.92,72.43) ; UV14.A8 v2(46.92,71.63) ; UV14.F1 v2(42.92,66.02) ; v2(36.51,72.96) 36.7,72.96 37.05,72.61 37.05,72.15 UV6.N1 ; UV9.R9 51.67,104.39 51.25,104.8 v2(51.25,105.54) ; UV4.H9 58.07,98.78 v2(57.67,99.18) 57.67,99.18 57.67,99.98 UV9.K2 ; UV15.H9 v2(41.32,86.91) ; UV14.B2 v2(45.32,66.03) ; UV5.N9 66.03,102.67 65.53,102.67 65.22,102.98 v2(65.22,103.19) ; UV6.K8 v2(39.72,66.03) ; UV5.C9 v2(65.75,94.38) ; UV6.C1 v2(45.32,72.43) ; UV6.K2 39.32,71.13 v2(39.62,70.83) ; UV4.A1 v2(52.07,92.78) ; UV14.A1 v2(46.92,66.03) ; UV14.D9 v2(44.52,72.43) ; UV15.D2 44.12,80.9 v2(44.52,80.5)
  BOTTOM w0.3: UV1.B26 v2(55.49,84.21) UV1.C25 ; UV1.E23 57.45,82.15 v2(57.13,82.47) ; v2(56.29,76.77) 56.29,76.77 UV1.L24
  BOTTOM w0.356: CV199.1 v2(74.71,99.62) ; v2(64.01,93.96) 63.84,93.78 CV198.1 ; v2(43.3,77.84) 43.4,77.84 CV257.1 ; CV247.1 49.33,96.89 v2(49.65,96.57) 49.33,96.26 CV246.1 ; CV164.1 v2(64.01,94.54) ; CV240.1 v2(60.1,94.52)
  BOTTOM w0.508: CV166.1 v2(74.8,97.02) ; v2(46.6,102.86) 47.05,102.42 RV115.1 ; CV280.1 v2(37.01,63.55) ; v2(36.63,88.57) 36.06,89.15 CV279.1 ; CV249.1 49.4,98.54 v2(49.59,98.73) ; CV170.1 v2(74.61,100.64) ; CV204.1 v2(74.8,97.91) ; v2(49.97,99.62) 49.78,99.43 CV251.1 ; v2(63.89,92.84) CV162.1 ; CV248.1 49.52,97.65 v2(49.71,97.46) ; CV205.1 v2(74.8,98.8) ; CV236.1 48.77,104.5 CV238.1 49.21,104.51 49.46,104.77 v2(49.46,105.8) 49.44,105.78 CV243.1 ; CV256.1 v2(30.54,86.61) ; CV261.1 v2(30.6,85.59)
  vias: v2(33.88,96.92) v2(35.35,92.37) v2(39.3,91.24) v2(40.13,63.55) v2(40.82,63.55) v2(41.9,63.55) v2(42.92,63.55) v2(44.13,63.55) v2(44.76,77.92) v2(44.76,63.55) v2(45.4,63.55) v2(45.46,77.91) v2(59.32,76.98) v2(59.51,79.9) v2(59.51,78.43) v2(59.6,80.92) v2(59.64,71.23) v2(60.19,79.94) v2(60.32,75.38) v2(63.76,80.14) v2(64.1,79.48) v2(64.59,80.17) v2(65.4,80.13) v2(74.73,107.39) v2(75.43,107.39) v2(85.21,89.21) v2(85.91,89.84) v2(85.91,89.21) v2(86.61,90.48) v2(86.61,89.84) v2(86.61,89.21) v3(79.24,106.8)
+1VALWP: length 14.9
  TOP w0.254: 182.43,37.77 183.38,37.77 184.59,38.98 184.59,46.6 v2(183.83,47.36)
  BOTTOM w0.254: PR306.1 183.54,49.98 PC307.1 184.06,49.09 184.4,48.76 184.4,47.93 v2(183.83,47.36)
  vias: v2(175.95,38.03) v2(176.59,38.03) v2(176.71,39.74) v2(177.22,38.03) v2(177.35,39.74) v2(177.86,38.03) v2(177.98,39.74) v2(178.49,38.03) v2(178.62,39.74) v2(179.13,38.03) v2(179.25,39.74) v2(179.89,39.74) v3(179.83,37.39)
+3V_1.8V_PGPPA: length 8.4
  TOP w0.254: RC196.2 RC197.2 150.36,87.24 149.79,86.67 v1(149.41,86.67) 148.71,86.67 148.46,86.41 144.59,86.41 v2(144.4,86.6)
  BOTTOM w0.254: v2(144.4,86.6) 143.98,87.12 UC1.AK15
+3V_PGPPB: length 2.2
  TOP w0.381: v2(143.71,88.37) 144.14,88.8 CC102.1 144.39,88.73 RC161.2
  BOTTOM w0.254: UC1.AG15 143.92,88.72 143.92,88.65 v2(143.71,88.37)
+3V_PGPPC: length 16.5
  TOP w0.254: v2(142.94,91.73) 142.98,91.77 CC73.1
  TOP w0.508: RC163.2 154.62,94.1 154.35,94.37 153.63,94.37 v2(153.54,94.46)
  IN2 w0.254: v2(153.54,94.46) 153.11,94.03 151.51,94.03 150.88,94.67 148.21,94.67 147.76,94.22 147.76,92.76 147.44,92.45 143.25,92.45 142.94,92.14 v2(142.94,91.73)
  BOTTOM w0.254: UC1.Y16 143.25,92.15 143.01,91.83 v2(142.94,91.73)
+3V_PGPPD: length 3
  TOP w0.305: CC103.1 145.74,90.87 RC172.2 145.28,90.87 v1(144.71,91.43) 144.5,91.43 v2(144.22,91.71)
  BOTTOM w0.254: v2(144.22,91.71) 143.98,91.95 UC1.Y15
+3V_PGPPE: length 20.6
  TOP w0.254: v2(143.68,93.41) 143.68,92.77 CC74.1
  IN2 w0.254: v2(160.08,94.48) 160.08,94.47 159.89,94.29 154.68,94.29 154.04,94.92 151.82,94.92 151.73,95.01 148.07,95.01 147.66,94.61 145.6,94.61 145.03,94.03 145.03,93.4 144.58,92.96 144.01,92.96 143.68,93.29 v2(143.68,93.41)
  BOTTOM w0.254: UC1.T16 143.32,93.82 143.6,93.54 143.6,93.48 v2(143.68,93.41)
  BOTTOM w0.508: RC167.2 159.7,94.1 160.08,94.47 v2(160.08,94.48)
+3V_PRIM: length 353.7
  TOP w0.254: CC63.1 140.33,86.11 140.33,86.86 140.52,87.05 140.71,87.05 141.05,87.39 v2(141.05,87.54)
  TOP w0.381: RC161.1 v2(146.45,88.73) 146.45,88.78 146.88,89.22 149.21,89.22 149.47,88.95 RC171.1 ; RI54.1 17.72,61.26 16.81,62.17 RI55.1 ; v2(144.44,90.89) 144.44,90.55 RC172.1
  TOP w0.457: RC221.1 151.19,72.48 v2(151.47,72.76)
  TOP w0.508: RC110.2 151.19,73.04 v2(151.47,72.76) ; RC327.2 160.57,62.4 160.2,62.03 160.2,61.78 v2(159.76,61.34) 159.95,61.15 RC108.1 ; v2(157.41,103.24) 157.41,102.73 158.88,101.26 v2(158.88,100.83) 158.88,98.34 159.25,97.97 ; RC197.1 RC171.1 ; v2(27.49,56.63) 21.71,56.63 17.84,60.51 RI54.1 ; RC154.1 RC221.1
  IN1 w0.508: v2(157.92,97.46) 157.88,97.5 157.88,98.52 158.6,99.24 v2(160.27,99.24) 160.78,99.24 162.74,97.27 166.97,97.27 172.68,91.57 172.68,82.8 174.01,81.46 174.01,78.63 175.63,77.01 175.63,65.46 174.81,64.63 174.81,61.01 173.6,59.81 173.6,58.12 172.24,56.76 v2(172.22,56.76)
  IN2 w0.508: v2(172.22,56.76) 171.75,56.28 171.75,55.03 169.72,53.01 168.97,53.01 ; v2(151.47,72.76) 151.47,72.41 153.18,70.7 153.18,64.75 154.32,63.62 157.84,63.62 158.61,62.85 159.7,62.85 160.21,62.34 160.21,61.79 v2(159.76,61.34) 159.76,60.25 158.87,59.36 158.87,57.71 159.96,56.62 162.79,56.62 163.35,56.06 163.35,54.06 164.4,53.01 168.97,53.01 ; v2(27.49,56.63) 28.7,56.63 41.14,44.19 45.21,44.19 55.68,33.72 80.42,33.72 81.7,35.01 88.66,35.01 92.72,39.07 157.56,39.07 159.89,41.39 v2(161.47,41.39) ; 168.97,53.01 168.97,47.49 168.24,46.76 v2(168.11,46.76) 168.83,46.04 170.8,46.04 172.07,44.77 173.72,44.77 176.08,42.41 176.08,39.23 176.52,38.79 182.56,38.79 183,39.23 183,42.07 v2(183.14,42.21)
  BOTTOM w0.254: v2(139.34,92.19) 139.56,91.96 139.56,88.47 UC1.AJ21 140.49,87.54 v2(141.05,87.54) 141.37,87.86 UC1.AJ19 ; RPC7.5 157.55,97.83 v2(157.92,97.46) 157.79,97.33 RPC7.6 ; UC1.V19 141.05,92.66 141.05,92.59 v2(141.01,92.55) ; v2(144.44,90.89) 144.3,90.76 144.26,90.76 UC1.AD15 ; RPC7.8 157.49,96.33 157.73,96.57 v2(157.85,96.57) 157.6,96.83 RPC7.7
  BOTTOM w0.508: v2(160.27,99.24) 160.52,98.99 QC3.5 ; v2(156.46,90.54) 156.85,90.15 RC64.2 157.08,89.93 157.66,89.35 158.26,89.35 RC68.2 ; v2(157.41,103.24) 159.33,105.16 159.33,107.33 158.24,108.42 158.24,109.27 156.58,110.93 153.7,110.93 151.68,108.91 151.68,108.82 151.5,108.64 ; PR314.1 v2(183.14,42.21) ; v2(168.11,46.76) 166.84,46.76 v2(161.47,41.39) ; v2(160.08,95.11) 160.52,95.56 QC3.2 ; RC167.1 RC202.1 157.92,94.99 v2(157.73,94.8) 157.54,94.99 RC50.2 RC49.2 ; RC233.2 158.32,100.27 v2(158.88,100.83)
  vias: v2(139.31,92.87) v2(153.23,91.68) v2(153.79,91.69) v3(167.82,96.57)
+3V_PRIM_RTC: length 0.6
  BOTTOM w0.254: v2(143.06,87.54) 142.68,87.15 UC1.AK17
  vias: v1(144.96,86.86)
+3V_PRIMJP:
  vias: v1(175.32,92.38)
+3V_SPI: length 121.5
  TOP w0.381: v2(179.63,20.25) 179.66,20.27 CC8.1
  TOP w0.508: RC154.2 v2(150.3,70.48)
  IN2 w0.508: 158.81,79.81 155.12,76.13 151.47,76.13 149.47,74.13 149.47,71.3 v2(150.3,70.48) 150.42,70.35 151.75,70.35 152.34,69.75 152.34,68.95 151.63,68.24 151.63,67.22 151.95,66.9 151.95,52.94 153.21,51.68 164.71,51.68 166.49,49.9 166.49,46.85 170.36,42.98 173.6,42.98 174.4,42.18 174.4,37.04 175.51,35.93 175.51,34.34 176.52,33.33 176.52,23.36 v2(179.63,20.25) ; 158.81,79.81 158.81,80.76 159.19,81.14 v2(159.73,81.14) ; 158.81,79.81 v2(159.82,79.81)
  IN3 w0.254: v2(143.71,87.54) 143.71,87.5 143.27,87.06 142.7,87.06 142.2,86.56 142.2,85.57 142.13,85.5 142.13,82.6 147.57,77.16 147.57,73.21 v2(150.3,70.48)
  BOTTOM w0.254: RC53.2 RC48.2 157.54,82.22 157.66,82.1 157.66,81.4 157.79,81.27 159.61,81.27 v2(159.73,81.14) ; UC1.AJ16 143.33,87.93 v2(143.71,87.54)
  BOTTOM w0.508: v2(179.63,20.25) 180.33,19.55 UC2.8 ; RC47.2 v2(159.82,79.81)
+3VALW: length 522.4
  TOP w0.254: RPE2.6 128.45,6.09 v2(128.52,6.02) 128.09,5.59 RPE2.5 ; RPE2.8 128.34,7.09 v2(128.52,6.91) 128.2,6.59 RPE2.7 ; RPE6.4 126.08,9.72 v2(125.92,9.57) 125.92,10.03 126.11,10.22 RPE6.3 ; RPE5.2 126.11,15.74 v2(125.91,15.93) 126.22,16.24 RPE5.1 ; RPE4.4 145.17,23.75 v2(145.41,23.99) 145.67,23.74 RPE4.3 ; RPE6.1 126.08,11.22 v2(125.94,11.08) 126.3,10.72 RPE6.2 ; RPE4.1 146.67,23.75 v2(146.42,23.99) 146.17,23.74 RPE4.2 ; RPE5.4 126.16,14.74 v2(125.91,14.98) 126.17,15.24 RPE5.3
  TOP w0.381: v2(157.6,68.19) 157.23,67.82 UC11.5 ; v2(125.22,20.06) 125.72,20.57 CC92.1 125.88,21.07 125.6,21.35 125.6,22.03 125.91,22.34 UC13.5 ; v2(169.88,47.93) 169.88,47.59 170.19,47.28 UC15.5
  TOP w0.508: RE361.2 126.85,17.14 126.1,17.14 125.85,17.39 v2(125.85,17.77) ; RC115.1 150.11,73.19 v2(150.11,72.76) ; v2(125.22,20.06) v3(125.69,19.58) 126.14,19.13 126.94,19.13 RE348.2 ; v2(151.86,6.55) 151.86,6.06 151.57,5.77 RE358.2 ; RE384.1 123.18,10.28 122.93,10.02 v2(122.93,9.77) 122.61,10.09 RE392.1 ; 175.76,95.5 175.77,95.51 176.1,95.18 177.98,95.18 178.31,95.51 RC166.2 ; v2(27.23,96.85) 27.23,98.28 PR3.2 ; PR28.1 37.85,113.77 38.35,113.28 38.35,111.62 v2(38.54,111.43) ; v2(126.13,8.32) 126.24,8.44 RE360.2 ; v2(193.86,64.25) 193.87,64.27 RM11.1 ; v2(124.03,3.6) 123.97,3.66 122.3,3.66 RE390.1 ; v2(23.93,69.08) 23.49,69.52 RE400.1 ; v2(18.34,16.95) v2(18.34,20.82) 18.34,21.9 v3(21.01,24.57) 23.68,27.23 23.68,32.31 22.54,33.46 19.42,33.46 18.28,34.6 18.28,41.2 18.96,41.89 v2(18.96,45.92) ; v2(122.93,11.05) 122.92,11.04 RE393.1 ; RE391.1 RE394.1 v2(122.87,9.14) ; RE380.1 153.6,16.44 153.94,16.78 153.94,18.27 RE332.2 ; RE363.1 141.14,24.96 v2(141.79,24.31) ; v2(192.78,51.93) 192.02,51.17 187.84,51.17 v3(186.53,49.86) 184.86,48.19 v2(183.83,48.19) ; v2(161.16,58.28) 160.79,57.92 RC123.1 ; DC8.2 30.52,13.43 RC209.1 30.98,13.44 31.21,13.21 v2(31.21,12.07)
  IN1 w0.508: v2(179.25,53.46) 179.25,54.28 179.7,54.73 182.05,54.73 183.06,53.71 183.06,48.95 v2(183.83,48.19) ; v2(27.23,96.85) 18.5,96.85 15.68,94.03 15.68,78.22 12.57,75.11 v2(12.57,68.18)
  IN2 w0.508: v2(110.86,112.01) 109.66,110.8 107.44,110.8 106.63,111.61 93.39,111.61 92.7,110.93 88,110.93 87.31,110.23 84.51,110.23 83.43,111.31 80.07,111.31 76.38,114.99 40.63,114.99 38.35,112.71 38.35,111.62 v2(38.54,111.43) ; v2(161.16,58.28) 162.17,59.3 163.25,59.3 ; v2(79.22,9.71) 78.01,8.5 64,8.5 61.59,10.91 61.59,13.71 60.32,14.98 55.62,14.98 54.76,14.12 52.29,14.12 50.03,11.87 40.38,11.87 40,11.48 31.79,11.48 v2(31.21,12.07) 30.63,11.48 28.38,11.48 25.43,14.44 22.63,14.44 20.69,16.37 18.92,16.37 v2(18.34,16.95) ; v2(125.22,20.06) 125.22,18.79 125.85,18.15 v2(125.85,17.77) 125.85,15.99 v2(125.91,15.93) v2(125.91,14.98) ; v2(169.88,47.93) 169.88,52.02 171.32,53.46 v2(179.25,53.46) 179.25,55.74 177.6,57.4 170.94,57.4 170.49,56.95 166.1,56.95 165.71,56.57 164.08,56.57 163.76,56.89 163.76,58.79 163.25,59.3 ; 163.25,59.3 163.25,63.3 161.91,64.65 160.43,64.65 159.95,65.13 159.95,66.22 159.12,67.05 158.74,67.05 v2(157.6,68.19) 157.6,68.75 157.14,69.21 155.67,69.21 155.28,69.6 155.28,70.29 155.54,70.55 157.46,70.55 158.22,71.31 158.22,75.38 158.24,75.39 ; 158.24,75.39 153.56,75.39 152.39,74.22 150.92,74.22 150.11,73.41 v2(150.11,72.76) ; 158.24,75.39 159.86,77.02 160.01,77.02 v2(160.71,77.72) ; v2(141.79,24.31) 145.09,24.31 v2(145.41,23.99) v2(146.42,23.99) 147.12,23.99 148.08,23.04 148.08,18.98 151.12,15.93 152.39,15.93 v2(154.04,14.28) 154.04,7.84 152.76,6.55 v2(151.86,6.55)
  IN3 w0.508: v2(18.96,45.92) 14.98,49.9 9.01,49.9 7.93,50.98 7.93,60.95 8.88,61.9 8.88,65.14 11.92,68.18 v2(12.57,68.18) 23.03,68.18 v2(23.93,69.08) ; v2(141.79,24.31) 139.12,24.31 137.09,22.28 135.88,22.28 135.38,22.79 132.14,22.79 131.25,21.9 131.25,20.88 130.68,20.31 125.47,20.31 v2(125.22,20.06)
  IN3 w1.016: 176.59,98.42 177.42,97.58 188.59,97.58
  BOTTOM w0.381: UC12.5 110.33,109.58 CC83.1
  BOTTOM w0.508: v2(110.86,112.01) 110.38,111.52 CC83.1 ; v2(27.23,96.85) 27.23,97.55 38.54,108.85 v2(38.54,111.43) ; PR16.2 18.34,20.2 v2(18.34,20.82) ; RC9.1 159.34,77.14 159.63,77.44 160.43,77.44 v2(160.71,77.72) ; PR37.1 v2(18.34,16.95) ; PR209.1 79.3,14.98 ; v2(187.7,19.93) 188.58,20.81 RA10.1 ; RL40.1 v2(188.52,93.58) ; PR307.1 v2(183.83,48.19)
  BOTTOM w1.016: 79.3,13.9 79.3,19.1 81.02,20.82 82.92,20.82
  vias: v2(79.22,12.88) v2(79.22,12.25) v2(79.22,11.61) v2(79.22,10.98) v2(79.22,10.34) v2(79.75,12.56) v2(79.75,11.93) v2(79.75,11.29) v2(79.75,10.66) v2(79.75,10.02) v2(79.75,9.39) v2(172.65,12.37) v2(173.28,13.64) v2(173.28,13.01) v2(173.28,12.37) v2(173.92,13.64) v2(173.92,13.01) v2(173.92,12.37) v2(175.76,99.5) v2(175.76,98.86) v2(188.97,96.77) v2(189.52,96.44)
+3VALW_DSW: length 222.3
  TOP w0.254: RPC11.7 158.04,62.67 158.31,62.4 v2(158.31,62.19)
  TOP w0.508: RC103.1 152.65,71.23 152.65,70.62 RC106.1 151.39,70.24 151.39,70.23 151.28,70.23 v2(150.74,69.7) ; RC209.2 28.54,13.44 27.84,14.14 v2(27.84,14.76) ; RC111.2 152.3,67.35 v2(152.3,67.99) 154.2,67.99 154.62,68.41 154.62,69.13 RC104.1 ; v2(142.36,90.05) 142.36,89.57 142.46,89.47 142.46,87.65 v2(142.35,87.54) ; v2(50.35,42.56) 49.93,42.14 35.1,42.14 v2(33.67,43.57)
  IN2 w0.508: v2(150.74,69.7) 146.53,69.7 145.4,68.56 145.4,48.49 143.83,46.93 96.67,46.93 95.89,46.16 95.89,41.78 94.81,40.7 90.44,40.7 86.99,37.25 81.73,37.25 79.83,35.35 56.24,35.35 50.35,41.24 v2(50.35,42.56) ; v2(33.67,43.57) 33.27,43.57 32.48,44.35 23.53,44.35 22.23,43.06 22.23,32.62 23.31,31.54 23.31,23.74 22.18,22.61 22.18,18.58 26,14.76 v2(27.84,14.76)
  IN3 w0.508: v2(158.31,62.19) 157.39,63.11 154.82,63.11 152.77,65.16 152.77,66.16 152.3,66.63 v2(152.3,67.99) 151.92,67.99 150.74,69.18 v2(150.74,69.7)
  BOTTOM w0.254: UC1.AD17 v2(142.36,90.05) 142.3,90.13 UC1.AD18 ; UC1.AJ17 142.39,87.59 v2(142.35,87.54)
+3VALW_EC: length 300.8
  TOP w0.203: UE5.22 147.48,13.75 148.01,14.28 148.51,14.28 CE67.1 ; CE78.1 134.82,2.54 135,2.73 UE5.103 ; RE352.1 148.31,6.95 UE5.5 ; v2(140.77,21.14) 140.77,20.5 141,20.27 UE5.43 ; CE63.1 139.71,2.09 139.8,2.19 UE5.115 ; UE5.65 130.25,17.75 128.96,19.04 128.96,19.98 128.63,20.31 CE69.1 ; UE5.19 147.68,12.55 148.08,12.95 v2(148.08,13.58) ; UE5.82 129.88,10.95 128.71,12.12 128.34,12.12 CE65.2
  TOP w0.254: RE352.1 148.71,6.74 149.1,6.34 149.84,6.34 CE66.1
  TOP w0.508: v2(13.11,47.01) v3(13.11,47.68) 13.11,48.03 9.9,51.24 9.9,55.62 10.58,56.3 JLED.3 14,56.3 v2(14.16,56.14) ; CE78.1 135.34,1.58 135.57,1.81 v2(135.57,2.34) ; RE342.1 151.5,15.23 CE62.1 150.03,13.76 CE67.1 148.25,13.76 v2(148.08,13.58) ; CE64.2 CE70.1 140.26,21.64 v2(140.77,21.14) ; CE66.1 150.16,6.67 149.98,6.85 v2(149.47,6.85) ; v2(147.19,22.34) 147.58,22.74 RE354.2 ; RE351.2 RE350.2 ; RE350.2 150.74,9.83 v2(151.06,10.15) ; RE350.2 RE349.2 RE347.2 ; CE65.2 v2(128.15,12.95) ; v2(137.03,23.74) 137.22,23.55 RE346.2 ; CE69.1 CE68.1 128.53,21.58 v2(128.9,21.58) ; v2(116.59,4.25) RE343.1 R2452.1 117.52,2.62 CE80.1 ; RI94.2 v2(16.44,45.97) ; v2(140.58,2.34) 140.58,1.96 140.2,1.58 CE63.1 ; RI93.2 v2(16.44,38.41)
  IN2 w0.508: v2(16.44,45.97) 16.41,47.01 v2(13.11,47.01) 13.11,45.87 14.15,44.82 14.15,39.11 14.85,38.41 v2(16.44,38.41) ; v2(116.59,4.25) 117.54,3.29 123.48,3.29 123.86,2.91 126.87,2.91 127.5,2.28 129.35,2.28 130.01,2.94 134.97,2.94 v2(135.57,2.34) ; v2(149.47,6.85) 151.06,8.44 v2(151.06,10.15) 150.42,10.15 148.08,12.5 v2(148.08,13.58) 147.38,14.28 147.38,22.15 v2(147.19,22.34) 146.87,22.66 142.3,22.66 v2(140.77,21.14) 138.17,23.74 v2(137.03,23.74) 137.03,24.06 136.71,24.38 131.69,24.38 v2(128.9,21.58) 127.09,23.38 105.98,23.38 96.28,33.09 53.88,33.09 43.48,43.49 40.94,43.49 33,51.43 31.8,51.43 28.18,55.05 15.26,55.05 v2(14.16,56.14)
  BOTTOM w0.508: v2(149.47,6.85) 146.36,3.74 142.04,3.74 140.65,2.34 v2(140.58,2.34) 140.39,2.34 139.76,2.98 136.2,2.98 v2(135.57,2.34) 134.55,3.36 132.64,3.36 131.76,4.25 131.76,5.39 133.98,7.61 133.98,10.28 134.55,10.85 134.55,11.8 133.85,12.5 133.03,12.5 132.52,11.99 128.83,11.99 128.15,12.68 v2(128.15,12.95)
+3VALWP: length 58.5
  TOP w0.508: PR113.1 59.1,29.02 v2(59.11,29.04)
  IN1 w0.508: v2(59.11,29.04) 56.15,29.04 55.81,28.69 55.81,23.17 57.97,21.01 57.97,20.31 59.68,18.6 62.92,18.6 v2(63.87,17.64) 65.02,18.79 77.65,18.79 78.23,18.22 78.23,16.63 v2(77.4,15.8)
  BOTTOM w0.254: PR109.1 63.24,19.4 PR108.2 63.26,19.51 63.75,19.99 65.26,19.99 66.06,19.19 77.76,19.19 78.54,18.41 78.54,16.32 78.02,15.8 77.84,15.8
+3VL_RTC: length 287.9
  TOP w0.381: CC79.1 141.18,86.21 v2(140.78,86.6) 141.52,86.6 CC84.1
  TOP w0.508: 148.65,69.65 148.65,70.79 148.19,71.25 RC94.1 148.32,71.68 RC93.1 147.82,72.19 147.33,72.68 147.33,75.13 147.33,75.13 147.33,75.35 v1(146.65,76.03) 146.04,76.64 146.04,78.41 144.99,79.46 v2(144.03,79.46) ; 148.65,69.65 147.43,69.65 RC91.1 ; 148.65,69.65 148.65,68.86 149.32,68.19 v2(149.41,68.19) ; DC8.1 28.22,9.14 DC1.1 v2(28.23,7.97) ; v2(150.57,4.04) 150.46,3.93 149.74,3.93 RE370.2 ; RE345.2 154.81,4.44 v2(154.74,4.5) ; RE376.1 v2(154.17,5.71)
  IN1 w0.508: v2(154.17,5.71) 153.68,5.71 151.9,3.93 150.69,3.93 v2(150.57,4.04)
  IN2 w0.508: v2(150.57,4.04) 150.14,3.61 147.43,3.61 145.39,1.57 122.35,1.57 121.3,2.62 111.79,2.62 110.36,4.06 105.89,4.06 102.9,7.05 63.34,7.05 57.76,12.63 52.91,12.63 49.71,9.43 49.71,7.55 49.23,7.07 34.26,7.07 33.36,7.97 v2(28.23,7.97) ; 178.94,19.36 176.71,17.14 167.92,17.14 157.7,6.91 156.14,6.91 154.93,5.71 v2(154.17,5.71) ; 178.94,19.36 175.89,22.41 175.89,33.07 174.87,34.08 174.87,35.61 173.77,36.72 173.77,41.86 173.41,42.22 170.16,42.22 165.78,46.6 165.78,49.65 164.45,50.98 152.77,50.98 151.31,52.44 151.31,66.64 149.76,68.19 v2(149.41,68.19) ; 178.94,19.36 182.75,19.36 183.17,19.78 v2(185.07,19.78)
  IN3 w0.254: v2(140.78,86.6) 140.78,86.09 141.21,85.66 141.21,85.5 141.21,85.5 141.21,85.12 141.21,85.12 141.21,84.87 141.21,84.86 141.21,84.48 141.21,84.48 141.21,84.29 141.22,84.28 141.22,83.61 141.21,83.59 141.21,82.58 141.21,82.58 141.21,82.56 141.57,82.21 141.87,82.21 144.03,80.04 v2(144.03,79.46)
  BOTTOM w0.178: UC1.BB14 144.12,79.45 144.11,79.43 144.06,79.43 v2(144.03,79.46)
  BOTTOM w0.254: UC1.AK19 140.81,86.62 v2(140.78,86.6)
  BOTTOM w0.508: RA11.1 190.09,22.09 187.38,22.09 v2(185.07,19.78) ; v2(154.74,4.5) 154.74,5.44 154.48,5.71 v2(154.17,5.71)
+3VL_RTC_VBAT: length 18.7
  TOP w0.102: v1(153.66,1.92) 153.41,2.18 RE345.1
  TOP w0.203: v2(142.23,2.34) 142.23,2.35 142.6,2.72 UE5.122
  TOP w0.508: CE72.1 142.12,2.23 v2(142.23,2.34) ; RE345.1 153.41,3.79 153.74,4.12 153.88,4.12 v2(154.07,4.31)
  BOTTOM w0.508: v2(154.07,4.31) 153.88,4.31 152.8,5.39 149.03,5.39 146.71,3.07 142.96,3.07 v2(142.23,2.34)
+3VLP: length 168.9
  TOP w0.508: RE369.2 v2(156.72,4.36) ; v2(30.31,15.42) 30.33,15.42 30.96,14.8 v3(30.94,14.79) 31.84,13.89 31.84,11.08 30.87,10.1 DC1.3 ; v2(154.47,18.91) 154.16,19.23 RE333.2
  IN1 w0.508: v2(104.45,8.31) 103.42,7.28 78.18,7.28 76.51,8.94 76.51,14.53 75.18,15.87 v2(65.27,15.87)
  IN2 w0.508: v2(104.45,8.31) 106.67,6.09 118.1,6.09 118.4,5.8 121.49,5.8 121.79,6.09 123.37,6.09 124.64,4.82 127.18,4.82 127.95,4.06 127.95,3.36 128.39,2.91 129.09,2.91 129.75,3.57 142.03,3.57 142.65,2.95 145.87,2.95 148.2,5.28 151.8,5.28 153.98,3.1 155.82,3.1 156.72,4 v2(156.72,4.36) ; v2(65.27,15.87) 64.64,16.5 64.64,18.09 63.43,19.3 40.7,19.3 38.86,17.45 35.3,17.45 33.27,15.42 v2(30.31,15.42)
  BOTTOM w0.508: v2(156.72,4.36) 157.46,4.36 157.92,4.82 157.92,10.41 156.97,11.36 156.97,15.04 155.24,16.77 155.24,18.15 v2(154.47,18.91)
+3VS: length 778.1
  TOP w0.254: CI23.2 24.36,87.05 24.06,87.05 23.02,86.01 UI8.13 ; 158.04,55.87 157.03,56.89 157.03,59.05 156.77,59.3 156.77,61.84 157.04,62.11 RPC11.5 ; C2498.1 155.25,6.79 155.97,7.5 U2407.1 ; UI8.1 20.52,79.65 CI20.2
  TOP w0.381: UC3.5 163.24,63.48 162.68,62.92 162.68,60.86 CC14.1 ; v2(123.75,15.55) 123.42,15.55 123.17,15.29 UE6.5
  TOP w0.406: Q2409.2 158.7,16.77 R2457.1 ; R2456.1 155.01,16.77 Q2409.5
  TOP w0.457: v2(172.65,100.32) 172.9,100.32 173.11,100.52 RL33.1
  TOP w0.508: 183.89,18.15 184.84,19.1 189.29,19.1 190.02,18.37 v2(190.02,18.12) ; QE11.2 96.7,54.57 96.7,56.06 95.56,57.21 RE330.1 ; RX27.1 6.75,83.21 v2(6.75,82.69) ; QX4.2 194.75,78.74 v2(194.76,78.72) ; v2(82.07,70.65) 82.82,71.4 RV211.2 ; RE50.1 2.52,73.6 v4(2.91,73.21) ; RI53.1 24.76,77.02 24.46,76.72 RX10.1 22.64,74.88 22.22,75.3 22.22,77.21 ; v2(95.51,110.93) 95.64,111.05 98.46,111.05 99.07,111.66 105.01,111.66 106.89,109.78 108.2,109.78 109.15,108.83 109.15,107.43 109.91,106.67 109.91,104.13 108.44,102.66 RC388.2 ; RS26.1 188.91,6.91 187.89,5.9 185.98,5.9 185.35,6.53 ; RS38.2 CS42.1 CS27.1 180.02,8.47 180.73,9.19 182.7,9.19 v2(182.71,9.2) ; v2(198.05,85.2) 198.05,84.21 QX3.2 198.18,84.08 RX13.1 ; v2(144.34,23.37) 144.07,23.63 CE82.1 RE353.2 ; 157.09,73.38 RC118.1 RC125.1 159,73.38 ; RC218.1 v2(146.36,67.61) ; v2(26.47,64.32) 26.4,64.24 RE399.1 ; v2(157.16,104.51) 157.92,104.51 161.35,101.08 161.35,99.62 v2(161.66,99.31) ; QX4.5 194.75,75.62 194.38,75.25 192.54,75.25 192.53,75.24 ; v4(4.24,86.66) 4.25,86.67 CX1.1 ; v2(154.87,15.93) R2456.1 ; 163.57,60.76 164.32,60.76 164.95,60.13 166.93,60.13 168.52,61.71 170.55,61.71 v2(170.87,61.4) ; v2(171.51,36.19) 171.25,36.44 CD55.1 CD54.1 170.82,34.79 170.44,34.41 v2(170.44,33.33) ; v2(159.7,16.31) 159.7,16.69 159.51,16.88 R2457.1 158.81,17.83 160.27,19.3 162.44,19.3 v2(164.6,21.46) ; 163.19,59.81 162.6,59.22 RC329.2 161.85,57.97 161.72,57.83 RC178.1 RC129.1 160.79,56.2 160.46,55.87 158.04,55.87 ; v2(196.46,73.71) 196.97,74.22 RX12.1 ; RS30.1 RS20.1 185.35,6.53 ; CI23.2 24.43,86.62 24.75,86.3 v2(24.95,86.3) ; RC330.2 RC222.1 v2(157.74,95.88) ; v2(158.24,49.2) 158.12,49.09 CD26.1 CD27.1 ; 185.35,6.53 184.71,5.9 183.01,5.9 182.72,6.19 v4(182.72,6.57) 182.71,6.58 RS29.1 182.7,7.34 RS34.2 ; R2448.1 v2(159.31,14.09) ; v4(200.21,15.55) 200.21,15.1 CA57.1 199.26,14.6 198.76,14.1 CA58.1 ; v2(20.31,61.33) 20.24,61.26 RI88.1 ; v2(154.62,6.6) C2498.1 ; CA59.1 194.75,15.8 v4(195.26,15.29) 195.76,14.79 CA60.1 ; RI91.2 17.33,42.02 17.83,42.02 18.1,42.28 18.1,47.31 v2(18.34,47.55) ; v2(19.67,79.57) CI20.2 ; RS33.2 v2(186.87,14.28) ; RS28.1 RS19.1
  TOP w1.016: 16.31,87.68 16.31,100.83 13.96,103.18 10.47,103.18
  TOP w1.524: 89.66,29.07 89.66,48.76 88.19,50.22 88.19,55.55
  TOP w2.032: 185.1,85.61 186.64,85.61 191.38,80.88 191.38,78.03
  IN1 w0.508: v2(167.82,91.18) 167.63,91.37 v2(167.63,92.57) 168.27,93.21 168.27,94.1 v2(167.76,94.61) 161.1,94.61 160.01,93.53 v2(160.01,93.15) ; v2(95.51,110.93) 95.12,110.93 90.73,115.31 87.12,115.31 85.59,113.78 75.75,113.78 73.54,111.57 v2(73.54,109.66) ; v2(154.87,15.93) 155.12,15.68 159.06,15.68 v2(159.7,16.31) ; v2(198.05,85.2) 195.94,85.2 195.26,84.51 195.26,79.22 v2(194.76,78.72) 193.15,78.72 192.65,78.22 v2(192.65,77.37) 192.65,76.7 195.64,73.71 v2(196.46,73.71) ; v2(20.38,86.99) 21.27,86.1 24.75,86.1 v2(24.95,86.3)
  IN2 w0.508: v2(86.59,83.6) 86.95,83.24 86.95,80.69 84.93,78.67 84.93,73.47 82.11,70.65 v2(82.07,70.65) ; v2(146.36,67.61) 148.77,65.19 148.77,49.39 148.27,48.89 148.27,47.93 148.63,47.57 157.43,47.57 158.24,48.38 v2(158.24,49.2) ; v2(154.62,6.6) 159.31,11.29 v2(159.31,14.09) 159.31,15.93 v2(159.7,16.31) ; v2(190.02,18.12) 190.02,17.87 193.1,14.8 193.1,13.45 v2(192.46,12.82) ; v2(123.75,15.55) 123.8,15.59 v2(123.8,19.95) ; v2(24.12,65.65) 20.66,65.65 20.26,65.26 20.26,61.38 v2(20.31,61.33)
  IN3 w0.508: v2(6.75,82.69) 6.75,85.5 5.59,86.66 v4(4.24,86.66) ; 182.71,14.28 v2(186.87,14.28) ; 182.71,14.28 181.1,15.89 v2(181.1,17.2) ; 182.71,14.28 v2(182.71,9.2) 182.71,6.58 v4(182.72,6.57) ; v2(123.8,19.95) 124.36,19.38 127.37,19.38 127.67,19.68 132.07,19.68 132.38,19.98 138.23,19.98 138.49,20.24 138.49,20.95 140.26,22.72 141.92,22.72 142.56,23.37 v2(144.34,23.37) ; v4(2.91,73.21) 4.06,73.21 4.63,72.64 6.91,72.64 7.78,73.5 9.23,73.5 13.26,69.46 v2(18.98,69.46) ; v2(200.21,23.04) 199.85,23.04 198.3,21.49 198.3,18.22 200.21,16.31 v4(200.21,15.55) 199.45,15.55 198.94,16.06 196.02,16.06 v4(195.26,15.29) 194.49,14.53 194.49,13.52 193.8,12.82 v2(192.46,12.82) ; v2(73.54,109.66) 73.54,107.61 75.16,105.99 77.01,105.99 81.65,101.34 81.65,97.72 82.54,96.83 86.54,96.83 89.02,94.35 89.02,86.02 v2(86.59,83.6) 86.92,83.27 86.92,80.61 88.83,78.71 88.83,73.65 88.64,73.46 88.64,57.52 v2(88.39,57.27) 88.39,44.57 77.53,33.71 57.26,33.71 49.45,41.52 27.68,41.52 v2(23.42,45.77) 22.35,46.85 19.04,46.85 v2(18.34,47.55) v2(15.55,50.35)
  IN3 w1.016: 18.66,79.75 12.95,85.46 9.71,85.46 8.88,84.64 8.88,83.49 8.08,82.69 v2(6.75,82.69)
  BOTTOM w0.203: 199.32,23.04 198.94,23.04 198.73,22.83 UA1.36 ; UA1.9 195.53,15.68 ; 199.32,16.03 198.84,16.03 198.73,16.14 UA1.1
  BOTTOM w0.254: JEDP.34 2.47,82.5 v2(2.75,82.22) 2.53,82 JEDP.35
  BOTTOM w0.305: DB1.9 124.3,19.7 124.05,19.95 v2(123.8,19.95) DB1.10
  BOTTOM w0.356: v2(170.44,33.33) 170.76,33.33 170.95,33.52 JDIMM2.201 ; JDIMM2.199 170.35,35.79 170.74,36.19 v2(171.51,36.19)
  BOTTOM w0.381: QC2.2 161.73,93.83 RC390.1 ; QE6.2 24.44,65.33 v2(24.12,65.65) ; v2(158.24,49.2) 157.95,48.92 JDIMM1.199 ; QC2.5 161.73,90.35 161.21,89.83 RC391.1 ; 195.53,15.68 195.53,15.56 v4(195.26,15.29)
  BOTTOM w0.432: v2(26.41,65.65) 26.73,65.33 QE6.5
  BOTTOM w0.508: RC217.1 152.71,108.71 153.4,109.4 153.93,109.4 154.56,108.77 155.57,108.77 ; 155.57,108.77 156.2,109.4 157.16,109.4 157.54,109.02 157.54,107.51 RC206.2 158.31,107.19 158.69,106.81 158.69,105.42 157.78,104.51 v2(157.16,104.51) ; 155.57,108.77 155.58,108.75 RC215.1 155.57,107.99 RC224.1 ; v2(173.03,48.89) 172.71,49.2 167.52,49.2 166.13,47.81 161.47,47.81 160.08,49.2 v2(158.24,49.2) ; 81.78,49.22 82.56,49.22 88.39,55.05 v2(88.39,57.27) ; 81.78,49.22 PR804.2 ; 81.78,49.22 81.78,38.66 80,36.88 75.43,36.88 74.67,37.65 PR814.1 ; v2(157.16,104.51) 156.77,104.89 RC199.2 ; v2(157.16,104.51) 157.16,104.26 156.9,104 RC200.2 156.53,103.12 RC231.2 ; RA13.2 190.02,17.34 v2(190.02,18.12) ; v2(95.51,110.93) 95.51,110.7 95.25,110.43 PR612.1 ; RI19.1 24.3,86.22 RI42.1 24.89,86.24 v2(24.95,86.3) ; RI22.1 v2(22.6,77.91) ; v2(167.76,94.61) 167.5,94.35 RC318.1 RC314.1 ; v2(21.71,77.91) RI26.1 RI23.1 ; v2(172.65,100.32) 172.65,100.13 172.33,99.81 167.19,99.81 166.74,99.37 164.39,99.37 ; JIO.6 23.93,48.95 23.42,48.44 v2(23.42,45.77) ; RA14.1 201.1,15.17 200.72,15.55 v4(200.21,15.55) 199.73,16.03 199.32,16.03 ; RC320.2 167.76,91.24 v2(167.82,91.18) ; RC62.2 RC63.2 160.11,88.75 v2(160.14,88.73) ; RC322.2 157.6,92.26 v2(157.73,92.13) 157.85,92.26 RC395.1 RC394.1 ; v2(162.62,93.34) 162.62,93.65 162.24,94.03 RC390.1 ; RC325.1 v2(160.01,93.15) ; v2(161.85,85.46) 162.31,85.92 RC65.2 ; RC323.1 167.25,92.19 v2(167.63,92.57) 167.63,92.64 167.19,93.08 RC321.2 ; RC230.2 158.44,99.38 159.25,100.19 160.78,100.19 v2(161.66,99.31) ; 199.32,23.04 v2(200.21,23.04) ; v2(20.38,86.99) 20.75,86.62 RI20.1 ; v2(15.55,50.35) 15.23,50.66 11.98,50.66 RI89.1
  BOTTOM w2.032: 164.84,97.46 168.49,97.46 180.37,85.59 181.29,85.59
  vias: v2(17.71,86.99) v2(19.3,76.45) v2(19.93,76.45) v2(20.57,76.45) v2(89.21,27.93) v2(89.21,27.3) v2(89.85,27.93) v2(161.16,88.7) v2(161.47,73.84) v2(161.74,88.7) v2(161.92,74.22) v2(162.11,98.86) v2(162.32,88.7) v2(162.55,98.42) v2(163,97.97) v2(182.75,85.72) v2(182.75,85.08) v2(183.44,85.72) v2(183.44,85.08) v3(190.62,71.75) v4(173.93,22.18) v4(173.93,21.49) v4(174.62,22.15) v4(174.62,21.52) v4(175.25,22.15) v4(175.25,21.52)
+3VS_CAM: length 4
  TOP w0.508: RX27.2 4.63,83.94 3.59,83.94 v1(3.22,84.31) 2.79,84.74 v2(2.79,84.89)
  BOTTOM w0.254: JEDP.29 2.67,85
  BOTTOM w0.508: 2.67,85 2.79,84.88 v2(2.79,84.89)
+3VS_D: length 11
  TOP w1.016: QV6.3 95.14,66.96 95.97,66.13 v1(95.97,64.14) 95.97,60 95.34,59.38 93.97,59.38 93.96,59.39
+3VS_DGPU: length 81.1
  TOP w0.508: RV80.1 RV84.1 70.49,87.94 71.74,87.94 v3(72.25,88.45) v2(72.97,89.17) ; RV40.1 v2(78.25,78.38)
  IN1 w0.508: v2(72.97,89.17) 72.97,87.48 74.22,86.22 76.64,86.22 78.25,84.61 v2(78.25,78.38)
  IN3 w0.508: v2(86.29,82.67) 86.29,80.35 88.13,78.51 88.13,73.9 87.88,73.64 v2(87.88,59.74)
  BOTTOM w0.508: v2(87.88,59.74) 88.13,60 88.13,61.78 86.83,63.08 80.61,63.08 71.88,54.35 PR801.2 ; v2(86.29,82.67) 84.79,82.67 80.85,78.73 78.61,78.73 v2(78.25,78.38) ; RV81.1 v2(72.97,89.17)
+3VS_DGPU_AON: length 76.3
  TOP w0.254: RPV7.6 83.51,79.01 v2(83.19,78.69) 83.38,78.51 RPV7.7 ; RPV5.6 82.11,78.51 v2(82.37,78.25) ; RPV5.7 82.11,79.01 v2(82.37,79.27) 82.13,79.51 RPV5.8 ; RV58.1 69.12,81.16 69.12,83.59 69.53,84 70.41,84 71.49,85.09 71.49,85.4 72.66,86.57 76.72,86.57 79.22,84.07 80.06,84.07 RV69.2 80.69,83.43 81.84,83.43 v2(81.91,83.49)
  TOP w0.508: 80.45,65.33 78.29,65.33 77.84,65.78 CV5.1 ; 80.45,65.33 v3(80.45,67.11) 80.45,67.83 ; 80.45,65.33 v2(82.92,65.33) ; 80.45,67.83 80.49,67.87 RV2718.2 83.94,67.87 85.34,69.27 88.26,69.27 88.88,68.65 CV295.1 CV64.1 90.69,68.66 92.38,68.66 QV6.1 ; 80.45,67.83 v2(80.45,68.83) 80.45,70.03 81.35,70.93 81.39,70.93 82.76,72.31 RV208.2 ; v2(69.54,68.47) 69.55,68.46 v2(70.32,68.46) 70.53,68.46 70.99,68 70.99,66.48 70.68,66.17 CV19.1 73.06,65.12 CV4.1 CV5.1 ; v2(74.92,90.8) 75.48,90.24 RV23.2 ; CV5.1 76.19,66.73 75.49,67.43 74.22,67.43 73.98,67.67 RV68.1 ; UV12.5 v2(85.79,83.94)
  BOTTOM w0.254: RPV6.8 80.68,69.18 80.45,68.95 v2(80.45,68.83)
  BOTTOM w0.508: v2(83.51,86.12) RV61.1 RV47.1 82.82,84.21 RV51.1 RV45.1 82.82,82.51 v2(82.42,82.1) ; v2(81.34,89.02) 81.11,88.79 RV203.2 80.67,88.79 RV204.2 ; UV13.5 82.48,65.1 82.71,65.33 v2(82.92,65.33) ; RV46.1 v2(83.51,87.33)
+3VS_TOUCH: length 24.9
  TOP w0.381: 21.96,66.55 21.96,65.02 22.47,64.51 v2(22.79,64.51)
  TOP w0.508: RE329.1 24.17,63.17 QE7.2 23.76,64.51 v2(22.79,64.51) ; v3(19.81,69.52) 19.81,69.02 21.09,67.73 RE402.1 RE339.1 ; RE339.1 22.48,66.55 QE9.1 ; RE339.1 RE338.1 ; JTP.8 27.66,61.27 v2(27.91,61.52) 27.31,62.12 CE58.1 RE399.2
  IN3 w0.508: v2(22.79,64.51) 23.62,64.51 25.58,62.54 v2(25.58,61.9) 27.53,61.9 v2(27.91,61.52)
  BOTTOM w0.508: RE335.1 26.85,62.35 27.68,61.52 v2(27.91,61.52) 28.37,61.07 RC78.2 ; RE334.1 v2(25.58,61.9)
+3VS_WLAN_NGFF: length 23.2
  TOP w0.508: CM5.1 v2(173.92,66.48) ; CM6.1 189.67,64.19 188.02,64.19 v3(187.73,64.48) 187.46,64.75 RM8.1
  BOTTOM w1.016: 174.75,68.94 175.43,69.63 189.19,69.63 190.56,68.25 190.56,67.11
  vias: v2(173.86,69.28) v2(173.86,68.7) v2(173.92,67.11) v2(191.32,65.4) v2(191.32,64.76) v3(172.78,68.89) v3(191.95,65.84)
+5V_CAM: length 20
  IN3 w1.016: 15.87,66.86 12.25,66.86 11.55,66.16 11.55,60.51 12.57,59.49 12.57,51.74 12.19,51.36
  vias: v2(10.79,51.43) v2(11.11,50.92) v2(16.88,66.41) v2(16.88,65.78) v3(17.33,67.17)
+5V_HDD: length 5.1
  TOP w0.102: v3(181.35,4.63) 181.67,4.94 v2(181.67,6.09) ; v2(181.67,6.09) 180.14,6.09 v3(180.02,5.96) ; v2(181.67,6.09) 182.17,6.09 v3(183.06,5.2)
+5V_PVDD:
  vias: v1(200.4,17.45) v2(200.56,20.17) v2(201.35,16.82)
+5V_USB_PWR1:
  vias: v2(195.93,50.61) v2(196.32,51.12) v2(196.7,50.61) v2(197.08,51.12) v2(197.46,50.61) v2(197.84,51.12) v3(195.45,51.17) v3(195.7,48.89) v3(196.21,46.85)
+5V_USB_PWR2:
  vias: v2(196.27,39.93) v2(196.27,39.3) v2(198.05,39.93) v2(198.05,39.3) v2(198.81,39.93) v2(198.81,39.3) v3(193.86,39.3) v3(194.18,41.71) v3(195.51,40.38)
+5V_USB_PWR3: length 0.6
  TOP w0.102: v2(27.23,45.08) v3(27.79,45.08)
+5VA: length 1.4
  BOTTOM w0.203: v2(193.99,23.47) 194.19,23.47 194.45,23.21 194.46,23.21 194.73,22.95 UA1.26
  vias: v1(191.95,23.8)
+5VALW: length 406
  TOP w0.203: CC98.1 178.16,74.09 UC5.4 ; U2301.4 v2(170.62,12.37)
  TOP w0.254: CC52.1 187.07,75.18 UC4.3 ; v2(20.95,62.22) 20.44,62.73 19.61,62.73 19.41,62.93 U2409.4 ; UC6.3 168.21,44.89 169.41,46.09 CC88.1
  TOP w0.508: CC52.1 187.88,74.93 v2(188.08,74.73) ; PR8.1 24.69,99.81 v2(24.69,99.43) ; v2(95.05,114.67) 95.24,114.85 PR602.2 ; v2(169.92,45.39) 169.4,45.91 CC88.1 ; RV2720.1 v2(93.71,68.88) ; v2(86.42,70.35) 86.04,70.35 85.45,70.93 RV2719.1 ; RV212.2 88.59,67.97 87.98,68.57 v2(86.54,68.57) ; CC98.1 177.6,73.79 v2(177.6,74.41)
  IN1 w0.508: v2(24.69,99.43) 26.6,99.43 33.46,106.29 33.46,109.02 37.67,113.24 72.09,113.24 73.97,115.12 84.38,115.12 85.3,116.03 90.96,116.03 92.93,114.06 94.44,114.06 v2(95.05,114.67) ; v2(188.08,74.73) 189.55,73.26 189.55,60.08 190.09,59.55 190.09,49.55 191.89,47.74 191.89,42.88 v2(191.13,42.12) ; v2(76.22,110.3) 77.32,111.4 83.47,111.4 84.11,110.76 86.51,110.76 v2(86.8,111.05) ; v2(79.18,21.33) 81.27,23.42 87.94,23.42 88.89,22.47 88.89,20.25 89.85,19.3 89.85,12.56 91.71,10.7 96.45,10.7 v2(96.51,10.76)
  IN2 w0.508: v2(149.85,115.18) 147.66,112.98 145.13,112.98 144.8,113.31 144.05,113.31 143.57,112.83 138.23,112.83 137.79,112.39 123.88,112.39 121.28,109.78 113.15,109.78 111.82,111.12 111.82,112.39 110.67,113.53 102.67,113.53 101.53,114.67 v2(95.05,114.67) 94.67,114.67 91.56,111.56 87.31,111.56 v2(86.8,111.05)
  IN3 w0.508: v2(106.68,21.52) 104.95,21.52 91.94,34.54 91.94,57.78 93.27,59.11 v2(93.27,62.6) 93.27,64.95 v2(92.39,65.84) 92.39,67.56 v2(93.71,68.88) ; v2(24.69,99.43) 24.69,97.02 25.77,95.94 25.77,90.29 24.06,88.57 24.06,82.54 29.52,77.08 29.52,61.4 27.81,59.68 25.08,59.68 22.54,62.22 v2(20.95,62.22) 20.06,63.11 v2(17.14,63.11)
  BOTTOM w0.254: PU606.6 150.16,114.67 PC685.1 ; v2(76.22,110.3) 77.46,109.05 77.46,104.77 78.67,103.56 78.67,99.86 79.3,99.23 PR662.2
  BOTTOM w0.508: v2(149.85,115.18) 150.29,115.18 PC685.1 ; v2(176.97,34.85) 176.4,35.42 176.4,36.02 169,43.42 169,44.48 v2(169.92,45.39) ; v2(86.42,70.35) 86.42,68.7 v2(86.54,68.57) 89.27,65.84 v2(92.39,65.84) ; v2(96.51,10.76) 96.51,10.75 JWDB1.4 ; v2(188.08,74.73) 177.92,74.73 v2(177.6,74.41)
  vias: v2(16.5,63.11) v2(30.98,43.68) v2(30.98,42.92) v2(30.98,42.16) v2(31.43,43.3) v2(31.43,42.54) v2(76,21.33) v2(76,20.69) v2(76.64,21.33) v2(76.64,20.69) v2(77.27,21.33) v2(77.27,20.69) v2(77.91,21.33) v2(77.91,20.69) v2(78.54,21.33) v2(78.54,20.69) v2(79.18,20.69) v2(82.54,18.98) v2(190,41.77) v2(190,41.14) v2(190.53,42.68) v2(190.51,42.09) v2(190.51,41.46) v2(191.13,41.48) v3(13.84,63.3) v3(190.37,45.58) v3(190.75,40.95) v4(168.28,12.88) v4(168.27,12.25) v4(168.27,11.61) v4(168.92,12.88) v4(168.9,12.25) v4(168.9,11.61) v4(169.54,12.25) v4(169.54,11.61)
+5VALWP: length 40.6
  IN3 w0.508: v2(79.11,27.42) 79.11,29.19 76.75,31.55 64.26,31.55 63.56,30.85 v2(63.56,29.58)
  BOTTOM w0.254: 79.11,27.87 79.11,29.84 77.02,31.93 v1(72.95,31.93) 64.26,31.93 63.52,31.2 PR117.2 63.49,31.14 PR115.1 ; v2(63.56,29.58) 63.36,29.39 PU102.14
+5VS: length 238.3
  TOP w0.508: QE10.3 89.77,51.82 93.25,48.34 93.7,48.34 94.67,47.36 v2(94.67,45.8) ; v2(97.72,34.73) 97.72,33.07 103.79,27 104.68,27 108.39,23.3 112.52,23.3 v2(112.52,11.23)
  IN1 w0.508: v2(85.78,43.36) 80.45,43.36 76.38,39.3 72.45,39.3 68.38,43.36 v2(67.56,43.36)
  IN1 w1.016: 186.49,21.14 186.68,21.33 186.68,29.16 187.61,30.09 187.61,35.02 189.91,37.32 193.3,37.32 194.59,38.61 194.59,42.94 194.01,43.52 194.01,47.49 195.07,48.55 195.07,51.21 195.58,51.72 195.58,54.54 196.8,55.76 196.8,67.43 195.94,68.29 195.94,71.28 v2(196.43,71.78) 197.41,72.76 197.41,77.14 197.29,77.27 ; 188.33,16.44 188.33,14.22 187.13,13.01 187.13,9.67 185.54,8.08 178.3,8.08 177.52,7.29 166.68,7.29
  IN2 w0.508: v2(85.78,43.36) 88.22,45.8 v2(94.67,45.8)
  IN3 w0.508: v2(97.72,34.73) 98.61,34.73 99.37,35.49 99.37,45.27 97.34,47.3 96.17,47.3 v2(94.67,45.8)
  IN3 w1.016: 11.42,102.35 9.96,102.35 9.65,102.67 2.91,102.67 1.83,101.59 1.83,70.79 2.72,69.9 6.89,69.9
  BOTTOM w0.508: DX4.1 196.97,72.32 v2(196.43,71.78) ; v2(67.56,43.36) 69.08,43.36 69.84,42.6 70.34,42.6 PR817.2
  vias: v2(13.77,57.78) v2(13.77,57.14) v2(14.28,57.46) v2(164.46,7.87) v2(164.84,8.44) v2(165.16,7.87) v2(165.54,8.44) v2(165.86,7.87) v2(192.78,15.99) v2(193.36,15.99) v2(196.2,78.08) v2(196.78,78.04) v3(165.28,12.56) v4(8.18,70.16) v4(8.82,70.16) v4(12.12,101.78) v4(12.76,101.78)
+5VS_KBL: length 1.8
  BOTTOM w0.508: v2(120.2,17.96) 119.31,18.85 v2(119.31,19.36)
  vias: v3(117.47,24.31)
+17.4V_BATT+: length 53
  TOP w0.102: v2(21.96,29.14) v3(21.96,29.7)
  TOP w0.508: v2(37.65,15.42) 37.65,13.9 37.25,13.5 PQ710.3 36.75,12.44 PR780.2
  IN3 w0.508: v2(50.81,15.98) 50.81,13.28 49.46,11.93 44.1,11.93 41.43,14.6 38.47,14.6 v2(37.65,15.42) 35.3,17.77 21.84,17.77 20.95,18.66 20.95,19.55 20.25,20.25 20.25,22.63 21.96,24.35 v2(21.96,29.14)
  BOTTOM w0.508: PR745.2 v2(50.81,15.98)
+17.4V_BATT++:
  vias: v2(15.42,28.76) v2(15.42,28.12) v2(15.42,27.49) v2(15.42,26.85) v2(15.42,26.22) v2(16.12,28.76) v2(16.12,28.12) v2(16.12,27.49) v2(16.12,26.85) v2(16.12,26.22) v2(17.96,25.67) v2(18.6,29.39) v2(18.6,25.67) v2(18.92,28.88) v2(19.23,29.39) v2(19.23,25.67) v3(18.66,27.49)
+19V_ADPIN:
  vias: v3(13.84,109.21) v3(16.69,106.29) v3(18.41,105.66)
+19V_VIN: length 208.9
  TOP w0.254: PR744.2 32.37,33.82 34.6,36.06 v2(34.6,39.62) ; v2(30.78,40.63) 30.66,40.52 PR739.2
  TOP w1.27: 24.31,107.12 24.31,106.48 28.82,101.97 28.82,94.35 28.5,94.03 28.5,64.62 33.65,59.48
  TOP w2.54: 33.78,54.54 33.78,51.43 31.24,48.89 22.98,48.89 20.63,46.54 20.63,41.01
  IN3 w0.508: v2(20.88,36.57) 20.88,24.85 19.2,23.16 19.2,18.87 21.5,16.56 30.54,16.56 31.19,15.91 v2(35.02,15.91) 35.02,11.76 36.25,10.53 40.7,10.53 42.03,9.2 43.68,9.2 44.11,9.62 46.03,9.62 47.15,8.5 48.51,8.5 48.76,8.25 v2(48.76,7.87)
  BOTTOM w0.254: 23.49,39.42 29.71,39.42 30.78,40.49 v2(30.78,40.63) 30.91,40.5 33.71,40.5 v2(34.6,39.62)
  BOTTOM w0.508: PR729.1 v2(48.76,7.87) ; PD704.2 36.7,18.22 35.02,16.54 v2(35.02,15.91)
  BOTTOM w1.27: 33.97,59.3 29.2,64.06 29.2,68.51 28.5,69.21 28.5,93.72 26.22,96 26.22,103.12 25.08,104.26 25.08,107.81
  vias: v2(20.31,39.42) v2(20.31,38.79) v2(20.31,38.15) v2(20.31,37.52) v2(20.31,36.88) v2(20.88,39.11) v2(20.88,38.47) v2(20.88,37.84) v2(20.88,37.2) v2(21.9,109.85) v2(21.9,109.21) v2(22.22,108.7) v2(22.54,109.85) v2(22.54,109.21) v2(22.85,108.7) v2(23.17,109.85) v2(23.17,109.21) v2(23.81,109.85) v2(23.81,109.21) v2(29.33,109.21) v2(29.33,108.58) v2(33.71,58.28) v2(33.71,57.65) v2(34.41,58.28) v2(34.41,57.65) v3(19.81,35.93) v3(24.31,108) v3(34.03,56.82)
+19VB: length 223.6
  TOP w0.381: PD706.1 31.51,37.6 31.17,37.27 30.09,37.27 30.02,37.34 PQ709.4
  TOP w0.457: v2(31.74,39.49) 31.51,39.25 PD706.1
  IN1 w0.508: v2(37.46,32.88) 33.65,32.88 31.51,35.02 31.51,39.25 v2(31.74,39.49)
  BOTTOM w2.54: 19.25,63.15 19.25,62.6 18.22,61.57 18.22,52.38 21.2,49.39 21.2,44.5 18.15,41.46 18.15,35.49 20.63,33.01 24.25,33.01 25.08,32.19 ; 18.99,71.43 18.99,72.11 14.88,76.23 14.88,98.19 18.98,102.29 18.98,111.05 20.38,112.45 25.33,112.45 26.41,111.37 30.22,111.37 31.04,110.54 33.71,110.54 39.83,116.67 41.56,116.67
  BOTTOM w3.048: 168.71,51.62 166.36,51.62 164.84,50.09 162.42,50.09 160.9,51.62 157.79,51.62 155.63,53.78 101.53,53.78 98.55,50.79 94.35,50.79 91.81,48.25 91.81,29.84
  vias: v2(12.31,77.65) v2(12.31,77.02) v2(12.31,76.38) v2(12.88,77.33) v2(12.88,76.7) v2(29.84,31.61) v2(30.47,31.61) v2(30.79,29.84) v2(30.79,29.2) v2(30.79,28.57) v2(30.79,27.93) v2(30.79,27.3) v2(31.11,31.61) v2(31.43,31.11) v2(31.43,30.47) v2(31.43,29.84) v2(31.43,29.2) v2(31.43,28.57) v2(31.43,27.93) v2(31.74,31.61) v2(32.06,31.11) v2(32.06,30.47) v2(32.38,31.61) v2(32.7,31.11) v2(32.7,30.47) v2(54.67,20.76) v2(54.67,20.12) v2(55.3,20.76) v2(55.3,20.12) v2(55.94,20.76) v2(55.94,20.12) v2(56.57,20.76) v2(56.57,20.12) v2(68.76,38.28) v2(69.08,37.77) v2(69.4,38.28) v2(69.72,37.77) v2(70.03,38.28) v2(70.35,37.77) v2(88.64,25.52) v2(88.64,24.88) v2(89.27,26.15) v2(89.27,25.52) v2(89.27,24.88) v2(89.91,26.15) v2(89.91,25.52) v2(89.91,24.88) v3(70.35,25.01)
+19VB_1.35V: length 19.1
  IN3 w0.254: v2(80.45,14.02) 80.45,19.04 84.45,23.04 90.23,23.04 v2(91.69,21.58)
  BOTTOM w0.254: PR208.1 v2(80.45,14.02)
+19VB_+1VALWP:
  vias: v1(174.11,50.98) v2(174.24,51.62) v2(175.25,51.81) v2(175.89,51.81)
+19VB_VGA: length 15.3
  IN1 w0.254: v2(80.77,41.33) 80.76,41.33 79.37,41.33 76.64,38.6 72.13,38.6 69.97,40.76 v2(68.19,40.76)
  BOTTOM w0.254: PR809.2 v2(80.77,41.33)
  vias: v1(71.43,51.74) v2(66.41,40.44) v2(66.41,39.81) v2(66.92,50.98) v2(66.92,40.76) v2(67.37,51.68) v2(67.56,40.76) v2(68,51.68) v2(68.64,51.68) v2(69.27,50.09) v2(69.91,50.09)
+VCC_CORE: length 76.4
  TOP w0.254: PR673.1 81.2,112.69 80.8,113.08 v2(80.8,117.15) ; PC1093.1 134.98,99 135.3,99 135.83,99.53 135.83,100.64 RC203.2
  TOP w0.381: PC1037.1 133.03,87.85 v2(133.04,87.84) ; v2(128.67,89.48) 128.29,89.48 PC1005.1 ; v2(125.98,89.4) 125.47,89.4 PC1069.1
  TOP w0.508: PC1074.1 123.75,89.84 v2(123.31,89.84) ; v2(117.72,93.34) 117.35,92.97 CV297.1 ; v2(128.62,91.95) 128.24,91.95 PC1003.1 ; PC1061.1 131.06,89.4 v2(131.57,89.4) ; PC1070.1 126.42,90.67 v2(125.98,90.67) ; v2(123.31,91.11) 123.75,91.11 PC1073.1 ; v2(131.04,91.95) 130.66,91.95 PC1173.1 ; v2(128.64,90.66) 129.09,90.66 PC1004.1 ; v2(140.04,113.59) 140.04,113.25 PC1013.1 ; v2(117.72,94.23) 117.35,94.59 CV298.1 ; v2(133.41,90.67) 133.85,90.67 PC1065.1 ; v2(142.64,113.59) 142.64,113.25 PC1011.1 ; PC1066.1 133.03,91.94 v2(133.41,91.94) ; v2(125.98,91.94) 125.6,91.94 PC1006.1 ; PC1064.1 131.5,90.67 v2(131.06,90.67)
  IN1 w0.254: v2(117.4,117.75) 116.92,117.26 111.4,117.26 110.08,115.94 97.85,115.94 95.94,117.85 94.86,117.85 93.38,119.33 90.25,119.33 88.93,118.01 82.77,118.01 82.3,117.55 81.2,117.55 v2(80.8,117.15)
  BOTTOM w0.203: UC1.G32 v2(134.35,98.84) UC1.G30 ; UC1.G33 v2(132.53,98.84) UC1.G35 ; v2(134.39,103.18) UC1.A30 ; v2(130.04,103.37) 130.04,103.05 129.43,102.44 UC1.A39 ; UC1.A34 v2(131.91,103.12) ; UC1.A44 126.95,103.36 v2(126.8,103.52)
  BOTTOM w0.254: UC1.AM37 v2(131.61,85.96) UC1.AM35 v2(132.53,85.96) UC1.AM33 ; UC1.G38 130.44,98.59 v2(130.69,98.84) ; v2(117.4,117.75) 117.21,117.56 117.21,115.37 117.47,115.12 120.08,115.12
  vias: v2(118.87,117.4) v2(118.87,112.89) v2(119.75,117.4) v2(119.75,112.89) v2(120.64,117.4) v2(120.64,112.89) v2(121.53,117.4) v2(121.88,116.49) v2(121.86,115.04) v2(121.88,113.69) v2(122.23,115.69) v2(122.23,114.42) v2(122.8,116.32) v2(122.8,115.05) v2(122.8,113.72) v2(123.69,114.23) v2(124.2,116.13) v2(125.02,113.47) v2(125.6,114.23) v2(125.91,116.13) v2(126.8,113.47) v2(127.44,114.23) v2(127.54,116.13) v2(127.53,97.08) v2(127.95,96.7) v2(128.26,108.96) v2(128.52,96.7) v2(128.9,107.81) v2(128.96,109.53) v2(128.96,97.27) v2(129.09,96.7) v2(129.66,108.45) v2(129.66,96.7) v2(129.66,87.75) v2(129.79,107.62) v2(129.85,88.38) v2(130.23,96.7) v2(130.17,89.53) v2(130.17,88.89) v2(130.49,88.38) v2(130.7,97.44) v2(130.68,92.7) v2(130.68,85.97) v2(130.8,96.7) v2(131.44,96.7) v2(131.57,92.7) v2(131.56,87.82) v2(132.07,96.7) v2(132.33,116.32) v2(132.33,115.5) v2(132.33,114.67) v2(132.33,113.85) v2(132.53,97.44) v2(132.45,92.7) v2(132.71,96.7) v2(133.15,116.32) v2(133.15,115.5) v2(133.15,114.67) v2(133.15,113.85) v2(133.34,96.7) v2(133.44,85.97) v2(134.04,116.32) v2(134.04,115.5) v2(134.04,114.67) v2(134.04,113.85) v2(134.99,92) v2(134.99,89.84) v2(137.28,116.13) v2(137.28,115.5) v2(137.28,114.86) v2(137.28,114.23) v2(139.21,116.39) v2(141.37,116.39) v2(143.47,116.39) v3(119.75,115.31)
+VCC_CORE_L: length 47.9
  TOP w0.254: PC645.1 82.22,113.61 PR673.2 81.34,117.97 v2(80.7,118.61)
  BOTTOM w0.254: PH605.2 116.49,119.88 96.58,119.88 95.47,120.98 84.09,120.98 v1(83.81,120.7) 83.72,120.62 PR644.2 84,119.22 PC646.2 ; PC646.2 84.92,118.63 PC642.2 84.94,118.62 85.15,118.42 85.7,118.42 PR640.2 ; PC646.2 PR656.2 83.04,118.62 82.42,119.24 81.34,119.24 v2(80.7,118.61)
+VCC_GT: length 40.6
  TOP w0.254: v2(89.34,105.02) 88.58,105.78 PR675.1
  TOP w0.381: v2(120.96,92.7) 121.35,92.7 PC1136.1 ; v2(120.96,95.22) 121.35,95.22 PC1134.1 ; v2(110.06,94.86) 110.06,95.28 PC1015.1 ; v2(106.61,97.68) 106.97,97.68 PC1026.1 ; PC1131.1 120.5,96.5 v2(120.92,96.5) ; v2(124.35,93.4) 124.35,93.82 PC1177.1 ; v2(120.96,93.92) 120.54,93.92 PC1135.1 ; PC1224.1 118.93,93.02 v2(118.93,92.64) ; PC1137.1 120.53,91.43 v2(120.95,91.43) ; v2(124.35,95.81) 124.35,96.23 PC1176.1 ; v2(118.36,95.11) 118.36,94.67 PC1138.1 ; v2(123.08,93.4) 123.08,93.82 PC1129.1 ; PC1130.1 123.08,96.23 v2(123.08,95.81) ; v2(108.79,94.86) 108.79,95.28 PC1014.1
  TOP w0.508: CV298.2 116.44,94.28 v2(116.39,94.23)
  BOTTOM w0.152: v2(122.47,103.64) 122.47,103.1 122.01,102.64 122.01,102.3 UC1.A53
  BOTTOM w0.203: UC1.A66 v2(114.56,103.3) ; UC1.A48 124.32,102.44 v2(124.32,103.24) ; UC1.A58 119.52,102.92 119.82,103.21 119.82,103.53 119.88,103.59 v2(119.88,103.82) ; v2(116.88,103.29) 117.03,103.14 117.03,102.78 117.04,102.78 UC1.A62
  BOTTOM w0.254: v2(89.34,105.02) 89.4,104.96 91.37,104.96 91.88,104.45 91.88,101.46 92.2,101.15 94.8,101.15
  BOTTOM w0.381: PC1159.1 100.96,95.3 v2(100.96,94.86) ; PC1179.1 102.67,91.62 v2(102.67,92.07) ; v2(102.16,94.86) 102.16,95.3 PC1019.1 ; v2(101.47,92.07) 101.47,91.62 PC1180.1 ; PC1023.1 97.34,95.3 v2(97.34,94.86) ; v2(99.75,94.86) 99.75,95.3 PC1183.1 ; PC1221.1 103.88,91.62 v2(103.88,92.07) ; PC1024.1 98.55,95.3 v2(98.55,94.86) ; v2(103.37,94.86) 103.37,95.3 PC1020.1
  BOTTOM w0.457: PC1155.1 102.65,97.31 v2(102.65,97.78) ; PC1154.1 100.23,97.31 v2(100.23,97.78) ; PC1022.1 97.82,91.6 97.82,92.07 ; PC1156.1 101.44,97.31 v2(101.44,97.78)
  BOTTOM w0.508: 93.34,96.51 v2(93.35,96.5) CV302.2 ; v2(106.61,97.68) 106.72,97.79 RC219.2
  vias: v2(93.34,100.64) v2(93.34,99.81) v2(93.34,98.99) v2(93.4,98.29) v2(93.97,98.99) v2(93.97,97.97) v2(94.42,98.48) v2(94.8,98.99) v2(95.05,91.24) v2(95.24,98.48) v2(95.5,91.62) v2(95.69,98.99) v2(96.61,92.07) v2(96.7,101.97) v2(96.72,101.3) v2(96.7,100.7) v2(96.68,100.08) v2(96.68,99.46) v2(96.98,102.58) v2(97.22,101.71) v2(97.3,100.14) v2(97.61,102.18) v2(97.59,100.7) v2(97.66,101.31) v2(99.03,92.07) v2(100.23,92.07) v2(105.15,92.07) v2(105.78,94.86) v2(106.36,92.07) v2(108.83,92.07) v2(110.1,92.07) v2(110.61,93.53) v2(110.8,95.75) v2(110.78,95.11) v2(110.8,91.43) v2(111.18,94.18) v2(111.18,92.35) v2(111.8,95.11) v2(111.8,91.44) v2(112.45,96.01) v2(112.45,94.18) v2(112.45,92.35) v2(113.1,95.1) v2(113.1,91.44) v2(113.75,94.18) v2(113.75,92.35) v2(114.36,95.94) v2(114.99,95.99) v2(115.05,94.18) v2(115.06,93.27) v2(115.71,94.22) v2(115.7,93.27) v2(115.73,92.39) v2(116.34,95.93) v2(116.33,90.54) v2(117.53,91.88) v2(118.81,97.09) v2(119.72,97.09) v2(121.75,97.15) v2(123.37,97.21) v2(124.01,97.21) v2(125.15,97.15) v2(125.91,95.3) v2(125.91,94.67) v2(125.91,94.1) v2(126.1,97.15) v2(129.09,95.5) v2(129.09,94.67) v2(129.09,93.91) v2(129.6,95.11) v2(129.6,94.29) v3(95.24,95.05)
