# Allegro board LA-D051P Boardview.brd (continued)
## Nets (continued)
GPU_THM_SMBDAT: Q2409.6 QC3.6 QV2.6 R2458.2 RC397.2 RE350.1 RV75.2 UE5.11
GT_SNUB1: PC678.1 PR676.2
GT_SW1: PL605.1 PR674.2 PR676.1 PU605.8
H_CATERR#: RC14.1 UC1.D63
H_CPU_SVIDALRT#: RC180.1 UC1.B63
H_CPUPWRGD: RC102.2 UC1.A68
H_PROCHOT#: CE84.1 PC605.2 PQ2.6 PQ3.3 PR678.1 PR777.1 RC3.2 RC4.1 UE6.4
H_PROCHOT#_R: RC4.2 UC1.C65
H_PROCHOT_EC: RE388.2 UE5.83 UE6.2
H_THERMTRIP#: RC2.2 UC1.C63
HDA_BIT_CLK: RPC9.8 UC1.AY22
HDA_CODEC_BITCLK: CA26.1 RA1112.1 RPC9.1 UA1.6
HDA_CODEC_RST#: RPC9.4 UA1.11
HDA_CODEC_SDIN0: RA130.2 UA1.8
HDA_CODEC_SDOUT: RPC9.3 UA1.5
HDA_CODEC_SYNC: RPC9.2 UA1.10
HDA_RST#: RPC9.5 UC1.AW22
HDA_SDIN0: RA130.1 UC1.BA21
HDA_SDOUT: RC17.2 RC218.2 RPC9.6 UC1.BB22
HDA_SYNC: RPC9.7 UC1.BA22
HDD_A0_PRE0: RS24.1 RS27.2 US2.9
HDD_A0_PRE1: RS23.1 RS30.2 US2.19
HDD_B0_EQ: RS37.1 RS38.1 US2.13
HDD_B0_PRE0: RS21.1 RS28.2 US2.8
HDD_B0_PRE1: RS18.1 RS29.2 US2.17
HDD_REXT_SATA0: RS26.2 RS31.1 US2.20
HDMI_CLK: CX13.2 UC1.G56
HDMI_CLK#: CX12.2 UC1.F56
HDMI_DATA0: CX15.2 UC1.G53
HDMI_DATA0#: CX14.2 UC1.F53
HDMI_DATA1: CX17.2 UC1.F58
HDMI_DATA1#: CX16.2 UC1.E58
HDMI_DATA2: CX19.2 UC1.F55
HDMI_DATA2#: CX18.2 UC1.E55
HDMI_DET: QX5.3 RC312.2 RX14.1 UC1.L9
HDMI_HPLUG: JHDMI.19 RX15.2 RX34.1
HOST_DEBUG_TX: JDEG1.8 RE392.2 RM12.2 RM13.2 UE5.81
HPOUT-L: RA55.1 UA1.32
HPOUT-R: RA56.1 UA1.33
I2C_SCL_TP: QE6.4 RC395.2 RE337.1 UC1.U6
I2C_SCL_TP_R: JTP.6 QE6.3 RE334.2 RE337.2
I2C_SDA_TP: QE6.1 RC394.2 RE336.1 UC1.U7
I2C_SDA_TP_R: JTP.7 QE6.6 RE335.2 RE336.2
I2CA_SCL: RPV3.1 UV1.B7
I2CA_SDA: RPV3.2 UV1.A7
I2CB_SCL: RPV3.3 UV1.C9
I2CB_SDA: RPV3.4 UV1.C8
I2CC_SCL: RV205.1 UV1.A9
I2CC_SDA: RV206.1 UV1.B9
I2CS_SCL: QV2.4 RV74.1 RV203.1 UV1.D9
I2CS_SDA: QV2.1 RV75.1 RV204.1 UV1.D8
I_ADP: PC748.1 PR774.1 RE386.2
I_ADP_R: CE83.1 RE386.1 UE5.110
I_BATT: PC749.2 PR775.1 RE389.2
I_BATT_R: CE90.1 RE389.1 UE5.114
I_SYS: PR620.1 PR727.1 PU703.8 RE403.1
ICSP_CLK: RE365.2 RE395.1 UE5.101
ICSP_CLR: RE396.1 UE5.87
ICSP_DAT: RE367.2 RE398.1 UE5.102
ILMT_+1VALWP: PR307.2 PR310.1 PU301.3
IMON_IA: PC625.2 PR629.2 PU602.14
IMON_VSA: PC643.1 PR651.1 PU602.23
IMVP_VR_ON: PR616.1 PR664.1 PR683.1 RC345.2
INT-SPK-L+: LA6.1 UA1.42
INT-SPK-L-: LA5.1 UA1.43
INT-SPK-R+: LA4.1 UA1.45
INT-SPK-R-: LA3.1 UA1.44
INT_TP#: JTP.4 QE7.3 RE329.2
INTRUDER#: RC94.2 UC1.AP16
ISOLATEB: RL33.2 RL35.2 UL1.20
ISUMP_GT: PC624.1 PC626.1 PR628.1 PR633.1 PR637.1 PR674.1 PU602.7
ISUMP_IA: PC642.1 PC646.1 PR655.1 PR656.1 PR657.1 PR661.2 PU602.19
ISUMP_VSA: PC633.1 PC637.1 PR624.2 PR642.1 PR643.2 PR654.1 PU602.27
JACK_PLUG#: JHP.5 RA4.1
JACK_SENSE#: RA4.2 RA13.1 UA1.13
JHDD_P10: JHDD.7 RS8.2
JTAG_CLK: JDEG1.4 RE397.2
JTAG_TDI: JDEG1.2 RE395.2
JTAG_TDO: JDEG1.5 RE398.2
JTAG_TMS: JDEG1.3 RE396.2
KB_BL_PWM: JKBBL.4 QE5.1 QE5.2 QE5.5 QE5.6
KB_DET#: JKB.30 RC327.1 UC1.BB7
KB_LED_BL_DET: RE58.1 RE61.1 UC1.W8
KB_LED_PWM: QE5.3 UE5.44
KSI0: JKB.22 RPE1.4 UE5.98
KSI1: JKB.24 RPE1.3 UE5.99
KSI2: JKB.26 RPE1.2 UE5.6
KSI3: JKB.23 RPE1.1 UE5.7
KSI4: JKB.27 RPE2.4 UE5.104
KSI5: JKB.25 RPE2.3 UE5.105
KSI6: JKB.28 RPE2.2 UE5.107
KSI7: JKB.29 RPE2.1 UE5.108
KSO0: JKB.13 RPE3.8 UE5.2
KSO1: JKB.15 RPE3.7 UE5.14
KSO2: JKB.14 RPE3.6 UE5.15
KSO3: JKB.16 RPE3.5 UE5.16
KSO4: JKB.20 RPE4.8 UE5.37
KSO5: JKB.21 RPE4.7 UE5.38
KSO6: JKB.18 RPE4.6 UE5.39
KSO7: JKB.19 RPE4.5 UE5.50
KSO8: JKB.17 RPE6.8 UE5.46
KSO9: JKB.7 RE348.1 UE5.68
KSO10: JKB.5 RPE5.8 UE5.72
KSO11: JKB.6 RPE5.7 UE5.74
KSO12: JKB.12 RPE5.6 UE5.75
KSO13: JKB.9 RPE5.5 UE5.76
KSO14: JKB.8 RPE6.6 UE5.77
KSO15: JKB.10 RPE6.7 UE5.86
KSO16: JKB.11 RPE6.5 UE5.92
L_BKLT_CTRL: DX6.2 RX33.1 UC1.R11
L_BKLT_EN_EC: RC223.2 UC1.R12 UE5.91
LAN_EN: RL27.2 UE5.3 UL3.4
LAN_WAKE#: RC56.1 RPC11.2 UC1.AM15
LCD_BRIGHTNESS: DX6.1 JEDP.36 RX26.1 RX33.2
LCD_TEST: JEDP.33 RX32.2
LCD_TST: DX5.3 DX6.3 RX32.1 UE5.26
LG1_VGA: PQ800.6 PR818.1 PU801.19
LG2_VGA: PQ801.6 PU801.17
LG_1.35V: PQ201.8 PU200.15
LGATE_CHG: PQ708.4 PU703.21
LID_CL_SIO#: CE77.1 RE363.2 RE366.2 UE5.41
LID_CLOSE#: DX9.1 JLED.4 RE366.1
LINE1-L: CA67.1 UA1.22
LINE1-R: CA68.1 UA1.21
LINE1-VREFO-L: RA165.1 UA1.31
LINE1-VREFO-R: RA166.1 UA1.30
LINE-IN-L: LA8.2 RA55.2 RA80.2 RA83.1 RA165.2
LINE-IN-R: LA9.2 RA56.2 RA82.2 RA84.1 RA166.2
LPC_LAD0: DB1.8 UC1.AY13 UE5.59
LPC_LAD1: DB1.7 UC1.BA13 UE5.60
LPC_LAD2: DB1.6 UC1.BB13 UE5.61
LPC_LAD3: DB1.5 UC1.AY12 UE5.62
LPC_LFRAME#: DB1.4 UC1.BA12 UE5.58
LPSS_UART2_CTS#: RC65.1 UC1.AD4
LX1_VGA: PC808.2 PL802.1 PQ800.7 PR821.2 PU801.20
LX2_VGA: PC806.1 PL803.1 PQ801.7 PR822.2 PU801.16
LX_1.8VALW: PL501.1 PR502.1 PU501.3
LX_1.35V: PC200.2 PC207.1 PL200.2 PQ201.9 PU200.16
LX_3V: PC102.2 PL100.1 PR106.1 PU100.6 PU100.19 PU100.20
LX_5V: PC114.2 PL101.1 PR112.1 PU102.6 PU102.19 PU102.20
MAINPWON: R2448.2 U2407.7
MCT0: RL19.1 TL2.14
MCT1: RL20.1 TL2.11
MDI0+: TL2.8 UL1.1
MDI0-: TL2.7 UL1.2
MDI1+: TL2.2 UL1.4
MDI1-: TL2.1 UL1.5
MDO0+: JLAN.1 TL2.9
MDO0-: JLAN.2 TL2.10
MDO1+: JLAN.3 TL2.15
MDO1-: JLAN.6 TL2.16
ME_FWP_EC: RC17.1 RE357.1 UE5.80
ME_SUS_PWR_ACK: RC108.2 UC1.AR13 UE5.42
MEC_XTAL1: C5232.1 RE382.2 Y1.1
MEC_XTAL1_R: RE382.1 UE5.123
MEC_XTAL2: C5233.1 UE5.125 Y1.2
MIC1-L: CA74.1 UA1.19
MIC_CLK_C: LA1.1 UA1.3
MIC_IN_R: CA38.1 DA12.3 JHP.4 LA7.1
MODEL_ID: C5230.1 R2452.2 R2453.2 UE5.109
MONO_PC_BEEP_R: RA1114.2 UA1.16
MPHYP_PWR_EN: RC210.1 UC1.AM10
MSCLK: JDEG1.6 RE391.2
MSDATA: JDEG1.7 RE394.2
NRB_BIT: RC118.2 UC1.AR7
NTC_IA: PR635.2 PU602.15
NVVDD_GND_SENSE: PR811.1 UV1.F1
NVVDD_GND_SENSE_R: PC804.1 PR810.2 PR811.2 PU801.10
NVVDD_SENSE: PR812.1 UV1.F2
NVVDD_SENSE_R: PC804.2 PR812.2 PR813.2 PU801.12
ONE_DIMM#: RC231.1 RC232.1 UC1.M2
PANEL_BKEN_EC: RX31.1 UE5.117
PBAT_CHG_SMBCLK: PD2.3 PR18.2 PR770.1 RE349.1 UE5.9
PBAT_CHG_SMBDAT: PD2.2 PR20.2 PR769.1 RE347.1 UE5.8
PBAT_PRES#: CE74.1 PC14.1 PC753.2 PD3.2 PR15.2 PR16.1 PR37.2 PR764.1 UE5.97
PC_BEEP: DA8.1 RA19.1 RA79.2
PCH_ALW_ON: RC191.1 RE361.1 UE5.71
PCH_BATLOW#: RC103.2 UC1.AU13
PCH_DPWROK: RC101.1 RC112.1 RC396.2 UC1.BB20
PCH_HDMI_CLK: QX4.1 RPC1.6 UC1.L13
PCH_HDMI_DATA: QX4.4 RPC1.5 UC1.L12
PCH_JTAG_TCK1: RC37.1 UC1.B56
PCH_OPIRCOMP: RC6.1 UC1.AU16
PCH_PCIE_WAKE#: RC66.1 RC104.2 UC1.BB15
PCH_PLTRST#: UC1.AN10 UC3.1 UC3.2
PCH_PLTRST#_EC: CE85.1 DB1.3 RC99.2 RM6.2 RX24.1 UC3.4 UE5.56 UL1.19 UV12.1
PCH_RSMRST#: RE359.1 UC11.1 UE5.88
PCH_RSMRST#_Q: RC55.1 RC396.1 RPC11.3 T4962.1(TP-1) UC1.AY17 UC11.4
PCH_RTCRST#: CC11.2 CLRP2.2 QC1.1 RC93.2 UC1.AM16
PCH_RTCX1: CC15.1 RC98.1 UC1.AM18 YC2.1
PCH_RTCX2: CC16.1 RC98.2 UC1.AM20 YC2.2
PCH_SMBCLK: JDIMM1.202 JDIMM2.202 QC2.1 RC390.2
PCH_SMBDAT: JDIMM1.200 JDIMM2.200 QC2.4 RC391.2
PCH_SPI_CLK: RC59.1 UC1.AV2
PCH_SPI_CLK_R: CC9.1 JC1.6 RPC5.3 UC2.6
PCH_SPI_D0: RC44.1 RC58.1 UC1.AV3
PCH_SPI_D0_R: JC1.5 RPC5.2 UC2.5
PCH_SPI_D1: RC57.1 UC1.AW3
PCH_SPI_D1_R: JC1.2 RPC5.1 UC2.2
PCH_SPI_D2: RC21.1 RC47.1 RC52.1 UC1.AW2
PCH_SPI_D2_R: JC1.3 RC61.2 UC2.3
PCH_SPI_D3: RC48.1 RC51.1 RC60.1 UC1.AU4
PCH_SPI_D3_R: JC1.7 RPC5.4 UC2.7
PCI_CLK_LPC1: RC45.1 RC54.1 UC1.AY9
PCIE_CRX_C_GTX_N1: CV12.2 UV1.AB9
PCIE_CRX_C_GTX_N2: CV14.2 UV1.AC10
PCIE_CRX_C_GTX_N3: CV16.2 UV1.AC11
PCIE_CRX_C_GTX_N4: CV18.2 UV1.AB12
PCIE_CRX_C_GTX_P1: CV11.2 UV1.AC9
PCIE_CRX_C_GTX_P2: CV13.2 UV1.AB10
PCIE_CRX_C_GTX_P3: CV15.2 UV1.AD11
PCIE_CRX_C_GTX_P4: CV17.2 UV1.AC12
PCIE_CRX_GTX_N1: CV12.1 UC1.H13
PCIE_CRX_GTX_N2: CV14.1 UC1.G11
PCIE_CRX_GTX_N3: CV16.1 UC1.H16
PCIE_CRX_GTX_N4: CV18.1 UC1.G15
PCIE_CRX_GTX_P1: CV11.1 UC1.G13
PCIE_CRX_GTX_P2: CV13.1 UC1.F11
PCIE_CRX_GTX_P3: CV15.1 UC1.G16
PCIE_CRX_GTX_P4: CV17.1 UC1.F15
PCIE_CTX_C_GRX_N1: CC17.1 UV1.AG7
PCIE_CTX_C_GRX_N2: CC18.1 UV1.AE7
PCIE_CTX_C_GRX_N3: CC20.1 UV1.AF9
PCIE_CTX_C_GRX_N4: CC23.1 UV1.AG10
PCIE_CTX_C_GRX_P1: CC21.1 UV1.AG6
PCIE_CTX_C_GRX_P2: CC19.1 UV1.AF7
PCIE_CTX_C_GRX_P3: CC22.1 UV1.AE9
PCIE_CTX_C_GRX_P4: CC24.1 UV1.AG9
PCIE_CTX_GRX_N1: CC17.2 UC1.B17
PCIE_CTX_GRX_N2: CC18.2 UC1.D16
PCIE_CTX_GRX_N3: CC20.2 UC1.D17
PCIE_CTX_GRX_N4: CC23.2 UC1.B19
PCIE_CTX_GRX_P1: CC21.2 UC1.A17
PCIE_CTX_GRX_P2: CC19.2 UC1.C16
PCIE_CTX_GRX_P3: CC22.2 UC1.C17
PCIE_CTX_GRX_P4: CC24.2 UC1.A19
PCIE_PRX_LANTX_N3_C: CL31.2 UL1.18
PCIE_PRX_LANTX_N6: CL31.1 UC1.G18
PCIE_PRX_LANTX_P3_C: CL30.2 UL1.17
PCIE_PRX_LANTX_P6: CL30.1 UC1.F18
PCIE_PRX_WLANTX_N5: JNGFF.35 UC1.F16
PCIE_PRX_WLANTX_P5: JNGFF.33 UC1.E16
PCIE_PTX_LANRX_N6: CC135.2 UC1.D20
PCIE_PTX_LANRX_N6_C: CC135.1 UL1.14
PCIE_PTX_LANRX_P6: CC136.2 UC1.C20
PCIE_PTX_LANRX_P6_C: CC136.1 UL1.13
PCIE_PTX_WLANRX_N5: CC25.2 UC1.C19
PCIE_PTX_WLANRX_N5_C: CC25.1 JNGFF.29
PCIE_PTX_WLANRX_P5: CC26.2 UC1.D19
PCIE_PTX_WLANRX_P5_C: CC26.1 JNGFF.27
PCIE_RCOMPN: RC120.2 UC1.F5
PCIE_RCOMPP: RC120.1 UC1.E5
PCIE_WAKE#: RC66.2 RE352.2 RM14.1 UE5.4 UL1.21
PECI_EC: DE3.1 RE364.2 UC1.A54
PECI_MEC1404: RE364.1 UE5.94
PEG_CLKREQ#: QV3.1 RPC10.4 RV5.2 UC1.AR10
PEX_PLL_CLK_OUT: RV4.2 UV1.AF22
PEX_PLL_CLK_OUT#: RV4.1 UV1.AE22
PEX_PLLVDD_GPU: CV6.1 CV20.1 CV29.1 RV12.2 UV1.AA14 UV1.AA15
PEX_TERMP: RV6.1 UV1.AF25
PHASE_CHG: PC721.2 PL700.1 PQ704.1 PQ704.2 PQ704.3 PQ708.5 PR766.1 PU703.22
PLT_RST#_R: JNGFF.44 RM6.1
PLT_RST_VGA#: QV2.2 QV2.5 QV4.2 RV9.2 RV66.1 UV1.AC7 UV13.4
PLT_RST_VGA_HOLD#: RPV7.2 UV1.C4 UV13.2
PLT_RST_VGA_MON#: RPV7.1 RV9.1 UV1.E9 UV12.4 UV13.1
PM_MSM#: T230.1(TP-1) UC1.AP56
PM_ZVM#: T225.1(TP-1) UC1.AR56
PME#: T91.1(TP-1) UC1.AU11
POK: CC142.1 PR107.2 PR113.2 PR315.1 PR507.1 PU100.9 PU102.9 RC55.2 RC95.2 RC112.2 UC11.2
POWER_SW#_MB: CE20.1 DE2.3 RE378.2 SW1.3 SW1.4
POWER_SW_IN#: CE79.1 RE376.2 RE378.1 UE5.127
PRIMCORE_VID0: T130.1(TP-1) UC1.AN11
PRIMCORE_VID1: T131.1(TP-1) UC1.AN13
PROG: PR753.2 PU703.9
PROJECT_ID1: RC314.2 RC319.1 UC1.AY8
PROJECT_ID2: RC315.1 RC318.2 UC1.BA8
PS_ID: PR3.1 PR4.2 UE5.36
PSID: PJPDC.1 PL2.2
PSID-1: PQ5.2 PR6.1 PR9.2
PSID-2: PQ5.1 PQ6.2 PR8.2
PSID-3: PQ6.3 PR4.1
PTP_DIS#: DE4.1 RE362.1 RE367.1
PTP_DIS#_R: RE362.2 UE5.90
PWM1_GT: PU602.12 PU605.13
PWM2_GT: PU602.13
PWM_IA: PU602.22 PU603.13
PWM_VSA: PU602.30 PU606.3
REFADJ: PR805.1 PU801.6
REFIN_VGA: PR807.2 PR808.1 PU801.7
REMOTE1+: C2500.1 C2502.1 Q2407.1 Q2407.2 U2407.2
REMOTE1-: C2500.2 C2502.2 Q2407.3 U2407.3
REMOTE2+: C2504.1 C2505.1 Q2408.1 Q2408.2 U2407.4
REMOTE2-: C2504.2 C2505.2 Q2408.3 U2407.5
RESET_OUT#: CE88.1 RE355.1 RPC11.1 UC1.BA20 UE5.73
RING2: LA10.2 RA1109.1 UA1.17
RING2_R: CA40.1 DA12.2 JHP.3 LA10.1
ROM_SCLK: RV63.1 RV80.2 UV1.C12
ROM_SI: RV65.1 RV84.2 UV1.B12
ROM_SO: RV64.1 RV81.2 UV1.A12
RTC_DET#: QC4.1 RC233.1 UC1.P1
RTCRST_ON: QC1.2 RC121.1 UE5.31
RUNPWROK: RE381.1 UE5.48
SA_SNUB: PC622.1 PR627.2
SA_SW: PC611.2 PL601.1 PQ501.9 PR624.1 PR627.1 PU606.8
SATA3_PRX_HDDTX_N0: CS33.1 UC1.F20
SATA3_PRX_HDDTX_P0: CS35.1 UC1.E20
SATA3_PTX_HDDRX_N0: CS36.1 UC1.B21
SATA3_PTX_HDDRX_P0: CS37.1 UC1.A21
SATA_LED#: QI2.2 R2455.1 RC199.1 UC1.H1
SATA_LED#_R: R2455.2 R2460.2 UE5.30
SATA_PRX_DTX_N0: CS31.2 JHDD.2
SATA_PRX_DTX_N0_R: CS31.1 US2.12
SATA_PRX_DTX_N0_RC: CS33.2 US2.4
SATA_PRX_DTX_P0: CS34.2 JHDD.1
SATA_PRX_DTX_P0_R: CS34.1 US2.11
SATA_PRX_DTX_P0_RC: CS35.2 US2.5
SATA_PTX_DRX_N0: CS32.2 JHDD.4
SATA_PTX_DRX_N0_R: CS36.2 US2.2
SATA_PTX_DRX_N0_RC: CS32.1 US2.14
SATA_PTX_DRX_P0: CS30.2 JHDD.5
SATA_PTX_DRX_P0_R: CS37.2 US2.1
SATA_PTX_DRX_P0_RC: CS30.1 US2.15
SD_RCOMP: RC76.2 UC1.AB7
SERIRQ: RC122.1 UC1.AY11 UE5.55
SIO_EXT_SCI#: RC200.1 UC1.J2 UE5.66
SIO_EXT_SMI#: RC222.2 RC234.2 UC1.L6 UE5.10
SIO_EXT_WAKE#: RC64.1 UC1.AD3 UE5.116
SIO_PWRBTN#: RC109.2 RC111.1 UE5.52
SIO_PWRBTN#_R: RC109.1 UC1.BA15
SIO_RCIN#: RC225.1 UC1.AW13 UE5.53
SIO_SLP_A#: T93.1(TP-1) UC1.AN16
SIO_SLP_LAN#: T87.1(TP-1) UC1.AW15
SIO_SLP_S0#: UC1.AT11 UC15.2
SIO_SLP_S3#: CE87.1 DC6.1 PQ1.2 PR2.1 PR658.1 PR682.1 R2313.1 R2318.1 RC130.1 RC194.1 RZ75.1 UC1.AP15 UC15.1 UE5.70
SIO_SLP_S4#: PR201.1 RC144.1 UC1.BA16 UE5.67
SIO_SLP_S5#: PQ711.2 UC1.AY16
SIO_SLP_SUS#: PR313.1 PR504.1 RC128.2 RC174.1 UE5.96
SIO_SLP_SUS#_R: RC128.1 UC1.AN15
SIO_SLP_WLAN#: T88.1(TP-1) UC1.BB17
SKL_CNL#: RC184.1 UC1.C64
SLEEVE: LA7.2 RA53.1 UA1.18
SM_RCOMP0: RC38.1 UC1.AR18
SM_RCOMP1: RC39.1 UC1.AT18
SM_RCOMP2: RC40.1 UC1.AU18
SMB_ALERT#: RC229.2 UC1.R10
SMBCLK: QC2.6 RPC18.1 UC1.R7
SMBDATA: QC2.3 RPC18.2 UC1.R8
SML0_ALERT#: RC202.2 UC1.W1
SML0_SMBCLK: RC49.1 UC1.R9
SML0_SMBDATA: RC50.1 UC1.W2
SML1_ALERT#: RC221.2 UC1.AM7
SML1CLK: QC3.4 RC399.1 RPC7.1 UC1.W3
SML1DATA: QC3.1 RC397.1 RPC7.2 UC1.V3
SNB_+1VALWP: PC302.1 PR303.2
SNUB_1.8VALW: PC506.1 PR502.2
SNUB_VGA1: PC819.1 PR821.1
SNUB_VGA2: PC820.1 PR822.1
SOC_GPIOA7: RC201.1 UC1.BB11
SOC_GPIOB16: RC195.1 UC1.AP7
SOC_GPIOC10: RC204.1 UC1.W4
SOC_XDP_TDI: RC13.1 UC1.D59 UC1.D60
SOC_XDP_TDO: RC15.1 UC1.A56 UC1.A61
SOC_XDP_TMS: RC11.1 UC1.C59 UC1.C60
SOC_XDP_TRST#: T4956.1(TP-1) UC1.B59 UC1.C61
SPK_L1-_CONN: CA30.1 DA13.3 JSPK.3 LA5.2
SPK_L2+_CONN: CA29.1 DA13.2 JSPK.4 LA6.2
SPK_R1-_CONN: CA32.1 DA14.3 JSPK.1 LA3.2
SPK_R2+_CONN: CA31.1 DA14.2 JSPK.2 LA4.2
SPKR: DA8.3 RC117.2 UC1.AW5
SRTCRST#: CC10.2 CLRP1.2 RC91.2 UC1.AN18
STRAP0: RV47.2 RV52.1 UV1.D1
STRAP1: RV48.1 RV51.2 UV1.D2
STRAP2: RV46.2 RV50.1 UV1.E4
STRAP3: RV45.2 RV49.1 UV1.E3
STRAP4: RV61.2 RV62.1 UV1.D3
STRAPREF0: RV44.1 UV1.F6
SUS_STAT#: RC110.1 UC1.BA11
SUSACK#: RC398.2 UE5.34
SUSACK#_R: RC398.1 UC1.AP11
SUSCLK: RC105.1 RM5.2 UC1.BA17
SUSCLK_R: JNGFF.42 RM5.1
SW_+1VALWP: PC304.2 PL301.1 PR303.1 PU301.10
SYS_PWROK: UC1.B6 UE5.89
SYS_RESET#: CLRP3.1 RPC11.4 UC1.B5
THM_SML1_CLK: Q2409.4 R2456.2 R2459.1 U2407.10
THM_SML1_DATA: Q2409.1 R2457.2 R2458.1 U2407.9
TMDS_L_TX0N: JHDMI.9 RX38.2 RX39.1
TMDS_L_TX0P: JHDMI.7 RX39.2 RX40.2
TMDS_L_TX1N: JHDMI.6 RX41.2 RX42.1
TMDS_L_TX1P: JHDMI.4 RX42.2 RX43.2
TMDS_L_TX2N: JHDMI.3 RX44.2 RX45.1
TMDS_L_TX2P: JHDMI.1 RX45.2 RX46.2
TMDS_L_TXCN: JHDMI.12 RX35.2 RX36.1
TMDS_L_TXCP: JHDMI.10 RX36.2 RX37.2
TMDS_TX0N: CX14.1 RP59.2 RX38.1
TMDS_TX0P: CX15.1 RP59.1 RX40.1
TMDS_TX1N: CX16.1 RP58.2 RX41.1
TMDS_TX1P: CX17.1 RP58.1 RX43.1
TMDS_TX2N: CX18.1 RP58.4 RX44.1
TMDS_TX2P: CX19.1 RP58.3 RX46.1
TMDS_TXCN: CX12.1 RP59.4 RX35.1
TMDS_TXCP: CX13.1 RP59.3 RX37.1
TON_1.35V: PR208.2 PU200.9
TON_VGA: PR809.1 PU801.9
TOUCH_SCREEN_PD#: DX9.2 RC215.2 RC402.1 RX25.1
TOUCHPAD_INTR#: DC3.1 QE7.1 RE354.1 UE5.33
TOUCHPAD_INTR#_D: DC3.2 RC216.2 UC1.BA5
TP_LOCK#: DE4.2 JTP.3 RC78.1
TP_PW_EN#: CE61.1 QE8.2 QE9.2 UE5.49
TS_EN_R: CX9.1 JEDP.22 RX25.2
TS_INT#: JEDP.21 RX47.2
TS_RST#: CX4.1 JEDP.19 RX24.2
UART_2_CRXD_DTXD: JWDB1.2 RC62.1 UC1.AD1
UART_2_CTXD_DRXD: JWDB1.3 RC63.1 RC68.1 UC1.AD2
UG2_VGA: PQ801.1 PU801.14
UG_1.35V: PQ201.1 PU200.17
UGATE_CHG: PQ704.4 PU703.23
USB2_COMP: RC119.1 UC1.AB6
USB2_ID: RC10.1 UC1.AG3
USB2_VBUSSENSE: RC16.1 UC1.AG4
USB3_CM_P0: RI42.2 RI46.2 UI8.14
USB3_CRX_C_RD_DTX_N3: CI22.2 UI8.11
USB3_CRX_C_RD_DTX_P3: CI19.2 UI8.12
USB3_CRX_DTX_N1: RI97.1 UC1.H8
USB3_CRX_DTX_N2: RI103.1 UC1.J6
USB3_CRX_DTX_N3: CI22.1 UC1.J10
USB3_CRX_DTX_P1: RI98.1 UC1.G8
USB3_CRX_DTX_P2: RI104.1 UC1.H6
USB3_CRX_DTX_P3: CI19.1 UC1.H10
USB3_CRX_L_DTX_N3: DI3.2 DI3.9 JCAM3D.9 LI10.1 RI3.2
USB3_CRX_L_DTX_P3: DI3.1 DI3.10 JCAM3D.8 LI10.4 RI4.2
USB3_CRX_RD_DTX_N3: LI10.2 RI3.1 UI8.20
USB3_CRX_RD_DTX_P3: LI10.3 RI4.1 UI8.19
USB3_CTX_C_DRX_N3: CI21.2 LI9.2 RI5.1
USB3_CTX_C_DRX_P3: CI24.2 LI9.3 RI6.1
USB3_CTX_C_RD_DRX_N3: CI16.2 UI8.8
USB3_CTX_C_RD_DRX_P3: CI5.2 UI8.9
USB3_CTX_DRX_N1: CI3.2 UC1.C13
USB3_CTX_DRX_N2: CI10.2 UC1.B13
USB3_CTX_DRX_N3: CI16.1 UC1.B15
USB3_CTX_DRX_P1: CI4.2 UC1.D13
USB3_CTX_DRX_P2: CI11.2 UC1.A13
USB3_CTX_DRX_P3: CI5.1 UC1.A15
USB3_CTX_L_DRX_N3: DI3.5 DI3.6 JCAM3D.6 LI9.1 RI5.2
USB3_CTX_L_DRX_P3: DI3.4 DI3.7 JCAM3D.5 LI9.4 RI6.2
USB3_CTX_RD_DRX_N3: CI21.1 UI8.23
USB3_CTX_RD_DRX_P3: CI24.1 UI8.22
USB3_DE1_P0: RI26.2 RI35.2 UI8.3
USB3_DE2_P0: RI20.2 RI31.2 UI8.16
USB3_EQ1_P0: RI23.2 RI32.2 UI8.2
USB3_EQ2_P0: RI21.2 RI36.2 UI8.17
USB3_ERD_P0: RI44.2 RI48.2 UI8.5
USB3_OS1_P0: RI22.2 RI40.2 UI8.4
USB3_OS2_P0: RI19.2 RI87.2 UI8.15
USB3_P0_PIN6: RI49.2 RI53.2 UI8.6
USB3_P0_PIN18: RI50.2 RI52.2 UI8.18
USB3RN1_JUSB1_R: DI1.1 DI1.10 JUSB1.5 RI97.2
USB3RN2_JUSB2_R: DI4.1 DI4.10 JUSB2.5 RI103.2
USB3RP1_JUSB1_R: DI1.2 DI1.9 JUSB1.6 RI98.2
USB3RP2_JUSB2_R: DI4.2 DI4.9 JUSB2.6 RI104.2
USB3TN1_JUSB1_C: CI3.1 RI99.1
USB3TN1_JUSB1_R: DI1.4 DI1.7 JUSB1.8 RI99.2
USB3TN2_JUSB2_C: CI10.1 RI106.1
USB3TN2_JUSB2_R: DI4.4 DI4.7 JUSB2.8 RI106.2
USB3TP1_JUSB1_C: CI4.1 RI100.1
USB3TP1_JUSB1_R: DI1.5 DI1.6 JUSB1.9 RI100.2
USB3TP2_JUSB2_C: CI11.1 RI105.1
USB3TP2_JUSB2_R: DI4.5 DI4.6 JUSB2.9 RI105.2
USB20_CR_N6_R: JIO.12 LI8.2 RI110.2
USB20_CR_P6_R: JIO.11 LI8.3 RI109.2
USB20_JUSB1_N0_R: DI2.2 JUSB1.2 LI2.2 RI95.2
USB20_JUSB1_P0_R: DI2.3 JUSB1.3 LI2.3 RI96.2
USB20_JUSB2_N1_R: DI5.2 JUSB2.2 LI5.2 RI101.2
USB20_JUSB2_P1_R: DI5.3 JUSB2.3 LI5.3 RI102.2
USB20_JUSB3_N4_R: JIO.15 LI11.2 RI108.2
USB20_JUSB3_P4_R: JIO.14 LI11.3 RI107.2
USB20_N1: LI2.1 RI95.1 UC1.AB9
USB20_N2: LI5.1 RI101.1 UC1.AD6
USB20_N4: LI11.1 RI108.1 UC1.AD9
USB20_N5: LX6.1 RX21.1 UC1.AJ1
USB20_N5_L: JEDP.28 LX6.2 RX21.2
USB20_N6: LI8.1 RI110.1 UC1.AF6
USB20_N7: DX2.3 JEDP.13 UC1.AH1
USB20_N8: JNGFF.5 UC1.AF8
USB20_P1: LI2.4 RI96.1 UC1.AB10
USB20_P2: LI5.4 RI102.1 UC1.AD7
USB20_P4: LI11.4 RI107.1 UC1.AD10
USB20_P5: LX6.4 RX22.1 UC1.AJ2
USB20_P5_L: JEDP.27 LX6.3 RX22.2
USB20_P6: LI8.4 RI109.1 UC1.AF7
USB20_P7: DX2.2 JEDP.14 UC1.AH2
USB20_P8: JNGFF.3 UC1.AF9
USB_EN#: CI13.1 CI26.1 CI46.1 RE356.1 UE5.13 UI5.4 UI6.4 UI7.4
USB_OC#0_1: CI15.1 RPC14.3 UC1.A9 UI5.3 UI6.3
USB_OC#2_3: CI47.1 RPC14.1 UC1.C9 UI7.3
USB_OC#4_5: RPC14.4 UC1.D9
USB_OC#6_7: RPC14.2 UC1.B9
VCI_IN1: RE370.1 UE5.126
VCIN0_PH: CE26.1 HE1.1 RE332.1 RE333.1 RE375.2
VCREF0: CE81.1 RE380.2 RE383.1 UE5.25
VGA_EN: PC801.1 PR801.1 PR823.1 PR825.1 PU801.3
VID_PLLVDD: CV30.1 CV34.1 CV35.1 CV60.1 CV61.1 LV3.2 UV1.M6 UV1.N6
VIDALERT_N: PR607.1 RC179.2 RC180.2
VIDSCLK: PR606.1 UC1.A63
VIDSOUT: PR609.1 RC181.2 UC1.D64
VL: PC126.1 PU102.15
VR_ALERT#: PR625.2 PU602.36
VR_CAP: C5231.1 UE5.18
VR_SCLK: PR618.2 PU602.37
VR_SDA: PR626.2 PU602.35
VRALERT#: RC115.2 UC1.AM11
VRAM_ID1: RC317.1 RC320.1 UC1.AP8
VRAM_ID2: RC316.1 RC321.1 UC1.AW7
VREF_VGA: PC803.2 PR806.2 PU801.8
VSA_SEN+: PC640.2 PC650.1 PC652.1 PR649.2 RC227.1 UC1.H20
VSA_SEN-: PC649.1 PC650.2 PU602.26 RC228.1 UC1.H21
VTTREF_1.35V: PC210.1 PU200.4
WL_OFF#_R: DM1.2 JNGFF.48 RM8.2
WLAN_RADIO_DIS#: DM1.1 RC224.2 UC1.B7
XCLK_BIASREF: RC96.1 RC124.1 UC1.E42
XDP_ITP_PMODE: RC31.2 UC1.E8
XDP_OBS0_R: T16.1(TP-1) UC1.C55
XDP_OBS1_R: T19.1(TP-1) UC1.D55
XDP_OBS2_R: T10.1(TP-1) UC1.B54
XDP_OBS3_R: T11.1(TP-1) UC1.C56
XDP_PRDY#: T4964.1(TP-1) UC1.D56
XDP_PREQ#: T4963.1(TP-1) UC1.D61
XDP_SPI_IO2: RC21.2 RC46.1
XDP_SPI_SI: RC9.2 RC44.2
XTAL24_IN: CC13.1 RC92.2 UC1.E37 YC1.1
XTAL24_OUT: CC12.1 RC92.1 UC1.E35 YC1.3
XTAL_OUT: RV24.1 UV1.B10
XTAL_OUT_R: CV36.1 RV24.2 YV1.3
XTAL_OUTBUFF: RV20.1 RV23.1 UV1.C10
XTALIN: CV37.1 UV1.C11 YV1.1
XTLI: CL36.2 UL1.29 YL2.1
XTLO: CL37.2 UL1.28 YL2.3
N16662246: CA62.2 RA12.2 UA1.27
N16662258: CA63.2 UA1.39
N16662270: CA64.2 UA1.7
N16662316: CA24.1 UA1.37
N16662328: CA24.2 UA1.35
N16662332: CA25.2 UA1.34
N16662348: CA23.2 UA1.28
N16662926: RA1113.2 UA1.4
N17072999: C5216.1 U2301.12
N17073002: C5217.1 U2301.10
N17200666: RS19.2 US2.7
N17200720: RS25.2 US2.10
N17335389: JNGFF.47 RM14.2
N17415515: PJP2.2 PJPDC.2 PJPDC.3 PL4.1
N17932877: RX10.2 UX4.3
N17933717: RL40.2 UL3.3
N18624295: JLED.7 QI2.3
N18624308: JLED.6 RI1.3
N18894766: PC640.1 PR646.2
N18894780: PC601.1 PR652.2
N18894857: PC632.1 PR636.1 PU602.28
N18894871: PH604.1 PR642.2
N19050685: RI57.1 UI8.24
N19050753: RI56.1 UI8.7
N19073745: CC95.1 UC5.12
N19073816: CC94.1 UC5.10
N19607621: QX5.2 RX15.1
N19675639: C5220.1 U2409.6
N19901660: CE76.1 R2454.1
N20173639: RE369.1 RE371.1 UE5.120
N20440449: CE73.1 RE346.1 UE5.54
N20880735: PC307.2 PR308.1
N21609269: RV111.2 UV5.L8
N23042445: RV21.1 UV1.A10
N23677896: CV83.1 UV10.12
N23677916: CV67.1 UV10.10
N23700319: PL2.1 PQ6.1 PR6.2
N24017484: CV46.1 CV47.1 CV54.1 RV58.2 UV1.G10 UV1.G12
N24019691: CV48.1 CV49.1 CV50.1 CV69.1 RV40.2 UV1.G8 UV1.G9
N24050156: RV82.1 UV1.F22
N24050174: RV83.1 UV1.J22
N24606174: PC313.1 PU301.5
N25003853: T14.1(TP-1) UC1.AW56
N25003855: T15.1(TP-1) UC1.AY56
N25004858: T22.1(TP-1) UC1.AT52
N26262691: QX3.1 RP58.5 RP58.6 RP58.7 RP58.8 RP59.5 RP59.6 RP59.7 RP59.8
N26277151: RL39.2 UL1.26
N26278721: RL31.2 UL1.31
N26280117: CL41.2 TL2.3 TL2.6
N26468807: RS20.2 RS22.2 US2.18
N26505655: PR604.2 PR607.2 PR625.1
N26505659: PR601.2 PR606.2 PR618.1
N26505677: PR605.2 PR609.2 PR626.1
N26506002: PR616.2 PU602.40
N26506037: PR612.2 PU602.39
N26506689: PR678.2 PU602.38
N26508248: PC603.1 PR602.1 PU602.34
N26508256: PC604.1 PR603.1 PU602.33
N26509112: PR608.1 PU602.32
N26509117: PR611.1 PU602.31
N26519264: PH605.1 PR657.2
N26519948: PC630.1 PR640.1 PU602.20
N26522108: PC639.2 PR645.1
N26523008: PC647.2 PR650.2
N26523611: PC629.2 PR639.1
N26527807: PH602.1 PR628.2
N26528911: PC627.2 PR638.2 PU602.8
N26532119: PC621.2 PR623.1
N26532121: PR621.2 PR622.2 PR623.2 PU602.5
N26533060: PC616.2 PR617.2 PU602.4
N26533062: PC614.2 PR617.1
N26533293: PR610.2 PU602.3
N26533871: PC613.2 PR613.2 PU602.2
N26554964: PC617.2 PR621.1
N26566701: PC631.1 PR630.2
N26806678: RV112.2 UV4.L8
N26836211: RV97.2 UV7.L8
N26836537: RV98.2 UV6.L8
N26838068: RV114.2 UV8.L8
N26838394: RV116.2 UV9.L8
N26894462: RV101.2 UV15.L8
N26894764: RV99.2 UV14.L8
N27802877: RC127.2 UC1.AT10
N27802878: RC126.2 UC1.AU8
N27802879: RC125.2 UC1.AU7
N27811001: RC113.2 RC116.1 UC12.4
N27812400: RC402.2 UC1.A7
N27817142: RC361.2 UC1.U11 UC1.U12
N27871984: DC1.2 QC4.2 RC192.2 RC400.1
N27876104: JKBBL.2 RE61.2
N28100651: CA21.1 RA1112.2
N28103940: CA68.2 RA82.1
N28103942: CA67.2 RA80.1
N28204071: CA65.2 CA69.1 RA79.1 RA81.2
N28215693: CL33.1 RL19.2 RL20.2
N28438430: PC304.1 PR304.2
N28438489: PR619.1 PU606.2
N28438498: PC611.1 PR619.2
N28483985: PQ1.3 PR5.2
N28484391: PC16.1 PQ2.3 PR28.2
N28484395: PC16.2 PQ2.2 PR29.1
N28484412: PQ2.5 PR31.1 PR33.2
N28484439: PC14.2 PQ3.5 PR32.1
N28484451: PQ1.5 PQ1.6 PR7.1 PR10.2
N28656203: DX3.1 FX1.2
N28656603: DX4.3 RX16.2
N28656604: DX4.2 RX17.2
N28712229: PC671.2 PU605.5
N28712232: PR672.2 PU605.3
N28712235: PC671.1 PR672.1
N28714854: PC655.2 PU603.5
N28714856: PR660.2 PU603.3
N28714858: PC655.1 PR660.1
N28714964: PR659.1 PU603.1
N28745337: PR769.2 PU703.3
N28745341: PR770.2 PU703.4
N28745344: PQ709.1 PQ718.1 PQ718.2 PQ718.3 PQ740.1 PQ740.2 PQ740.3 PR737.1 PR763.1
N28745361: PC750.1 PU703.27
N28745372: PC752.2 PR754.1
N28745397: PR777.2 PU703.5
N28745398: PR774.2 PU703.6
N28745401: PR775.2 PU703.7
N28745403: PC721.1 PR771.2
N28745412: PC757.2 PR743.1 PU703.18
N28745424: PR755.2 PU703.12
N28745425: PC708.1 PR776.1 PU703.14
N28745427: PC708.2 PR742.1 PU703.15
N28745442: PC747.1 PR740.2 PU703.31
N28745443: PC747.2 PR772.2 PU703.32
N28745445: PC750.2 PU703.28
N28745448: PR773.1 PU703.25
N28745452: PR745.1 PU703.26
N28745458: PR771.1 PU703.24
N28745460: PR757.2 PU703.17
N28745463: PQ718.5 PR703.1
N28745469: PR757.1 PR779.2
N28745471: PQ709.6 PQ718.4 PQ740.4 PR762.1
N28745480: PC779.2 PQ717.4 PR773.2
N28745481: PC705.1 PC760.1 PC762.1 PC763.1 PC764.1 PC765.1 PJP701.2 PL704.2 PQ704.5
N28745526: PC779.1 PL700.2 PQ717.1 PQ717.2 PQ717.3 PR765.1
N28745552: PR742.2 PR765.2
N28745555: PR765.3 PR776.2
N28745573: PQ709.2 PR737.2 PR738.1
N28745582: PR703.2 PR772.1
N28745583: PR703.3 PR740.1
N28745613: PC767.1 PR766.2
N28745644: PQ709.5 PR739.1 PR746.2
N28745648: PD704.1 PD705.1 PR743.2
N28745659: PQ709.3 PR744.1
N28745660: PR764.2 PU703.13
N28745668: PQ710.2 PQ711.1
N28745686: PQ707.6 PR720.2
N28783709: CE61.2 QE9.3 RE400.2
N28784713: QE8.1 RE402.2
N28883037: QI1.2 QI1.3 RI93.1
N28911604: QI2.5 QI2.6 RI91.1
N28917899: RC60.2 RPC5.5
N29150944: PC630.2 PR644.1
N29151042: PC627.1 PR632.2
N29151125: PC632.2 PR641.1
N29151735: PR658.2 PR664.2 PU603.12
N29151788: PR682.2 PR683.2 PU605.12
N29207759: PH601.2 PR610.1 PR631.2
N29270847: PH603.2 PR635.1 PR647.2
N29296707: RC52.2 RC61.1
N29351482: RI1.5 RI1.6 RI94.1
N29351651: JLED.5 QI1.6
N29409930: QV5.5 QV5.6 QV74.2 RV2719.2
N29410477: CV59.1 QV5.3 QV7.4 RV2720.2
N29411532: QV8.5 QV8.6 RV129.1 RV212.1
N29411851: CV66.2 QV6.2 RV129.2
N29413258: QV8.3 RV2718.1
N30058541: CC93.2 RC130.2 UC13.2
N30601882: CV200.1 RV208.1 RV211.1 UV23.5
N32012960: PQ501.8 PU606.5
N32012964: PQ501.1 PU606.1
N32015249: PR679.1 PU606.7
N32027782: JDEG1.9 RE393.2
N32027839: JDEG1.1 RE390.2
N32028607: RE397.1 T4931.1(TP-1)
N32778757: PR671.1 PU605.1
N33124395: PC204.2 PR210.1 PU200.12
N33124472: PC207.2 PR203.1
N33726059: PD102.1 PR116.2
N33726168: PC128.1 PD102.2 PR114.2 PR120.2 PR121.2
N33965903: PC802.1 PR805.2 PR806.1 PR807.1
N33966216: PR808.2 PR824.1
N33966301: PR802.1 PR803.1 PR804.1 PU801.4
N33966313: PQ800.1 PU801.2
N33966437: PC805.1 PU801.11
N34009843: PBATT.3 PD3.3
N34010362: PBATT.5 PR15.1
N39352229: PC102.1 PR100.2
N39352417: PC119.1 PU102.16 PU102.17
N39352440: PC114.1 PR111.2
N39352447: PC113.2 PR108.1
N39352755: PC127.2 PR117.1
N55201771: JHDMI.13 RX12.2
N113223666: RV43.2 UV1.B25
N113223669: RV42.2 UV1.C24
N113223672: RV41.1 UV1.D22
N123563926: CD21.2 RD12.1
N123564541: CD31.2 RD16.1
N123564950: CD49.2 RD21.1
N124136876: CC71.1 UC1.BB10
N124150417: T123.1(TP-1) UC1.K32
N124150426: T121.1(TP-1) UC1.AK32
N124433686: T213.1(TP-1) UC1.BA70
N124433695: T215.1(TP-1) UC1.BA68
N124433804: T156.1(TP-1) UC1.BB68
N124433815: T157.1(TP-1) UC1.BB69
N124433840: T158.1(TP-1) UC1.AK13
N124433849: T159.1(TP-1) UC1.AK12
N124433912: T162.1(TP-1) UC1.AU5
N124433921: T163.1(TP-1) UC1.AT5
N124434211: T199.1(TP-1) UC1.BB5
N124434229: RC182.1 UC1.AY3
N124434328: T214.1(TP-1) UC1.AY4
N124434330: T216.1(TP-1) UC1.BB3
N124434364: T221.1(TP-1) UC1.AW71
N124434366: T223.1(TP-1) UC1.AW70
N124434499: RC183.1 UC1.AY71
N124727868: T17.1(TP-1) UC1.AN55
N124727876: T18.1(TP-1) UC1.AP53
N294148061: QV74.1 RV2721.1
N312638881: PR620.2 PU602.1

Pads without a net: DE2 2; FD1 1; FD2 1; FD3 1; FD4 1; JDIMM1 77 122 125 198; JDIMM2 77 122 125 198; JEDP 16 17 38; JHDD 8; JHDMI 14; JIO 5 7; JKB 2 3; JKBBL 3; JLAN 4 5 7 8; JNGFF 6 8 9 10 11 12 13 14 15 16 17 19 20 21 22 23 24 26 28 32 34 40 50 51 52 53 54 56 57 58 59 60 62 63 65; PQ3 1 2 6; PU100 10 15; PU102 10; PU301 2; PU603 4 9; PU605 4 9; RPC1 7 8; RPC7 3 4; RPC10 3; RPC18 3 4; RPV5 4 5; RPV6 4 5; TL2 4 5 12 13; U2407 8; UA1 14 15 23 24 48; UC1 A3 A4 A6 A11 A23 A25 A26 A27 A29 A31 A33 A36 A38 A40 A45 A47 A50 A52 A65 A69 AB1 AB4 AB11 AB12 AB13 AB62 AC1 AC2 AC3 AD11 AD12 AE62 AF11 AF12 AF13 AG1 AG2 AG62 AH3 AH7 AH8 AH9 AH10 AH11 AH12 AJ3 AK6 AK7 AK9 AK10 AK42 AK43 AK45 AK46 AK48 AK50 AK52 AK53 AK55 AK56 AK58 AK60 AK70 AL25 AL27 AL43 AL46 AL50 AL53 AL56 AL60 AM1 AM2 AM3 AM4 AM48 AM50 AM52 AM53 AM56 AM58 AN1 AN2 AN3 AN5 AN8 AP1 AP2 AP3 AP4 AP13 AT15 AU1 AU2 AU56 AU58 AU63 AW1 AW9 AW17 AW20 AW48 AW68 AW69 AY1 AY2 AY5 AY7 AY20 AY21 B2 B3 B11 B23 B25 B26 B27 B29 B31 B33 B36 B38 B40 B45 B47 B50 B52 B69 B70 BA3 BA4 BA9 BB2 BB4 BB9 BB57 BB66 C2 C4 C7 C11 C12 C15 C21 C23 C24 C27 C28 C29 C31 C32 C33 C36 C37 C38 C40 C50 C51 C52 C54 C70 C71 D1 D3 D4 D5 D7 D8 D12 D15 D21 D23 D24 D27 D28 D29 D31 D32 D33 D36 D37 D38 D40 D50 D51 D52 D54 D71 E1 E2 E3 E10 E22 E23 E25 E27 E28 E30 E38 E40 E48 E61 F6 F10 F21 F25 F30 F46 F48 F50 F52 F60 F61 F65 G1 G2 G3 G4 G21 G46 G50 G61 G65 H2 H3 H5 H11 H63 J4 J5 J68 J71 K45 K46 L7 M1 M3 M4 N1 N2 N3 N7 N8 N9 N11 N12 P4 P62 U2 U3 U4 U8 U9 V1 V2 V62 W7 W10 W11 W12; UC7 1; UC12 1; UC13 1; UE6 1; UL1 6 7 9 10 25 27; UV1 AA1 AA2 AA3 AA4 AA5 AA6 AB1 AB2 AB3 AB4 AB5 AB6 AB13 AB15 AB16 AB18 AB19 AB21 AC3 AC4 AC13 AC14 AC15 AC16 AC17 AC18 AC19 AC20 AC21 AD1 AD2 AD3 AD4 AD5 AD7 AD10 AD14 AD17 AD20 AD23 AE1 AE2 AE3 AE4 AE10 AE12 AE13 AE15 AE16 AE18 AE19 AE21 AE23 AE24 AF2 AF3 AF4 AF10 AF12 AF13 AF15 AF16 AF18 AF19 AF21 AF24 AG3 AG12 AG13 AG15 AG16 AG18 AG19 AG21 AG22 AG24 AG25 B2 B3 B6 B19 C1 C2 C3 C5 C7 C18 D4 D5 D6 D10 D12 D16 D17 D18 E6 E10 E12 F4 F5 F7 F9 F10 F11 F12 G1 G2 G3 G4 G5 G6 G7 H3 H4 H6 J1 J2 J3 J4 J5 J6 J7 J26 K1 K2 K3 K4 K5 K6 K7 L3 L4 M1 M2 M3 M4 M5 M7 N1 N2 N3 N4 N5 N7 P3 P4 P6 R1 R2 R3 R4 R5 R6 R7 T1 T2 T3 T4 T5 T6 T7 T24 U3 U4 U6 U24 V1 V2 V3 V4 V5 V6 V7 V24 V25 W1 W2 W3 W4 W5 W6 W7 Y3 Y4 Y6; UV4 J1 J9 L1 L9 M7; UV5 J1 J9 L1 L9 M7; UV6 J1 J9 L1 L9 M7; UV7 J1 J9 L1 L9 M7; UV8 J1 J9 L1 L9 M7; UV9 J1 J9 L1 L9 M7; UV14 J1 J9 L1 L9 M7; UV15 J1 J9 L1 L9 M7

## Via types
v1: diameter 0.305, hole 0.152, TOP to BOTTOM, 643 vias
v2: diameter 0.457, hole 0.203, TOP to BOTTOM, 5133 vias
v3: diameter 0.406, hole 0.203, TOP to BOTTOM, 138 vias
v4: diameter 0.508, hole 0.254, TOP to BOTTOM, 278 vias

## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point)
0.675V_DDR_VTT_ON: length 149.8
  TOP w0.102: v1(158.93,56.51) 159,56.57 RC129.2 RC123.2 159.87,58.11 v2(159.6,58.38) 158.82,59.16 UC7.4
  IN1 w0.102: v2(104.12,18.99) 104.12,10.46 101.37,7.71 82.44,7.71 81.46,8.69 81.46,11.87 81.08,12.25 v2(80.45,12.25)
  IN3 w0.102: v2(104.12,18.99) 104.3,19.17 105.4,19.17 105.85,18.72 129.77,18.72 129.95,18.55 130.36,18.55 131.04,19.23 132.37,19.23 132.68,19.55 139.44,19.55 140.01,20.12 140.01,21.01 140.96,21.96 143.06,21.96 143.76,22.66 146.09,22.66 147.2,23.77 165.86,23.77 168.19,26.1 170.05,26.1 170.91,26.97 170.91,33.58 169.96,34.53 169.96,36.37 167.98,38.35 167.98,40.6 168.35,40.98 168.35,43.01 167.82,43.54 167.82,45.69 167.06,46.45 167.06,50.06 160.52,56.6 160.52,57.08 159.6,58 v2(159.6,58.38)
  BOTTOM w0.254: PR202.1 v2(80.45,12.25)
1.35V_PWR_EN: length 14.6
  TOP w0.102: v2(86.71,75.78) v1(85.72,75.78) 84.64,75.78 UV23.4 82.88,74.51 82.48,74.11 RV201.2 ; QV5.2 90.71,69.62 v2(90.35,69.27)
  BOTTOM w0.102: v2(86.71,75.78) 86.71,72.92 v2(90.35,69.27)
1.35V_VTT_PWRGD: length 115.3
  TOP w0.254: RC392.1 108.13,98.73 107.5,99.37 v1(106.86,99.37) 105.91,99.37 v2(105.78,99.24)
  IN2 w0.254: v2(94.61,30.66) 89.4,30.66 86.67,27.93 85.21,27.93 81.84,24.57 81.84,17.58 81.53,17.26 v2(81.53,15.61)
  IN3 w0.254: v2(94.61,30.66) 89.78,35.49 87.88,35.49 87.47,35.89 87.47,39.68 90.42,42.63 90.42,58.87 91.07,59.52 91.07,64.4 90.87,64.59 90.87,72.52 91.56,73.21 91.56,91.77 99.99,100.19 104.45,100.19 105.4,99.24 v2(105.78,99.24)
  BOTTOM w0.203: PU200.10 82.62,14.34 PR209.2
  BOTTOM w0.254: PR209.2 81.98,15.16 v2(81.53,15.61)
3V_FB: length 3.6
  BOTTOM w0.254: PR110.1 PC113.1 PR109.2 62.32,18.06 62.02,17.76 PU100.13
3V_PRIM_OC: length 2.7
  TOP w0.102: v1(177.28,92.64) 177.33,92.69 UC8.3 178.14,94.59 RC166.1
3V_SN:
  vias: v1(69.59,18.28)
3V_VIN:
  vias: v1(59.24,13.33) v2(57.91,14.34) v2(58.54,14.34)
3VS:
  vias: v3(172.52,16.18)
3VS_GATE: length 4.7
  TOP w0.102: R2318.2 176,11.05 v1(176.21,10.85)
  TOP w0.203: C2322.1 172.99,11.71 171.66,11.71 171.25,12.12 171.25,12.4 171.02,12.63 U2301.5
5V_FB: length 4.7
  BOTTOM w0.102: v1(59.75,30.28) PR118.1
  BOTTOM w0.254: PR118.1 PC127.1 PR115.2 62.91,29.95 PU102.13
5V_SN:
  vias: v1(70.03,30.47)
5V_VIN: length 1.2
  TOP w0.102: PC115.1 v1(57.03,25.32)
  vias: v2(58.22,24.69) v2(59.24,25.84) v2(59.87,25.84)
5VS:
  vias: v3(169.6,17.58)
5VS_GATE: length 4.1
  TOP w0.102: 171.52,10.74 171.68,10.57 v1(171.68,8.82)
  TOP w0.203: U2301.3 170.22,12.62 170.16,12.56 170.16,12.01 C2309.1
+0.675V_A_VREFDQ: length 51.3
  TOP w0.381: v2(113.28,80.52) 111.31,78.54 109.15,78.54 105.85,75.24 98.93,75.24 98.29,75.87 95.43,75.87 95.05,75.49 v2(95.05,75.43)
  TOP w0.508: v2(97.78,54.41) 99.75,52.44 v1(99.75,51.36) 99.75,50.41 99.29,49.95 CD21.1 98.62,49.9 RD10.2
  IN3 w0.508: v2(95.05,75.43) 95.05,74.85 97.28,72.63 97.28,61.27 96.51,60.51 96.51,57.14 97.78,55.87 v2(97.78,54.41)
  BOTTOM w0.076: UC1.AY68 113.25,80.55 v2(113.28,80.52)
+0.675V_B_VREFDQ: length 83.9
  TOP w0.508: RD14.2 CD31.1 109.65,33.66 v1(110.01,33.3) v2(110.48,32.82)
  IN1 w0.508: v2(94.64,74.22) 94.64,70.19 94.35,69.9 94.35,66.7 91.9,64.25 91.9,56.98 90.99,56.06 90.99,40.82 92.51,39.3 102.48,39.3 103.56,38.22 103.56,36.5 106.57,33.49 109.81,33.49 v2(110.48,32.82)
  BOTTOM w0.152: UC1.BA67 113.89,80.46 113.55,80.13 113.55,79.82
  BOTTOM w0.203: 113.55,79.82 113.38,79.64 113.01,79.64 112.45,79.09 110.37,79.09 108.04,76.76 107.44,76.76
  BOTTOM w0.508: 107.44,76.76 105.07,74.4 94.82,74.4 v2(94.64,74.22)
+0.675V_DDR_VREFCA: length 37.1
  TOP w0.254: v2(139.06,38.03) 138.66,38.42 RD8.2 ; v1(150.3,24.82) 150.3,24.95 150.87,25.52 150.87,26.05 RD19.1 RD17.2 150.23,27.6 RD20.1 150.25,28.48 RD18.2 149.67,28.49 v2(149.6,28.56)
  IN1 w0.254: v2(139.06,38.03) 139.06,36.5 140.01,35.55 152.76,35.55 155.06,33.25 155.06,28.12 154.6,27.66 150.5,27.66 v2(149.6,28.56)
+0.675V_DDRA_VREFCA: length 6.6
  TOP w0.254: v1(134.61,37.52) v2(135.18,37.52) 135.2,37.51 CD17.1 136.32,37.08 136.98,37.08 CD18.1 RD8.1
  BOTTOM w0.356: JDIMM1.126 136.05,38.03 135.54,37.52 v2(135.18,37.52)
+0.675V_DDRA_VREFDQ: length 5.4
  TOP w0.254: v2(95.56,48.38) v1(95.94,48.76) CD2.1 CD1.1 RD11.1 97.71,49.88 RD10.1 RD9.2
+0.675V_DDRB_VREFCA: length 5.2
  TOP w0.254: v1(149.03,24.44) 149.04,24.45 v2(149.04,25.04) 148.42,25.66 CD47.1 148.43,25.82 CD48.1 RD17.1
  BOTTOM w0.356: JDIMM2.126 148.45,25.63 v2(149.04,25.04)
+0.675V_DDRB_VREFDQ: length 8.5
  TOP w0.254: v2(107.02,37.33) 107.74,37.33 CD29.1 ; CD29.1 107.82,37.28 v1(107.82,38.15) ; CD29.1 CD28.1 RD15.1 RD14.1 RD13.2
  BOTTOM w0.356: JDIMM2.1 108.55,35.74 107.02,37.27 v2(107.02,37.33)
+0.675V_VREFCA: length 134.5
  TOP w0.508: v2(153.22,28.82) 153.22,28.26 153.98,27.5 154.45,27.5 154.98,26.97 v3(154.98,26.34) 154.46,25.82 CD49.1 RD19.2
  IN1 w0.508: v2(95.69,73.35) 95.69,69.78 95.37,69.46 95.37,67.75 95.69,67.43 95.69,59.32 92,55.64 92,41.24 92.93,40.31 102.93,40.31 104.58,38.66 104.58,37.08 106.99,34.66 152.39,34.66 153.22,33.84 v2(153.22,28.82)
  BOTTOM w0.203: 110.59,78.69 110.69,78.79 113.36,78.79 114.2,79.64 114.2,81.09 114,81.29 UC1.AY67
  BOTTOM w0.381: 109.13,76.7 109.42,76.99 109.42,77.52 110.59,78.69
  BOTTOM w0.508: 109.13,76.7 105.79,73.35 v2(95.69,73.35)
+0.675VS_VREF_CA0: length 67.2
  TOP w0.203: 64.88,101.59 65.14,101.34 65.61,101.34 65.84,101.56 66.45,101.56 66.87,101.98 UV5.M8
  TOP w0.254: 50.16,106.86 50.16,103.12 50.89,102.38 52.07,102.38 UV9.M8 ; v2(59,101.4) 59.58,101.98 59.58,106.34 58.69,107.24 58.69,107.69
  TOP w0.508: v2(73.03,102.38) 73.62,102.96 73.62,106.01 71.81,107.81 66.86,107.81 66.16,107.12 64.58,107.12 ; 64.58,107.12 64.58,107.76 v2(64.95,108.13) ; 64.58,107.12 64.58,102.8 64.88,102.5 64.88,101.59 ; 50.16,106.86 v1(50.16,107.75) 50.16,108.39 v2(50.9,109.13) ; v2(58.69,109.13) 58.69,107.69
  IN2 w0.508: v2(64.95,108.13) 64.95,108.83 64.63,109.15 61.02,109.15 61,109.13 v2(58.69,109.13) v2(50.9,109.13)
  BOTTOM w0.254: v2(73.03,102.38) 72.15,102.38 UV8.M8 ; v2(59,101.4) 59,102.1 58.72,102.38 57.67,102.38 UV4.M8
  BOTTOM w0.508: v2(73.03,102.38) 73.68,102.38 73.91,102.61 CV70.1 75.49,102.62 RV107.1 74.62,103.55 74.16,104 74.16,104.96 74.66,105.45 RV108.2
+0.675VS_VREF_CA1: length 69.9
  TOP w0.254: v2(38.3,79.17) 37.6,79.17 37.32,79.46 37.32,80.5 UV7.M8 ; v2(37.32,65.14) 37.32,66.03 UV6.M8
  TOP w0.457: v2(30.35,80.45) RV100.2 31.03,80.27 31.95,79.35 RV94.1 CV105.1 37.92,78.29 38.3,78.67 v2(38.3,79.17)
  TOP w0.508: v2(31.17,73.5) 30.79,73.89 v1(30.79,75.37) 30.79,76.32 31.95,77.47 CV105.1
  IN2 w0.508: v2(30.54,88.57) 30.09,88.57 29.71,88.19 29.71,81.08 v2(30.35,80.45)
  BOTTOM w0.203: 38.11,73.29 38.36,73.03 38.36,72.56 38.14,72.34 38.14,71.72 37.72,71.31 37.72,71.23 UV14.M8
  BOTTOM w0.254: UV15.M8 37.32,86.1 37.32,87.28 37.03,87.57 33.7,87.57 32.7,88.57 v2(30.54,88.57) ; v2(30.35,80.45) 32.2,78.59 37.72,78.59 v2(38.3,79.17)
  BOTTOM w0.508: 38.11,73.29 37.2,73.29 36.9,73.59 34.22,73.59 34.14,73.5 32.52,73.5 ; 32.52,73.5 v2(31.17,73.5) ; 32.52,73.5 32.52,71.82 32.06,71.37 32.06,66.48 33.99,64.55 36.72,64.55 v2(37.32,65.14)
+0.675VS_VREF_DQ0: length 72.3
  TOP w0.254: 73.84,99.11 73.51,98.78 UV5.H1 ; 59.96,106.99 59.96,99.85 58.87,98.76 58.09,98.76 UV9.H1
  TOP w0.508: 59.96,106.99 59.77,107.18 v2(59.77,109.82) ; v2(65.65,108.13) 66.1,108.13 66.41,108.45 v1(68.07,108.45) 72.08,108.45 74.25,106.27 74.25,101.17 73.84,100.77 73.84,99.11
  IN1 w0.508: v2(65.65,108.13) 65.65,108.51 64.34,109.82 v2(59.77,109.82) 59.24,110.36 50.92,110.36 v2(50.09,109.53)
  BOTTOM w0.254: UV8.H1 65.68,98.78 65.16,99.31 ; UV4.H1 51.15,99.3
  BOTTOM w0.508: v2(65.65,108.13) 65.65,107.62 64.61,106.58 64.61,102.78 64.9,102.49 64.9,99.57 65.16,99.31 ; 51.15,99.3 51.15,99.39 50.16,100.38 CV71.1 RV113.1 RV115.2 49.52,102.42 50.09,102.99 v2(50.09,109.53)
+0.675VS_VREF_DQ1: length 75.4
  TOP w0.254: 40.4,87.6 40.82,87.18 40.82,86.6 UV7.H1 ; UV6.H1 40.92,72.49 40.39,73.02
  TOP w0.381: 40.4,87.6 40,88 33.27,88 32.06,89.21 v2(30.54,89.21)
  TOP w0.508: 31.95,72.38 CV106.1 RV96.1 RV95.2 ; 31.95,72.38 33.13,73.57 36.92,73.57 37.21,73.28 40.13,73.28 40.39,73.02 ; 31.95,72.38 v1(31.04,72.38) v2(30.28,72.38)
  IN2 w0.508: v2(40.51,65.21) 39.81,64.51 33.65,64.51 30.28,67.87 v2(30.28,72.38) v2(30.28,77.64) 29.6,77.64 29.08,78.16 29.08,88.51 29.77,89.21 v2(30.54,89.21)
  BOTTOM w0.254: UV14.H1 40.92,65.62 v2(40.51,65.21) ; UV15.H1 40.94,80.08 40.94,79.3 39.85,78.21 31.22,78.21 30.65,77.64 v2(30.28,77.64)
+0.675VS_VTT: length 53.1
  IN1 w1.524: 92.26,9.39 97.53,9.39
  BOTTOM w1.524: 114.29,22.85 111.82,22.85 110.23,21.26 110.23,18.15 110.9,17.48 110.9,13.24 107.53,9.87 100.23,9.87 ; 172.21,24.12 170.43,22.34 ; 175.25,31.11 175.25,35.55 171.82,38.98 165.86,38.98 165.35,39.49 161.16,39.49
  vias: v1(159.51,42.98) v2(90.42,9.83) v2(90.42,9.2) v2(90.99,9.52) v2(98.93,10.21) v2(98.93,9.58) v2(99.5,9.9) v2(159.7,47.74) v2(159.7,47.11) v2(160.01,39.81) v2(160.01,39.17) v2(172.14,35.17) v2(172.14,34.54) v2(172.46,26.92) v2(172.46,26.28)
+0.675VSP: length 0.6
  TOP w0.102: v2(89.08,10.6) v3(89.08,11.23)
+1.0V_APLL: length 3.3
  IN2 w0.508: v2(144.31,93.46) 144.31,94.08 145.34,95.11 v2(145.34,95.18)
  BOTTOM w0.254: UC1.L21 v2(140.4,96.76) ; v2(144.31,93.46) 144.31,93.34 144.02,92.99 UC1.V15
  vias: v1(156.2,98.1) v2(154.07,96.94) v2(154.63,96.91)
+1.0V_CLK4_F100OC: length 0.5
  BOTTOM w0.254: UC1.N20 v2(140.4,95.08)
  vias: v1(151.38,100.32) v2(150,98.31)
+1.0V_CLK5: length 16.4
  TOP w0.254: v2(138.07,98.94) 138.29,98.72 138.29,98.59 v1(138.6,98.28) 139.58,97.29 141.06,97.29 ; RC96.2 126.87,99.18 v2(127.09,98.96)
  IN1 w0.254: v2(127.09,98.96) 127.69,98.36 137.48,98.36 v2(138.07,98.94)
  BOTTOM w0.254: v2(141.05,95.97) 141.34,96.34 UC1.L19
+1.0V_CLK6_24TBT: length 14.3
  IN1 w0.254: v2(146.74,102.92) 147.63,102.04 147.63,97.49 147.29,97.15 145.91,97.15 145.78,97.28 142.04,97.28 141.7,96.94 v2(141.7,96.84)
  BOTTOM w0.203: UC1.A14 144.3,102.4 144.3,102.4 144.3,103.15 v2(144.4,103.25) ; v2(146.74,102.92) 146.78,102.89 UC1.A10
  BOTTOM w0.254: UC1.K19 141.37,97.16 v2(141.7,96.84)
  vias: v1(149.47,104.77)
+1.0V_DTS: length 2.8
  TOP w0.076: RC162.2 152.84,95.29 152.84,95.62 153.23,96.02 v1(153.23,96.32)
  TOP w0.508: v2(152.33,94.48) 152.72,94.87 RC162.2
  BOTTOM w0.254: v2(152.33,94.48) 152.31,94.46 UC1.T1
+1.0V_MPHYJP:
  vias: v1(186.49,80.76)
+1.0V_MPHYPLL: length 10.6
  TOP w0.381: v2(143.65,95.95) 143.93,96.23 CC61.1
  TOP w0.508: CC122.1 140.43,89.17 v2(140.38,89.22)
  BOTTOM w0.254: UC1.T20 140.72,93.77 v2(141.09,93.4) 141.37,93.68 UC1.T19 ; UC1.P15 143.98,94.77 v2(143.7,95.04) 143.98,95.32 UC1.N15 143.98,95.62 v2(143.65,95.95) ; v2(143.65,95.95) 143.98,96.27 UC1.L15 UC1.K15 ; v2(143.65,95.95) 143.65,95.83 UC1.N16 ; UC1.P16 143.02,94.96 v2(143.02,95.03) 143.33,95.33 UC1.N16 ; UC1.N16 143.33,95.64 v2(143.02,95.95) 142.68,95.6 UC1.N17 UC1.N18 141.69,95.83 v2(141.69,95.85) ; UC1.AF20 140.72,89.56 v2(140.38,89.22) 140.07,89.52 UC1.AF21
  vias: v1(175,83.05) v2(153.28,86.29) v2(154.03,86.48) v2(160.14,83.94) v2(160.2,84.89) v2(160.78,84.26) v2(161.28,84.89)
+1.0V_PRIM: length 265.5
  TOP w0.203: UE5.95 130.08,5.75 128.77,4.44 128.28,4.44 CE75.1
  TOP w0.381: CC87.1 146.09,96.97 145.85,97.21 142.55,97.21 142.35,97.01 v2(142.35,96.84)
  TOP w0.508: CC87.1 149.4,96.97 149.79,96.57 149.79,95.69 v2(149.85,95.62) 150.31,95.17 151.8,95.17 RC162.1 151.81,95.8 152.14,96.13 v2(152.77,96.13) ; CE75.1 128.09,3.85 128.39,3.55 v2(128.66,3.55)
  TOP w3.048: 184.4,73.59 184.4,70.73 182.81,69.14 179.89,69.14
  IN1 w0.508: v2(149.85,95.62) 150.93,95.62 151.31,96 151.31,98.43 149.69,100.05 149.69,101.74 150.87,102.92 v2(150.87,103.28) ; v2(158.62,11.93) 162.72,11.93 163.16,12.38 163.16,13.16 175.56,25.55 175.56,35.86 173.6,37.81 173.6,40.38 v2(173.16,40.82)
  IN2 w0.508: v2(158.62,11.93) 158.62,11.51 153.02,5.92 147.94,5.92 145.61,3.59 142.92,3.59 142.29,4.21 129.42,4.21 128.76,3.55 v2(128.66,3.55)
  IN2 w1.016: 99.05,35.81 100.26,35.81 104.13,31.93 104.13,27.93 105.71,26.36 170.25,26.36 171.57,27.68 171.57,32.69 173.03,34.15 173.03,36.19 172.59,36.63 172.59,39.74
  IN3 w0.254: v2(149.85,95.62) 149.74,95.62 149.47,95.36 147.92,95.36 147.52,94.95
  IN3 w1.016: 95.81,89.78 93.53,87.49 93.53,72.38 94.93,70.98 94.93,66.03 94.86,65.97 ; 96.49,35.28 93.55,35.28 92.83,36 92.83,54.16 94.54,55.87 94.54,59.68
  BOTTOM w0.203: UC1.AK20 140.72,87.08 139.91,86.58 v2(139.84,86.58)
  BOTTOM w0.254: v2(142.35,96.84) 142.61,97.18 UC1.K17 ; UC1.AF18 142.02,89.54 v2(141.7,89.21) 141.37,89.54 UC1.AF19 ; v2(139.79,92.57) 140.07,92.85 UC1.V21 ; UC1.AB17 142.44,91.55 142.44,91.73 UC1.Y18 142.35,92.47 v2(142.35,92.57) ; UC1.P18 142.05,94.66 141.69,95.02 v2(141.69,95.03) ; UC1.L1 151.98,97.11 152.77,96.32 v2(152.77,96.13) ; UC1.AB20 v2(141.05,90.89) 141.37,91.21 UC1.AB19
  vias: v2(94.29,64.95) v2(94.29,64.32) v2(97.66,35.74) v2(98.16,35.42) v2(145.79,94.16) v2(146.55,94.16) v2(150.1,81.88) v2(151.22,79.34) v2(151.58,78.9) v2(152.28,103.37) v2(173.16,41.46) v2(175,74.57) v2(175,73.98) v2(175,73.4) v2(175,72.81) v2(175,72.22) v3(178.11,61.71)
+1.0V_PRIM_JP:
  vias: v1(167.44,42.35)
+1.0V_VCCSFR: length 22.7
  TOP w0.254: v2(139.75,96.76) 139.75,96.71 139.95,96.51 CC55.1
  TOP w0.508: RC143.2 138.77,102.63 138.77,103.6 139.74,104.58 v1(140.26,104.58) v2(140.84,104.58)
  IN1 w0.381: v2(140.84,104.58) 142.35,104.58 146.01,100.91 146.01,98.74 144.96,97.69 140.23,97.69 139.75,97.2 v2(139.75,96.76)
  BOTTOM w0.254: v2(139.75,96.76) 140.07,97.08 UC1.K21 140.19,97.29 140.61,97.29 UC1.K20
+1.0V_VCCST: length 87.7
  TOP w0.508: v2(97.1,115.64) PC602.1 PR605.1 PR604.1 PR601.1 ; v2(144.14,114.1) 144.71,113.53 144.71,113.34 145.57,112.48 v3(146.11,112.48) 146.9,112.48 149.92,109.47 149.92,107.75 148.9,106.73 144.9,106.73 142.8,104.64 142.8,104.23 v2(142.04,103.47) 142.74,102.76 CC48.1 142.69,102.23 RC140.2
  IN3 w0.508: v2(144.14,114.1) 144.14,113.47 143.5,112.83 138.58,112.83 137.91,112.16 136.21,112.16 135.61,111.56 125.66,111.56 123.12,109.02 116.58,109.02 116.26,108.7 v2(116.26,108.32) ; v2(97.1,115.64) 97.4,115.94 105.91,115.94 108.9,112.96 110.93,112.96 111.75,112.13 111.75,110.54 113.53,108.77 v2(113.53,108.32)
  BOTTOM w0.203: UC1.A18 141.82,103.25 v2(142.04,103.47)
  BOTTOM w0.508: RC113.1 113.53,109.92 ; 113.53,109.92 RC181.1 RC179.1 116.26,109.92 ; 113.53,109.92 v2(113.53,108.32) 113.53,108.02 RC184.2 ; 116.26,109.92 v2(116.26,108.32) RC2.1 ; 116.26,109.92 RC14.2
+1.0V_VCCSTU: length 70.4
  TOP w0.508: v2(144.4,112.7) 144.4,111.42 142.78,109.8 142.78,105.57 140.95,103.74 RC140.1 RC143.1 ; CC96.1 v2(176.22,79.61)
  IN1 w0.508: v2(144.4,112.7) 144.84,112.26 156.58,112.26 157.96,110.88 157.96,106.45 163.22,101.18 168.66,101.18 171.1,98.75 171.1,96.65 175.99,91.76 175.99,84.74 176.88,83.85 176.88,80.27 v2(176.22,79.61)
  vias: v1(176.59,78.67)
+1.0V_XDP: length 9.9
  TOP w0.508: RC12.2 156.66,103.5 156.52,103.64 156.52,105.91 v1(155.19,107.24) v2(153.66,108.77)
  BOTTOM w0.508: RC31.1 v2(153.66,108.77)
+1.0VO_DSW: length 2.5
  TOP w0.076: v1(153.26,85.72) 152.68,86.3 v2(152.67,86.3)
  TOP w0.508: CC85.1 152.35,85.97 v2(152.67,86.3)
  BOTTOM w0.152: UC1.AL1 151.89,86.4 152.57,86.4 v2(152.67,86.3)
+1.0VS_DGPU:
  vias: v2(54.81,61.61) v2(55.49,66) v2(55.57,61.61) v2(56.31,61.6) v2(57.11,66.81) v2(57.06,61.6) v2(57.98,67.67) v2(58.82,68.51) v2(60.43,68.46) v2(62.14,69.11) v2(62.84,69.11) v2(67.16,69.3) v2(67.18,68.7) v2(67.86,69.3) v3(74.29,61.14)
+1.0VS_PLLAVDD: length 24.5
  TOP w0.254: v2(62.93,80.93) 62.93,80.77 v1(62.6,80.45)
  TOP w0.508: v2(59.49,75.1) 59.46,75.07 CV55.1 ; v2(62.93,80.93) 62.98,80.98 CV53.1 ; v2(58.76,80.05) 57.97,79.26 CV52.2 ; v2(61.73,69.93) 61.11,70.56 LV4.1 59.63,70.56 CV51.1
  IN3 w0.508: 60.27,79.2 60.27,78.06 59.93,77.72 59.93,76.26 59.49,75.82 v2(59.49,75.1) 59.49,72.36 60.9,70.95 60.9,70.76 v2(61.73,69.93) ; 60.27,79.2 59.06,79.2 58.76,79.5 v2(58.76,80.05) ; 60.27,79.2 61.2,79.2 v2(62.93,80.93)
  BOTTOM w0.254: v2(58.76,80.05) 58.37,79.66 UV1.H22 ; UV1.F16 v2(62.93,80.93) ; v2(59.49,75.1) 58.96,74.57 58.47,74.57 UV1.P22
+1.0VS_VCCIO: length 29
  TOP w0.457: RC1.1 122.7,97.57 v2(122.34,97.22)
  IN1 w0.508: v2(135.27,87.71) 135.25,87.73 135.25,88.57 134.36,89.46 134.36,95.18 133.53,96 129.72,96 129.6,96.13 127.37,96.13 126.87,96.64 126.87,97.53 126.46,97.93 122.7,97.93 122.34,97.58 v2(122.34,97.22)
  BOTTOM w0.254: UC1.AK28 135.31,87.71 v2(135.27,87.71) ; UC1.AL42 128.87,86.81 UC1.AM42 v2(127.95,85.96) ; UC1.AL30 v2(135.27,85.96) 135.33,85.96 UC1.AM28 ; UC1.AL30 134.81,86.37 UC1.AM30 134.55,86.35 v2(134.36,86.16) ; UC1.AL30 v2(135.27,87.71) ; v2(135.27,87.71) 135.23,87.71 UC1.AK30
  vias: v2(168.14,55.11) v2(168.14,54.47) v2(168.65,55.43) v2(168.65,54.79) v2(168.59,54.09) v2(169.09,54.41) v2(169.09,53.78) v3(167.44,51.17)
+1.0VS_VCCSTG: length 192.1
  TOP w0.254: v2(138.88,100.16) 138.84,100.2 CC56.1
  TOP w0.508: CC89.1 165.3,41.33 RC188.2 165.28,38.98 v1(166.01,38.25) 166.87,37.39 171.36,37.39 172.19,36.57 176.62,36.57 v2(177.79,35.39)
  IN1 w0.508: v2(177.79,35.39) 178.11,35.71 179.86,35.71 184.73,40.57 184.73,50.94 186.47,52.68 186.47,56.8 186.59,56.92 186.59,60.03 186.02,60.6 186.02,65.65 185.58,66.09 185.58,76.51 176.85,85.24 176.85,92.12 172.01,96.96 172.01,99.08 169.04,102.05 163.65,102.05 159.48,106.21 159.48,110.25 156.84,112.89 152.77,112.89 151.44,114.23 149.15,114.23 147.82,112.89 145.12,112.89 144.68,113.34 144.07,113.34 143.56,112.83 139.11,112.83 v2(138.24,113.7)
  IN3 w0.381: v2(138.88,100.16) 139.56,99.49 140.02,99.49 140.66,98.84 v2(140.75,98.84)
  IN3 w0.508: v2(121.09,111.25) 122.04,112.2 135.34,112.2 135.94,112.8 137.34,112.8 v2(138.24,113.7)
  BOTTOM w0.127: 138.32,100.6 138.32,100.75 138.42,100.85 138.42,101.13 138.32,101.23 138.32,101.41 138.42,101.51 138.42,101.76 138.34,101.84 ; 137.89,100.57 137.89,100.75 137.73,100.9 137.73,101.05 137.86,101.18 137.86,101.43 137.76,101.54 137.76,101.74 137.89,101.87 ; 138.35,102.29 138.85,102.29
  BOTTOM w0.203: UC1.A22 139.34,102.49 138.83,103.01 138.47,103.01 138.14,102.68
  BOTTOM w0.254: v2(140.75,98.84) UC1.G20
  BOTTOM w0.508: RC3.1 110.74,108.14 111.32,107.56 111.82,107.56 112.13,107.88 112.13,110.48 112.52,110.86 118.21,110.86 118.6,110.47 118.6,109.92 ; RC11.2 119.42,107.64 118.6,108.46 118.6,109.92 ; 118.6,109.92 RC13.2 RC15.2 121.15,111.18 v2(121.09,111.25) ; 137.98,103.5 137.98,104.19 137.38,104.79 137.38,106.21 136.87,106.72 136.87,108.92 138.24,110.28 v2(138.24,113.7)
+1.0VS_VCCSTG_IO:
  vias: v1(163.32,43.93)
+1.8V_PG: length 127.2
  IN2 w0.254: v2(84.82,26.16) 84.82,26.59 85.65,27.42 87.05,27.42 88.96,29.33 98.16,29.33 105.3,22.19 124.67,22.19 127.18,19.68 128.01,19.68 131.95,15.74 133.98,15.74 v2(134.71,16.47)
  BOTTOM w0.254: v2(84.82,26.16) 84.83,26.17 PU501.5 ; v2(134.71,16.47) 135.53,16.47 136.33,17.26 136.33,17.77 137.85,19.3 152.9,19.3 154.11,20.5 v1(159.82,20.5) 164.84,20.5 165.54,21.2 171.51,21.2 175,24.69 175,26.98 177.48,29.46 177.48,34.28 179.51,36.31 179.95,36.31 180.9,37.27 182.56,37.27 184.21,38.92 184.21,43.36 183.83,43.74 PR312.2
+1.8V_PRIM: length 163.2
  TOP w1.016: 158.32,90.31 163.38,90.31
  IN1 w1.016: 182.37,71.05 182.37,69.97 179.51,67.11 179.51,59.55 177.79,57.84 177.79,56.32
  IN3 w1.016: 181.31,72.38 181.31,75.58 178.41,78.48 176.08,78.48 174.49,80.06 174.49,81.84 167,89.34 165.75,89.34 165.37,89.72
  BOTTOM w0.203: UC1.AA1 152.41,91.81 v2(152.65,91.57)
  BOTTOM w0.254: UC1.AF16 v2(143.66,90.05)
  BOTTOM w1.016: 85.85,35.11 85.85,36.38 89.21,39.74 89.21,49.71 91.94,52.44 91.94,57.49 92.99,58.54 99.24,58.54 100.7,57.08 156.58,57.08 158.76,59.25 162.6,59.25 163.32,58.53 167,58.53 170.95,54.59 176.45,54.59 176.97,55.11
  vias: v2(164.27,90.54) v2(164.85,90.48) v2(177.79,55.43) v2(177.79,54.79) v2(182.37,72.57) v2(182.37,71.94) v3(155.76,89.72)
+1.8V_PRIM_VS:
  vias: v1(181.79,74.16)
+1.8VALWP: length 8.3
  BOTTOM w0.254: PR501.1 81.79,26.06 PC503.1 80.67,26.06 79.81,26.92 v1(79.81,28.76) 79.81,29.01 80.32,29.52 80.59,29.52 80.78,29.71 82.1,29.71 82.42,30.03
+1.8VS: length 99.5
  TOP w0.508: v2(164.39,57.23) 164.41,57.22 RC177.1
  IN1 w0.508: v2(185.42,55.43) 185.67,55.67 185.67,59.07 185.16,59.58 185.16,64.23 184.06,65.33 184.06,75 v2(180.59,78.48)
  IN2 w0.508: v2(164.39,57.23) 164.39,57.84 164.9,58.35 166.49,58.35 167.25,57.59 170.23,57.59 170.67,58.03 177.92,58.03 180.52,55.43 v2(185.42,55.43)
  IN3 w0.508: v2(193.6,55.43) 191.89,53.71 191.89,45.74 193.8,43.84 193.8,35.74 195.32,34.22 195.32,28.38 197.67,26.03 197.67,25.84 198.37,25.14 199.57,25.14 200.65,24.06 201.99,24.06 204.15,21.9 v4(204.4,21.9)
  BOTTOM w0.508: v4(204.4,21.9) 203.84,21.9 RA8.1 ; v2(193.6,55.43) v2(185.42,55.43)
  vias: v3(179.83,78.92)
+1.8VS_3VS_PGPPA: length 26.1
  TOP w0.508: RC177.2 RC178.2 162.63,56.93 v2(163.12,57.42) 163.42,57.71 163.95,57.71 164.51,58.27 RC225.2 ; RC122.2 RC107.2 156.48,69.23 155.86,68.61 v2(155.44,68.61)
  IN2 w0.508: v2(155.44,68.61) 155.44,68.06 156.46,67.05 156.46,65.08 157.16,64.38 159.57,64.38 160.71,63.24 162.17,63.24 162.49,62.92 162.49,61.44 160.52,59.47 160.52,57.72 160.96,57.28 162.99,57.28 v2(163.12,57.42)
+1.35V_VCCSFR_OC: length 2.3
  TOP w0.254: RC141.2 CC49.1 138.69,87.23 v2(138.93,87.46)
  BOTTOM w0.203: v2(138.93,87.46) UC1.AL23
+1.35V_VDDQ: length 55.3
  TOP w0.381: UC7.5 157.52,60.24 157.94,60.66 CC57.1
  TOP w0.508: v2(157.28,61.4) 157.6,61.08 CC57.1
  BOTTOM w0.127: UC1.BB41 v2(129.32,78.6)
  BOTTOM w0.178: UC1.BB23 139.27,80.37 139.27,79.21 v2(139.45,79.04) ; UC1.BB51 123.2,79.42 v2(123.22,79.41) ; UC1.BB47 125.67,80.31 125.67,79.49 v2(125.59,79.41) ; v2(134.28,79.42) 134.28,80.38 UC1.BB32
  BOTTOM w0.203: v2(135.19,83.46) 135.55,83.1 UC1.AU28 ; v2(137.98,83.38) 138.26,83.1 UC1.AU23
  BOTTOM w0.254: UC1.AU42 128.61,83.1 v2(128.88,83.37) ; UC1.AU35 131.61,83.4 v2(131.63,83.39)
  BOTTOM w0.356: v4(146.82,36.45) 147.55,35.73 JDIMM2.123 ; 135.15,49.18 JDIMM1.123 ; v4(144.86,36.13) 144.4,36.13 143.95,35.68 JDIMM2.111 ; 142.49,25.39 142.45,25.43 JDIMM2.106 ; 140.65,25.2 140.65,25.21 JDIMM2.100 ; JDIMM1.118 133.64,39.51 v2(133.64,40.91) ; v2(137.98,25.06) 137.5,25.06 137.05,25.51 JDIMM2.88 ; JDIMM2.82 v2(135.25,25.07) ; JDIMM1.106 130.05,40.9 v2(129.66,41.29) ; JDIMM2.81 134.95,36.08 v4(134.83,36.2) ; v2(144.25,25.08) JDIMM2.112 ; JDIMM2.87 136.75,35.98 v4(136.61,36.12) ; JDIMM2.117 145.75,35.73 ; v2(131.26,42.43) 131.85,41.84 JDIMM1.112 ; JDIMM2.93 138.55,36.16 ; JDIMM2.105 v4(142.15,36.19)
  BOTTOM w0.508: v2(140.07,63.47) 140.07,63.47 147.78,63.47 149.85,61.4 v2(157.28,61.4)
  vias: v1(135.44,55.05) v2(99.43,33.07) v2(99.56,33.65) v2(99.88,32.63) v2(100.01,33.2) v2(100.13,33.77) v2(100.32,32.19) v2(100.45,32.76) v2(100.58,33.33) v2(100.7,33.96) v2(100.77,31.74) v2(100.89,32.31) v2(101.02,32.88) v2(101.15,33.52) v2(101.21,31.3) v2(101.34,31.87) v2(101.47,32.44) v2(101.59,33.07) v2(101.66,30.85) v2(101.78,31.42) v2(101.91,32) v2(102.04,32.63) v2(102.1,30.41) v2(102.23,30.98) v2(102.36,31.55) v2(102.48,32.19) v2(102.55,29.96) v2(102.67,30.53) v2(102.8,31.11) v2(102.93,31.74) v2(103.12,30.09) v2(103.24,30.66) v2(120.11,49.14) v2(121.74,46) v2(121.93,38.05) v2(123.63,38.14) v2(125.72,49.65) v2(126.04,49.06) v2(126.21,38.01) v2(129.39,38.1) v2(131.25,50.61) v2(131.25,49.09) v2(133.27,49.07) v2(133.69,24.99) v2(142.01,25.06) v2(146.04,25.14) v2(148.14,25.01) v4(140.04,36.51)
