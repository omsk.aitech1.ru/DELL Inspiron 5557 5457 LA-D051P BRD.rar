# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
SIO_PWRBTN#_R: length 29.3
  TOP w0.102: RC109.1 161.35,66.81 v2(161.35,66.69)
  BOTTOM w0.076: UC1.BA15 143.29,80.37 143.29,78.66 144.28,77.67 144.28,77.14
  BOTTOM w0.102: v2(161.35,66.69) v1(160.82,67.22) 160.52,67.52 160.52,69.14 159.31,70.35 158.2,70.35 157.98,70.56 154.81,70.56 154.59,70.35 151.32,70.35 150.43,71.24 147.25,71.24 146.11,72.38 146.11,75.05 144.28,76.88 144.28,77.14
SIO_RCIN#: length 121.6
  TOP w0.102: UE5.53 137,16.59 v2(137.15,16.44) ; v1(166.49,58.54) RC225.1 165.42,57.86 v2(165,57.44)
  IN3 w0.102: v2(137.15,16.44) 137.37,16.65 138.45,16.65 140.04,18.24 141.19,18.24 141.82,18.88 146.9,18.88 150.33,22.31 171.79,22.31 172.9,23.42 172.9,27.05 172.55,27.4 172.55,35.72 169.97,38.3 169.97,43.66 169.47,44.15 169.47,49.91 165.47,53.92 165.47,56.98 v2(165,57.44) 164.73,57.71 164.2,57.71 163.4,58.51 163.4,61.83 162.79,62.45 162.79,63.76 161.89,64.66 160.71,64.66 160.14,65.23 160.14,67.11 160.23,67.2 160.23,69.1 158.53,70.79 v2(158.58,70.79)
  BOTTOM w0.076: 145.52,77.14 145.52,78.24 144.47,79.29 144.47,79.62 144.35,79.75 144.35,80.13 144.36,80.15 144.4,80.24 144.4,80.36 144.33,80.58 144.33,80.72 144.39,80.88 144.39,80.96 144.61,81.66 144.61,81.66 144.78,81.84 UC1.AW13
  BOTTOM w0.102: v2(158.58,70.79) 155.06,70.79 154.59,71.26 154.2,71.26 153.79,70.86 152.77,70.86 152.05,71.58 151.16,71.58 150.99,71.75 147.88,71.75 146.63,73 146.63,75.76 145.52,76.88 145.52,77.14
SIO_SLP_A#: length 1.2
  TOP w0.076: T93.1 142.86,85.59 v2(142.58,85.31)
  BOTTOM w0.076: UC1.AN16 v2(142.58,85.31)
SIO_SLP_LAN#: length 4.8
  BOTTOM w0.076: UC1.AW15 143.51,81.79 143.67,81.63 143.67,81.64 143.82,81.3 143.82,79.83 143.66,79.67 143.66,78.75 144.44,77.97 T87.1
SIO_SLP_S0#: length 84.2
  TOP w0.102: UC15.2 172.52,47.93 172.84,47.62 173.22,47.62 173.67,48.06 173.67,50.16 172.97,50.85 172.97,54.22 174.17,55.43 174.17,56.06 173.88,56.35 v1(170.69,56.35) 167.42,56.35 166.97,55.91 166.97,53.94 165.16,52.12 164.2,52.12 v2(163.63,52.7)
  IN1 w0.076: v2(145.33,83.98) 145.3,83.98 144.96,84.32 144.96,86.35 145.36,86.75 147.94,86.75 148.52,86.16 148.52,85.63 148.59,85.56 148.59,82.6 152.14,79.05 153.39,79.05 154.69,77.75 154.87,77.75
  IN1 w0.102: v2(163.63,52.7) 162.21,54.12 162.21,56.16 162.78,56.72 163.32,56.72 163.76,57.16 163.76,57.5 165.09,58.83 165.09,60.42 165.18,60.51 165.18,61.93 165.91,62.65 165.91,65.22 168.92,68.23 168.92,72.52 168.37,73.07 168.37,75.14 167.6,75.91 161.89,75.91 160.05,77.75 154.87,77.75
  BOTTOM w0.076: v2(145.33,83.98) 145.56,83.75 UC1.AT11
SIO_SLP_S3#: length 430
  TOP w0.102: CE87.1 128.58,18.04 128.58,17.01 129.84,15.75 UE5.70 132.13,15.75 133.15,14.72 133.15,13.72 v2(133.34,13.53) 133.61,13.53 134.04,13.96 134.04,16.18 133.53,16.69 133.52,16.69 133.14,17.07 133.03,17.07 132.01,18.09 130.36,18.09 129.53,18.91 129.53,20.06 129.15,20.44 129.15,21.2 129.6,21.64 129.74,21.64 RC130.1 130.89,22.8 130.89,23.61 130.48,24.02 DC6.1 ; UC15.1 171.84,47.28 171.57,47.55 171.57,48.7 171.95,49.08 172.6,49.08 RZ75.1 172.71,50.11 172.71,54.98 173.42,55.69 v2(173.72,55.69) ; v2(36.56,110.1) 36.56,109.15 36.25,108.84 v1(36.25,108.58) PR2.1 35.74,106.75 35.74,106.23 35.49,105.97 PQ1.2 ; RC194.1 178.62,71.79 v2(178.85,71.56) ; R2318.1 174.31,9.26 173.02,9.26 R2313.1 172.14,8.63 171.13,7.61 167.38,7.61 167,7.23 163.19,7.23 162.55,7.87 v2(162.55,12.63)
  IN1 w0.102: v2(133.34,13.53) 133.34,13.4 134.71,12.03 140.8,12.03 141.79,13.02 148.09,13.02 148.95,13.89 152.91,13.89 154.42,12.37 162.3,12.37 v2(162.55,12.63) ; v2(36.56,110.1) 36.87,109.78 37.46,109.78 40.26,112.58 70.12,112.58 72.78,109.92 72.78,109.24 73.02,109 74.01,109 74.22,109.21 v2(74.86,109.21) 74.99,109.08 76.72,109.08 77.51,109.87 87.3,109.87 88.08,110.65 93.18,110.65 94.17,109.65 97.56,109.65 99.22,111.32 101.86,111.32 103.12,112.58 v2(103.18,112.58) 103.5,112.58 105.02,111.05 110,111.05 110.19,111.24 120.51,111.24 120.92,111.65 121.61,111.65 122.45,112.49 136.68,112.49 137.01,112.17 143.72,112.17 144.28,111.6 150.33,111.6 152.27,109.66 152.27,107.24 153.85,105.66 158.14,105.66 163.04,100.75 166.36,100.75 175.56,91.56 175.56,84.56 175.79,84.33 175.79,79.43 177.7,77.52 179.03,77.52 179.63,76.92 179.63,72.34 v2(178.85,71.56) 178.4,71.11 178.4,59.97 176.61,58.18 176.06,58.18 173.72,55.84 v2(173.72,55.69)
  IN3 w0.076: 151.89,77.14 151.38,77.65 151.12,77.65 149.52,79.26 149.52,86.13 149.23,86.41 145.09,86.41 144.92,86.24 144.16,86.24 143.95,86.03 143.95,84.95 143.68,84.69 v2(143.5,84.69)
  IN3 w0.102: 173.71,55.69 173.71,52.39 172.62,51.3 172.62,39.45 176.56,35.51 176.56,24.53 178.22,22.88 178.22,19.88 180.36,17.74 180.36,11.39 176.17,7.2 164.04,7.2 163.19,8.06 163.19,11.99 v2(162.55,12.63) ; 173.71,55.69 172.82,54.8 170.55,54.8 168.74,56.61 167.1,56.61 164.66,59.05 164.45,59.05 164.15,59.34 164.15,59.64 164.45,59.93 164.45,60.27 164.13,60.59 164.13,61.76 163.25,62.64 163.25,63.95 162.55,64.64 162.55,65.4 162.17,65.78 160.97,65.78 160.46,66.29 160.46,69.6 158.33,71.73 158.33,72.55 154.2,76.67 152.36,76.67 151.89,77.14 ; 173.71,55.69 v2(173.72,55.69)
  BOTTOM w0.076: v2(143.5,84.69) 143.94,85.05 UC1.AP15
  BOTTOM w0.102: v2(74.86,109.21) 76.07,108 76.07,104.39 77.59,102.86 77.59,98.61 77.78,98.42 PR682.1
  BOTTOM w0.254: v2(103.18,112.58) 103.24,112.51 103.24,112.02 PR658.1
SIO_SLP_S4#: length 191.1
  TOP w0.102: RC144.1 159.76,68 v2(159.82,68.06) ; v2(132.35,16.76) 132.16,16.95 UE5.67
  IN1 w0.102: v2(80.45,13.14) 80.52,13.14 81.69,11.96 81.69,8.78 82.54,7.94 101.28,7.94 103.71,10.37 103.71,19.39 v2(103.7,19.4)
  IN3 w0.102: v2(159.82,68.06) 159.82,65.22 160.61,64.43 161.79,64.43 162.56,63.66 162.56,62.35 163.18,61.74 163.18,58.42 163.99,57.61 163.99,56.99 165.24,55.74 165.24,53.82 169.24,49.82 169.24,44.06 169.74,43.57 169.74,38.21 171.1,36.84 171.1,35 172.05,34.05 172.05,24.79 169.79,22.53 150.23,22.53 146.81,19.1 141.73,19.1 141.09,18.47 139.95,18.47 138.36,16.88 132.48,16.88 v2(132.35,16.76) 130.66,16.76 129.69,17.73 129.33,17.73 129.16,17.55 128.82,17.55 128.11,18.27 124.06,18.27 123.28,17.49 110.76,17.49 110.17,18.09 104.44,18.09 103.7,18.83 v2(103.7,19.4)
  BOTTOM w0.076: 143.6,77.86 142.96,78.49 142.96,80.93 UC1.BA16
  BOTTOM w0.102: v2(159.82,68.06) 159.82,68.95 159.3,69.47 157.37,69.47 157.14,69.24 152.88,69.24 152.51,68.88 150.67,68.88 149.49,70.05 145.52,70.05 144.14,71.43 v1(144.14,75.11) 143.72,75.53 143.72,77.73 143.6,77.86
  BOTTOM w0.254: PR201.1 v2(80.45,13.14)
SIO_SLP_S5#: length 243.8
  TOP w0.254: v2(38.98,7.67) 38.6,8.06 38.6,9.71 39.24,10.34 39.24,13.52 39.68,13.96 39.68,16.06 38.98,16.76 33.9,16.76 33.53,16.39 PQ711.2
  IN1 w0.102: v2(129.63,21.07) 129.63,21.01 131.46,19.18 138.82,19.18 139,19.35 146.4,19.35 148.53,21.48 157.93,21.48 160.6,24.15 161.51,24.15 162.72,25.36 162.72,35.45 163.4,36.13 163.4,44.51 162.93,44.97 162.93,50.06 160.22,52.77 160.22,59.37 162.07,61.21 162.07,65.28 v2(161.98,65.37) ; v2(113.67,5.09) 113.26,5.5 107.07,5.5 105.73,6.84 63.25,6.84 57.52,12.56 52.83,12.56 47.24,6.98 39.68,6.98 v2(38.98,7.67)
  BOTTOM w0.076: UC1.AY16 142.93,81.42 142.63,81.12 142.63,80.69 142.79,80.53 142.79,78.37 143.39,77.78 143.39,77.14
  BOTTOM w0.102: 143.39,77.14 143.39,75.23 143.88,74.73 143.88,71.3 145.54,69.65 149.42,69.65 150.43,68.65 152.6,68.65 152.97,69.02 157.26,69.02 157.49,69.24 159.15,69.24 159.57,68.83 159.57,68.44 159.38,68.25 159.38,66.86 160.23,66.01 160.91,66.01 161.05,65.86 161.49,65.86 v2(161.98,65.37) ; v2(129.63,21.07) 129.56,21.15 127.63,21.15 127.17,21.61 125.75,21.61 124.94,20.79 124.69,20.79 124.46,20.57 113.91,20.57 113.47,21.01 113.02,21.01 112.73,20.72 112.73,13.36 v1(113.31,12.79) 113.85,12.25 113.85,5.27 v2(113.67,5.09)
SIO_SLP_SUS#: length 275.5
  TOP w0.102: v2(178.62,98.54) 178.31,98.24 RC174.1 ; v2(136.61,10.74) 136.61,8.52 133.98,5.9 132.64,5.9 132.1,5.35 UE5.96 130.19,5.35 129.98,5.13 v2(129.98,4.82) ; RC128.2 155.44,62.46 v2(155.44,62.03)
  TOP w0.254: v2(188.04,63.07) 187.15,63.07 185.41,61.33 v1(185.41,60.63) 185.41,59.11 185.98,58.54 185.98,54.94 v2(185.86,54.82)
  IN1 w0.102: v2(178.62,98.54) 178.62,86.92 188.59,76.95 188.59,75.75 188.27,75.43 187.89,75.43 187.65,75.19 187.65,73.96 188.04,73.56 v2(188.04,63.07) 188.41,62.7 188.41,60.49 189.65,59.25 189.65,42.7 189.21,42.26 189.21,39.03 186.4,36.22 186.4,30.51 185.48,29.58 185.48,25.26 179.8,19.59 176.72,19.59 174.32,17.19 169.67,17.19 165.69,13.21 165.69,12.28 163.61,10.2 152.92,10.2 151.22,11.9 148.81,11.9 147.87,10.96 136.83,10.96 v2(136.61,10.74)
  IN3 w0.102: v2(129.98,4.82) 129.72,4.82 129.5,4.59 124.05,4.59 123.27,3.81 119.51,3.81 117.82,5.5 111.19,5.5 109.21,7.48 109.21,7.93 108.01,9.14 108.01,12.12 107.5,12.63 105.28,12.63 104.39,13.52 104.39,16.82 89.85,31.36 83.62,31.36 81.4,29.14 v2(81.02,29.14)
  BOTTOM w0.102: v2(155.44,62.03) 155.82,62.41 156.9,62.41 157.09,62.6 159.51,62.6 160.08,62.03 160.08,61.65 160.45,61.27 161.1,61.27 161.25,61.43 161.25,61.64 161.5,61.89 164.2,61.89 164.45,62.14 167.97,62.14 168.19,61.92 183.21,61.92 184.36,63.07 v2(188.04,63.07)
  BOTTOM w0.254: v2(185.86,54.82) 186.37,54.31 186.37,51.11 187.13,50.35 187.13,45.33 186.43,44.63 PR313.1 ; PR504.1 v2(81.02,29.14)
SIO_SLP_SUS#_R: length 28.7
  TOP w0.102: RC128.1 155.81,64.25 v2(155.81,64.76)
  IN3 w0.102: v2(155.81,64.76) 155.63,64.76 152.93,67.47 152.93,69.04 147.88,74.09 147.88,77.59 144.58,80.89 144.58,82.35 143,83.94 143,84.8 v2(143.52,85.33)
  BOTTOM w0.076: UC1.AN15 143.86,85.61 143.58,85.33 v2(143.52,85.33)
  BOTTOM w0.102: v2(155.81,64.76) v1(156.2,65.15)
SIO_SLP_WLAN#: length 2
  BOTTOM w0.102: UC1.BB17 142.36,77.97 T88.1
SKL_CNL#: length 7.4
  BOTTOM w0.076: 113.29,105.34 113.29,104.63 113.5,104.42 114.18,104.42 114.45,104.15 114.97,104.15 115.66,103.46 115.66,101.96 115.8,101.82 UC1.C64
  BOTTOM w0.102: 113.29,105.34 113.29,106.6 113.42,106.72 RC184.1
SLEEVE: length 16.6
  IN3 w1.016: 193.16,19.42 193.16,20.44 194.96,22.24 194.96,23.85 194.24,24.57 194.24,27.87 191.83,30.28 191.83,31.3 190.87,32.25
  BOTTOM w0.203: v2(192.27,19.04) 192.52,19.29 UA1.18
  vias: v1(190.43,32.44) v2(189.92,32.69) v2(189.92,32.11) v2(191.76,18.72)
SM_RCOMP0: length 10.6
  TOP w0.254: RC38.1 v1(140.39,75.49) 140.39,81.26 140.68,82.61 140.94,83.21 141.26,83.64 141.48,83.86 141.67,84.02 v2(141.67,84.04)
  BOTTOM w0.254: v2(141.67,84.04) 142.03,84.4 UC1.AR18
SM_RCOMP1: length 10
  TOP w0.254: RC39.1 141.28,75.49 140.86,75.91 v1(140.86,78.35) 140.86,81.67 141.06,82.51 141.28,83.02 141.48,83.23 v2(141.67,83.4)
  BOTTOM w0.254: UC1.AT18 141.78,83.4 v2(141.67,83.4)
SM_RCOMP2: length 9.4
  TOP w0.254: RC40.1 142.17,75.37 141.34,76.19 v1(141.34,76.7) 141.34,77.87 141.2,79.26 141.2,81.52 141.36,82.12 v2(141.67,82.77)
  BOTTOM w0.254: v2(141.67,82.77) 142,83.1 UC1.AU18
SMB_ALERT#: length 9.6
  TOP w0.076: v2(147.31,94.16) 147.82,94.67 149.92,94.67 150.23,94.35 151.25,94.35 151.63,93.97 153.92,93.97 v1(154.39,93.5) 154.68,93.21 154.87,93.21
  TOP w0.102: RC229.2 154.87,93.21
  BOTTOM w0.076: v2(147.31,94.16) 147.24,94.16 UC1.R10
SMBCLK: length 19.6
  TOP w0.076: v2(149.03,94.23) 148.85,94.05 148.85,93.86 148.93,93.78 150.49,93.78 150.81,93.46 151.2,93.46 151.38,93.64 RPC18.1
  IN3 w0.076: v2(149.03,94.23) 148.81,94.01 148.81,93.93 148.89,93.85 150.51,93.85 150.64,93.72 153.5,93.72 153.64,93.85 154.84,93.85 154.85,93.87 154.87,93.87
  IN3 w0.102: 154.87,93.87 158.47,93.87 159.88,92.45 160.46,92.45 161.28,91.62 161.35,91.62 v2(161.54,91.81)
  BOTTOM w0.076: v2(149.03,94.23) 148.72,94.53 UC1.R7
  BOTTOM w0.102: QC2.6 161.08,91.35 v2(161.54,91.81)
SMBDATA: length 20.6
  TOP w0.076: RPC18.2 151.31,93.14 151.19,93.26 150.72,93.26 150.4,93.58 148.85,93.58 148.65,93.77 148.65,93.97 v2(148.39,94.23)
  IN3 w0.076: v2(148.39,94.23) 148.61,94.01 148.61,93.84 148.8,93.65 150.42,93.65 150.56,93.51 153.59,93.51 153.72,93.65 154.85,93.65 154.86,93.64 154.87,93.64
  IN3 w0.102: v2(162.17,91.81) 161.75,91.39 161.19,91.39 160.36,92.22 159.79,92.22 158.37,93.64 154.87,93.64
  BOTTOM w0.076: UC1.R8 148.07,94.55 v2(148.39,94.23)
  BOTTOM w0.102: QC2.3 162.38,92.02 v2(162.17,91.81)
SML0_ALERT#: length 9.3
  BOTTOM w0.076: UC1.W1 152.27,92.64 152.77,92.64 153.03,92.89 v1(153.5,92.89) 153.98,92.89 154.87,93.78 154.87,94.8
  BOTTOM w0.102: RC202.2 158.93,95.44 155.52,95.44 154.87,94.8
SML0_SMBCLK: length 11.6
  BOTTOM w0.076: UC1.R9 147.72,94.34 147.72,94.33 148.2,93.85 149.66,93.85 150.17,93.34 150.17,92.89 150.48,92.58 150.48,92.39 150.75,92.13 151.78,92.13 151.96,92.04 152.31,92.04 152.53,92.26 154.05,92.26 154.87,93.08
  BOTTOM w0.102: RC49.1 155.75,94.42 155.51,94.42 155.38,94.28 155.38,93.59 154.87,93.08
SML0_SMBDATA: length 6.3
  BOTTOM w0.076: 154.5,93.03 154.49,93.02 154.49,93 153.95,92.47 152.5,92.47 152.24,92.21 151.99,92.21 151.82,92.29 151.63,92.29 UC1.W2
  BOTTOM w0.102: 154.5,93.03 155.15,93.69 v4(155.15,94.09) 155.15,94.38 155.42,94.64 155.72,94.64 RC50.1
SML1_ALERT#: length 22.4
  TOP w0.102: v2(152.01,70.98) 151.83,71.16 RC221.2
  IN1 w0.076: v2(148.08,85.97) 147.76,85.97 147.38,86.35 145.98,86.35 145.71,86.08 145.71,80.59 148.77,77.52 148.77,77.14
  IN1 w0.102: v2(152.01,70.98) 152.01,71.24 151.06,72.19 151.06,73.97 148.77,76.25 148.77,77.14
  BOTTOM w0.076: v2(148.08,85.97) 148.46,86.35 UC1.AM7
  BOTTOM w0.102: v2(152.01,70.98) 151.76,71.24 v1(151.57,71.24)
SML1CLK: length 17.9
  IN1 w0.076: v2(154.74,95.62) 154.74,95.56 154.64,95.45 154.64,95.35 154.74,95.24 154.87,95.24
  IN1 w0.102: 154.87,95.24 155.89,95.24 156.11,95.47 158.49,95.47 159.89,96.87 v2(159.89,97.21)
  BOTTOM w0.076: 153.12,93.49 153.1,93.48 153.08,93.48 152.41,92.8 152.16,92.8 151.87,92.68 151.74,92.68 151.51,92.75 151.51,92.75 151.37,92.75 151.16,92.67 151,92.67 UC1.W3
  BOTTOM w0.102: QC3.4 159.81,98.04 v1(158.74,98.04) 158.74,97.16 RC399.1 159.71,97.03 v2(159.89,97.21) ; RPC7.1 155.59,96.33 155.46,96.47 155.08,96.47 154.55,95.94 154.55,95.81 v2(154.74,95.62) 154.55,95.43 154.55,94.48 153.56,93.49 153.12,93.49
SML1DATA: length 19.6
  TOP w0.102: v2(160.33,96.83) v1(160.97,96.83)
  IN1 w0.076: 154.87,94.99 154.74,94.99 154.43,95.3 154.43,95.39 154.2,95.62 v2(154.16,95.62)
  IN1 w0.102: v2(160.33,96.83) 160.17,96.83 158.58,95.24 156.33,95.24 156.08,94.99 154.87,94.99
  BOTTOM w0.076: UC1.V3 150.75,92.87 151.21,92.87 151.34,92.91 151.53,92.91 151.56,92.91 151.76,92.85 151.83,92.85 151.84,92.85 152.12,92.97 152.29,92.97 152.94,93.62 152.94,93.64 152.95,93.65
  BOTTOM w0.102: 152.95,93.65 153.08,93.78 153.53,93.78 154.32,94.57 154.32,95.46 v2(154.16,95.62) 154.32,95.79 154.32,96.04 154.99,96.7 155.46,96.7 155.59,96.83 RPC7.2 ; QC3.1 161.43,95.81 161.87,95.81 RC397.1 161.46,96.83 v2(160.33,96.83)
SNB_+1VALWP:
  vias: v1(172.71,46.41)
SNUB_1.8VALW: length 1.4
  BOTTOM w0.102: PR502.2 v1(89.21,29.65)
SNUB_VGA1: length 1.6
  TOP w0.102: PR821.1 v1(61.27,51.11)
SNUB_VGA2: length 1.7
  TOP w0.102: PR822.1 v1(61.27,41.58)
SOC_GPIOA7: length 16.4
  TOP w0.102: RC201.1 157.6,72.31 v2(157.6,72.7)
  BOTTOM w0.076: 148.96,77.14 148.09,78.02 147.86,78.02 145.98,79.91 UC1.BB11
  BOTTOM w0.102: 148.96,77.14 150.68,75.43 151.42,75.43 153.81,73.04 155.73,73.04 156.52,72.25 v1(157.16,72.25) v2(157.6,72.7)
SOC_GPIOB16: length 32.9
  TOP w0.102: RC195.1 160.9,60.7 v1(161.3,61.1) 161.66,61.45 v2(161.66,61.47)
  IN3 w0.076: v2(148.97,85.4) 148.61,85.03 148.61,79.4 150.86,77.14
  IN3 w0.102: v2(161.66,61.47) 161.62,61.47 160.12,62.97 160.12,63.95 156.2,67.87 156.2,68.81 156.65,69.25 156.65,70.72 156.2,71.17 156.2,73.08 155.1,74.19 153.82,74.19 150.86,77.14
  BOTTOM w0.076: v2(148.97,85.4) 148.87,85.4 UC1.AP7
SOC_GPIOC10: length 59
  TOP w0.102: v2(165.59,61.74) 165.89,62.03 v1(166.24,62.03) 166.49,62.03 166.69,61.83 RC204.1
  IN1 w0.076: v2(149.73,93.21) 150.42,93.21 151.24,92.4 153.84,92.4 154.21,92.03 154.21,91.05 153.71,90.54 152.58,90.54 151.15,89.1 151.15,86.35 152.27,85.22 153.98,85.22 154.17,85.03 154.87,85.03
  IN1 w0.102: 154.87,85.03 156.73,85.03 157.58,85.88 157.99,85.88 158.92,86.81 165.08,86.81 168.12,83.77 168.12,76.42 168.6,75.95 168.6,73.16 169.14,72.62 169.14,68.13 166.13,65.12 166.13,62.28 v2(165.59,61.74)
  BOTTOM w0.076: UC1.W4 149.73,92.9 v2(149.73,93.21)
SOC_XDP_TDI: length 10.4
  TOP w0.102: v3(120.01,107.75) v2(120.01,108.32)
  BOTTOM w0.076: UC1.D60 118.52,100.99 UC1.D59 119.06,100.99 119.13,101.26 119.13,101.37 119.22,101.65 119.26,101.8 119.27,101.85 119.27,102.1 119.24,102.19 119.24,102.38 119.27,102.48 119.27,103 119.57,103.3 119.57,103.3 119.57,103.59 119.52,103.64 119.52,103.67 119.42,103.77 119.42,104.37 120.01,104.96 120.01,105.34
  BOTTOM w0.102: RC13.1 120.01,108.44 v2(120.01,108.32) 120.01,105.34
SOC_XDP_TDO: length 15.1
  IN3 w0.102: v2(117.85,105.66) 118.29,105.21 121.47,105.21 v2(121.91,105.66)
  BOTTOM w0.076: 121.91,105.34 121.91,105.13 120.6,103.82 120.6,103.31 120.39,103.1 120.39,102.81 UC1.A56 ; UC1.A61 117.61,102.72 117.61,102.99 117.59,103.02 117.59,105.34
  BOTTOM w0.102: RC15.1 121.91,108.25 v2(121.91,105.66) 121.91,105.34 ; v2(117.85,105.66) 117.59,105.4 117.59,105.34
SOC_XDP_TMS: length 8.5
  IN3 w0.076: v2(119.21,103.45) 118.99,103.24 v2(118.13,103.24)
  BOTTOM w0.076: UC1.C59 119.03,101.62 119.11,101.88 119.11,102.05 119.05,102.24 119.05,102.39 119.11,102.51 119.11,103.36 v2(119.21,103.45) 119.24,103.49 119.24,104.89 119.44,105.08 119.44,105.34 ; v2(118.13,103.24) 118.19,103.18 118.19,101.73 UC1.C60
  BOTTOM w0.102: RC11.1 119.44,105.34
SOC_XDP_TRST#: length 11.3
  TOP w0.076: v3(116.45,104.19) 116.82,103.83 v2(117.04,103.83)
  IN3 w0.076: v2(118.58,103.87) 118.54,103.83 v2(117.04,103.83)
  BOTTOM w0.076: 118.58,105.34 v2(118.58,103.87) 118.57,103.87 118.57,103.86 118.66,103.76 118.66,102.87 118.52,102.73 118.52,102.29 UC1.B59 ; UC1.C61 117.33,101.7 117.33,101.76 117.32,101.77 117.32,102.38 117.3,102.44 117.28,102.47 117.28,102.86 117.26,102.88 117.26,103.61 v2(117.04,103.83)
  BOTTOM w0.102: 118.58,105.34 118.58,106.13 118.87,106.42 118.87,107.24 T4956.1
SPK_L1-_CONN:
  vias: v1(205.1,15.42) v2(205.54,15.88) v2(205.67,15.29)
SPK_L2+_CONN:
  vias: v1(203.19,14.22) v2(203.51,14.91) v2(203.92,14.38)
SPK_R1-_CONN:
  vias: v1(210.24,14.85) v2(210.75,15.29) v2(210.75,14.28)
SPK_R2+_CONN:
  vias: v1(208.53,15.23) v2(207.7,15.42) v2(208.24,15.68)
SPKR: length 106
  TOP w0.102: RC117.2 159.57,74.55 159.57,75.2 v2(159.87,75.5) ; DA8.3 188.09,16.23 186.57,17.75 v1(185.18,17.75) 184.94,17.99 v2(184.94,18.21)
  IN3 w0.102: v2(184.94,18.21) 184.56,18.6 184.56,23.84 185.78,25.05 185.78,37.45 187.51,39.18 187.51,47.43 186.76,48.18 186.76,55.15 184.23,57.69 179.3,57.69 178.41,58.58 172.35,58.58 171.95,58.97 168.05,58.97 167.29,59.72 167.29,60.32 167.47,60.51 167.47,65.88 169.6,68.01 169.6,71.56 165.03,76.13 160.49,76.13 v2(159.87,75.5)
  BOTTOM w0.076: UC1.AW5 149.57,81.94 149.73,81.77 149.73,81.4 149.22,80.89 149.22,79.75 151.19,77.78
  BOTTOM w0.102: v2(159.87,75.5) 159.81,75.44 155.5,75.44 154.45,76.49 153.67,76.49 152.38,77.78 151.19,77.78
SRTCRST#: length 19.8
  TOP w0.076: 143.15,81.93 143.15,82.21 142.95,82.4 142.95,83.57 v1(142.15,84.37) 142.15,85.1 141.95,85.31 v2(141.67,85.31)
  TOP w0.102: RC91.2 146.42,71.57 146.42,73.99 CC10.2 145.99,75.1 145.22,75.87 144.58,75.87 v2(144.52,75.94) 144.01,76.45 144.01,78.47 143.15,79.33 143.15,81.93
  BOTTOM w0.076: UC1.AN18 142.06,85.7 v2(141.67,85.31)
  BOTTOM w0.102: v2(144.52,75.94) 145.54,74.92 CLRP1.2
STRAP0: length 7.5
  BOTTOM w0.102: RV47.2 81.44,84.64 80.22,84.64 RV52.1 79.29,85.11 v1(78.71,84.53) 77.18,83 UV1.D1
STRAP1: length 7.9
  BOTTOM w0.102: UV1.D2 75.24,82.66 77.32,82.66 77.84,83.17 v1(78.73,83.17) 78.96,83.17 RV48.1 80.17,84.38 81.71,84.38 RV51.2
STRAP2: length 12.1
  BOTTOM w0.102: RV46.2 81.45,86.87 80.21,86.87 RV50.1 v1(78.8,87.33) 78.18,87.33 76.7,85.85 76.7,85.13 75.72,84.16 74.62,84.16 74.49,84.03 74.49,83.65 74.3,83.46 74.04,83.46 73.75,83.17 73.75,82.6 UV1.E4
STRAP3: length 8.5
  BOTTOM w0.102: UV1.E3 74.45,82.5 75.06,82.5 75.19,82.38 v1(77.59,82.38) 77.93,82.38 78.32,82.76 RV49.1 80.21,83.22 81.45,83.22 RV45.2
STRAP4: length 10
  BOTTOM w0.102: RV61.2 81.39,86.64 80.27,86.64 RV62.1 79.5,85.87 v1(78.8,85.87) 77.93,85.87 77.43,85.36 77.43,84.55 76.27,83.39 74.62,83.39 74.23,83 UV1.D3
STRAPREF0: length 14.9
  TOP w0.102: v2(71.21,80.93) 70.81,81.33 70.81,83.57 v1(71.24,84) 71.84,84.6 72.21,84.6 72.4,84.79 72.4,85.25 73.15,86 75.6,86 79.02,82.57 RV44.1
  BOTTOM w0.102: v2(71.21,80.93) 71.58,81.3 UV1.F6
SUS_STAT#: length 9.8
  TOP w0.102: v1(150.83,75.53) 151.19,75.18 v2(151.19,74.98) RC110.1
  BOTTOM w0.076: UC1.BA11 145.71,80.37 145.71,79.84 147.9,77.65 148.08,77.65 148.58,77.14
  BOTTOM w0.102: v2(151.19,74.98) 150.74,74.98 148.58,77.14
SUSACK#: length 60
  TOP w0.102: v2(162.72,57.9) 162.72,58.53 RC398.2 ; UE5.34 144.6,18.11 v2(144.39,17.9)
  IN1 w0.089: v2(162.72,57.9) 161.41,56.59 161.41,53.22 164.1,50.54 164.1,45.46 164.56,44.99 164.56,35.65 164.49,35.58 164.49,24.98 161.47,21.96 160.05,21.96 158.35,20.26 153.87,20.26 153.52,19.91 148.93,19.91 146.91,17.9 v2(144.39,17.9)
SUSACK#_R: length 37.1
  TOP w0.102: RC398.1 163.65,59.38 v1(163.79,59.52) 164.04,59.77 v2(164.04,60.1)
  IN1 w0.076: 147,81.9 147,82.62 146.63,82.98 146.63,84.38 146.41,84.61 v2(146.24,84.61)
  IN1 w0.102: v2(164.04,60.1) 163.33,60.81 163.33,63.74 163.66,64.07 163.66,65.63 161.04,68.25 161.03,68.25 161.03,70.61 158.4,73.24 156.26,73.24 154.3,75.2 152.19,75.2 147,80.4 147,81.9
  BOTTOM w0.076: v2(146.24,84.61) 145.8,85.05 UC1.AP11
SUSCLK: length 60.9
  TOP w0.102: v2(184.71,67.87) 184.4,67.87 v1(184.14,67.62) 184.02,67.49 184.02,65.57 RM5.2 ; RC105.1 158.87,67.82 158.71,67.99 v2(158.71,68.05)
  BOTTOM w0.076: UC1.BA17 142.36,80.43 142.63,80.17 142.63,78.24 143,77.87 143,77.14
  BOTTOM w0.102: 143,77.14 143,75.25 143.63,74.61 143.63,71.17 145.47,69.33 149.42,69.33 151.17,67.59 158.24,67.59 v2(158.71,68.05) 158.71,67.02 159.95,65.78 160.81,65.78 160.99,65.6 160.99,65.16 161.24,64.92 162.46,64.92 162.68,65.14 163.73,65.14 164.14,64.73 167.99,64.73 170.94,67.68 184.52,67.68 v2(184.71,67.87)
SUSCLK_R: length 2.9
  TOP w0.102: RM5.1 184.71,66.59 v2(184.72,66.6)
  BOTTOM w0.102: JNGFF.42 184.73,66.6 v2(184.72,66.6) v1(184.15,67.18)
SW_+1VALWP: length 7.8
  IN3 w0.508: v2(178.24,47.68) 178.24,51.74 178.68,52.19 179.25,52.19 v2(180.46,53.39)
  BOTTOM w0.508: v2(180.46,53.39) 180.71,53.65 PC304.2
  vias: v1(179.13,47.68)
SYS_PWROK: length 160.7
  TOP w0.076: v2(154.35,104.49) 154.36,104.49 154.55,104.68 v3(154.55,105.27)
  TOP w0.102: UE5.89 133.18,8.15 134.11,9.07 134.11,10.86 134.83,11.58 v2(134.83,12.48)
  IN1 w0.076: v2(154.35,104.49) 154.56,104.49 154.87,104.18
  IN1 w0.089: v2(134.83,12.48) 135.02,12.29 140.74,12.29 141.7,13.24 146.86,13.24 147.73,14.11 153,14.11 154.51,12.6 161.67,12.6 162.08,13 162.4,13 175.13,25.73 175.13,35.68 172.63,38.18 172.63,53.06 173.28,53.71 173.28,55.88 178.18,60.78 178.18,71.61 179.41,72.84 179.41,76.82 178.94,77.3 177.61,77.3 175.56,79.34 175.56,84.24 175.34,84.47 175.34,91.47 166.27,100.53 162.95,100.53 159.48,104 155.05,104 154.87,104.18
  BOTTOM w0.076: v2(154.35,104.49) 154.1,104.49 154.04,104.43 153.83,104.43 153.12,103.72 150.21,103.72 149.9,103.42 149.9,103.17 149.52,102.79 149.52,101.9 UC1.B6
SYS_RESET#: length 99.2
  TOP w0.102: RPC11.4 157.04,63.87 156.2,63.03 156.2,59.36 156.71,58.86 156.71,56.57 157.92,55.36 161.6,55.36 162.34,56.1 164.94,56.1 167.51,58.67 v1(175.06,58.67) 175.82,59.43 v2(175.82,59.43)
  IN1 w0.076: v2(153.37,103.38) 153.96,102.8 154.87,102.8
  IN1 w0.089: v2(175.82,59.43) 175.82,59.43 177.78,61.39 177.78,71.48 177.06,72.2 177.06,77.54 175.35,79.25 175.35,82.02 174.03,83.34 174.03,92.14 166.12,100.05 162.8,100.05 160.05,102.8 154.87,102.8
  BOTTOM w0.076: 154.03,104.09 153.6,103.66 153.6,103.61 v2(153.37,103.38) 152.91,102.92 150.38,102.92 150.16,102.7 150.16,102.32 149.84,102 UC1.B5
  BOTTOM w0.102: CLRP3.1 156.11,105.66 155.26,105.66 154.73,105.12 154.73,104.26 154.57,104.09 154.03,104.09
THM_SML1_CLK: length 9.2
  TOP w0.102: Q2409.4 156.46,17.98 R2459.1 155.8,18.47 R2456.2 154.4,17.07 154.4,15.79 v1(155.17,15.02) 156.1,14.09 156.1,13.65 155.97,13.52 U2407.10
THM_SML1_DATA: length 6.2
  TOP w0.102: U2407.9 156.47,13.52 156.33,13.65 156.33,14.02 R2458.1 v1(158.36,15.04) 158.81,15.49 R2457.2 158.65,16.12 Q2409.1
TMDS_L_TX0N: length 11.6
  BOTTOM w0.089: JHDMI.9 203.38,85.87 203.38,85.98 203.32,86.04 203.02,86.04 202.93,85.96 202.93,80.37 202.33,79.77 200.43,79.77 RX39.1 199.97,79.35 199.61,79.71 198.85,79.71 RX38.2
TMDS_L_TX0P: length 11.7
  BOTTOM w0.089: JHDMI.7 203.38,86.53 203.38,86.31 203.29,86.22 202.94,86.22 202.75,86.03 202.75,80.45 202.25,79.95 200.34,79.95 RX39.2 199.65,79.89 198.87,79.89 RX40.2
TMDS_L_TX1N: length 4.4
  BOTTOM w0.089: JHDMI.6 201.59,87.61 201.5,87.61 200.76,86.86 200.48,86.86 RX42.1 199.72,86.83 198.92,86.83 RX41.2
TMDS_L_TX1P: length 4.3
  BOTTOM w0.089: JHDMI.4 201.59,87.79 201.43,87.79 200.68,87.04 200.42,87.04 RX42.2 199.71,87.01 198.93,87.01 RX43.2
TMDS_L_TX2N: length 6.3
  BOTTOM w0.089: RX44.2 198.73,90.19 199.53,90.19 RX45.1 200.26,90.2 201.83,90.2 202.88,89.15 203.23,89.15 203.32,89.06 203.32,88.93 JHDMI.3
TMDS_L_TX2P: length 6.3
  BOTTOM w0.089: JHDMI.1 203.32,89.47 203.32,89.39 203.26,89.33 202.95,89.33 201.9,90.38 200.26,90.38 RX45.2 199.52,90.38 198.74,90.38 RX46.2
TMDS_L_TXCN: length 5.1
  BOTTOM w0.089: JHDMI.12 201.59,84.61 201.2,84.61 200.84,84.26 200.84,83.56 200.59,83.3 200.41,83.3 RX36.1 199.65,83.28 198.84,83.28 198.67,83.12 198.67,83.09 RX35.2
TMDS_L_TXCP: length 5.1
  BOTTOM w0.089: JHDMI.10 201.59,84.79 201.12,84.79 200.66,84.33 200.66,83.63 200.51,83.49 200.35,83.49 RX36.2 199.66,83.46 198.83,83.46 198.67,83.62 198.67,83.64 RX37.2
TMDS_TX0N: length 6.1
  TOP w0.089: v2(196.34,79.54) 196.54,79.75 196.98,79.75 197.28,80.05 v4(197.28,80.51) 197.28,80.94 196.88,81.34 RP59.2
  BOTTOM w0.089: RX38.1 197.22,79.74 196.53,79.74 v2(196.34,79.54) 196.01,79.87 195.84,79.87 CX14.1
TMDS_TX0P: length 5.5
  TOP w0.089: v2(196.34,80.13) 196.53,79.94 196.91,79.94 197.07,80.1 197.07,80.89 196.8,81.15 196.48,81.15 196.16,80.84 RP59.1
  BOTTOM w0.089: CX15.1 195.9,80.06 196.27,80.06 v2(196.34,80.13) 196.54,79.93 197.26,79.93 RX40.1
TMDS_TX1N: length 6.5
  TOP w0.089: v2(196.27,86.67) 196.46,86.86 196.78,86.86 197.22,87.3 v4(197.22,87.75) 197.22,88.14 196.95,88.41 195.89,88.41 195.85,88.45 RP58.2
  BOTTOM w0.089: CX16.1 195.83,86.86 196.08,86.86 v2(196.27,86.67) 196.45,86.85 197.29,86.85 RX41.1
TMDS_TX1P: length 6
  TOP w0.089: RP58.1 195.74,87.95 196.02,88.23 196.87,88.23 197.01,88.09 197.01,87.35 196.7,87.04 196.48,87.04 196.43,87.09 v2(196.27,87.25)
  BOTTOM w0.089: RX43.1 197.32,87.03 196.49,87.03 v2(196.27,87.25) 196.07,87.05 195.79,87.05 CX17.1
TMDS_TX2N: length 5.4
  TOP w0.089: v2(196.21,90.09) 196.41,90.29 196.58,90.29 196.78,90.08 196.78,89.35 196.5,89.07 196.12,89.07 195.73,89.45 RP58.4
  BOTTOM w0.089: CX18.1 195.98,90.22 196.07,90.22 v2(196.21,90.09) 196.38,90.26 197.05,90.26 RX44.1
TMDS_TX2P: length 5.8
  TOP w0.089: v2(196.21,90.67) 196.4,90.47 196.66,90.47 196.97,90.16 196.97,89.27 196.58,88.88 196.04,88.88 195.97,88.95 RP58.3
  BOTTOM w0.089: CX19.1 195.83,90.48 196.02,90.48 v2(196.21,90.67) 196.44,90.44 197.17,90.44 RX46.1
TMDS_TXCN: length 5.5
  TOP w0.089: v2(196.34,83.05) 196.53,83.24 196.89,83.24 197.07,83.07 197.07,82.28 196.82,82.02 196.47,82.02 196.16,82.34 RP59.4
  BOTTOM w0.089: CX12.1 195.89,83.24 196.14,83.24 v2(196.34,83.05) 196.56,83.27 197.23,83.27 197.58,82.92 RX35.1
TMDS_TXCP: length 6
  TOP w0.089: v2(196.34,83.63) 196.54,83.43 196.97,83.43 197.29,83.11 v4(197.29,82.54) 197.29,82.23 196.9,81.84 RP59.3
  BOTTOM w0.089: RX37.1 197.24,83.46 196.51,83.46 v2(196.34,83.63) 196.13,83.43 195.98,83.43 CX13.1
TON_1.35V: length 1.8
  BOTTOM w0.203: PU200.9 82.07,13.94 PR208.2
TON_VGA: length 3.6
  BOTTOM w0.102: PR809.1 78.48,41.33 v1(78.29,41.14)
  BOTTOM w0.203: PR809.1 78.88,41.65 78.42,41.65 77.57,42.49 PU801.9
TOUCH_SCREEN_PD#: length 172.3
  TOP w0.102: DX9.2 RX25.1 10.71,91.08 9.8,91.08 v2(9.58,90.86) v1(8.95,90.86)
  IN1 w0.076: v2(153.12,104.77) 153.12,105.34
  IN1 w0.102: 153.12,105.34 153.12,105.5 151.78,106.85 151.78,109.51 150.15,111.14 144.1,111.14 143.53,111.71 136.82,111.71 136.52,112.01 122.99,112.01 121.55,110.57 104.26,110.57 104.06,110.77 99.57,110.77 97.98,109.17 92.82,109.17 92.58,109.41 77.91,109.41 76.98,108.49 72.79,108.49 72.32,108.96 72.32,109.6 69.81,112.12 41.52,112.12 28.02,98.62 11.62,98.62 9.17,96.16 9.17,91.27 v2(9.58,90.86)
  BOTTOM w0.076: v2(153.12,104.77) 153.12,105.1 153.36,105.34
  BOTTOM w0.102: 153.36,105.34 153.57,105.55 153.78,105.55 154.17,105.93 154.17,106.62 RC402.1 154.67,107.14 RC215.2
TOUCHPAD_INTR#: length 225.6
  TOP w0.102: UE5.33 145,20.22 145.03,20.25 145.48,20.25 v2(145.85,20.63) v1(146.74,20.63) 147.82,21.71 RE354.1 ; QE7.1 v2(24.82,66.98) ; DC3.1 159.31,72.18 v2(158.93,71.8)
  IN1 w0.102: v2(158.93,71.8) 158.74,72 156.74,72 156.43,71.7 156.43,71.23 156.61,71.05 156.61,69.2 156.17,68.76 156.17,67.91 156.58,67.49 156.58,65.22 156.75,65.06 156.75,60.45 158.64,58.56 158.64,52.71 162.05,49.31 162.05,44.6 162.51,44.14 162.51,36.5 160.98,34.97 160.98,25.78 157.56,22.37 148.15,22.37 147.39,21.61 146.13,21.61 145.85,21.33 v2(145.85,20.63) 145.54,20.31 142.32,20.31 140.81,21.82 135.76,21.82 135.11,21.17 135.11,20.66 134.29,19.85 131.74,19.85 131.29,20.31 131.29,21.18 129.95,22.52 112.92,22.52 109.43,26.02 107.48,26.02 104.48,29.02 104.48,32.09 99.48,37.09 87.29,37.09 86.96,37.42 81.18,37.42 80.01,36.25 54.85,36.25 45.34,45.76 41.61,45.76 31.43,55.94 31.43,62.6 26.92,67.11 24.95,67.11 v2(24.82,66.98)
TOUCHPAD_INTR#_D: length 20.7
  TOP w0.102: DC3.2 160.81,72.32 162.55,74.06 v1(162.55,74.29) 162.55,74.54 162.24,74.86 161.74,74.86 161.18,74.3 RC216.2 160.71,75.23 160.08,75.86 v2(160.08,76.37)
  BOTTOM w0.076: 152.01,78.16 151.35,78.16 149.89,79.62 149.89,80.23 149.5,80.62 UC1.BA5
  BOTTOM w0.102: 152.01,78.16 153.43,78.16 155.66,75.92 159.39,75.92 159.84,76.37 v2(160.08,76.37)
TP_LOCK#: length 12.1
  TOP w0.102: v2(23.17,63.68) 22.79,63.3 DE4.2 22.85,62.98 v1(22.85,61.84) 22.66,61.64 JTP.3
  BOTTOM w0.102: RC78.1 24.85,59.53 24.06,60.32 24.06,62.79 v2(23.17,63.68)
TP_PW_EN#: length 149.5
  TOP w0.102: v2(23.68,66.48) 24.17,66.97 QE8.2 23.64,67.67 QE9.2 23,68.51 CE61.1 ; UE5.49 138.6,17.14 138.26,16.79 v2(138.26,14.87)
  IN1 w0.102: v2(23.68,66.48) 23.93,66.22 26.54,66.22 29.57,63.19 29.57,56.65 40.91,45.3 45.05,45.3 55.08,35.27 79.68,35.27 80.49,36.08 83.65,36.08 84.46,35.27 95.91,35.27 106.8,24.38 108.69,24.38 113.04,20.03 114.19,20.03 114.96,20.79 122.68,20.79 123.07,20.4 124.04,20.4 124.79,19.65 128.52,19.65 129.85,18.32 130.22,18.32 132.54,15.99 134.16,15.99 135.28,14.87 v2(138.26,14.87)
  BOTTOM w0.102: v2(23.68,66.48) v1(23.68,66.98)
TS_EN_R: length 12
  TOP w0.102: v2(9.58,91.56) RX25.2 CX9.1 10.27,93.26 v1(10.66,93.65)
  BOTTOM w0.102: JEDP.22 2.4,88.5 2.67,88.77 3.56,88.77 4.12,89.34 5.26,89.34 5.77,89.84 7.87,89.84 v2(9.58,91.56)
TS_INT#: length 4.7
  TOP w0.102: v1(2.28,88.51) 2.75,88.51 3.49,89.25 3.49,89.28 v2(3.68,89.47) 3.87,89.29 RX47.2
  BOTTOM w0.102: v2(3.68,89.47) 3.68,89.43 3.25,89 JEDP.21
TS_RST#: length 5.3
  TOP w0.102: RX24.2 3.65,90.48 v2(3.64,90.49) 3.31,90.16 2.55,90.16 CX4.1 v1(2.34,91.37)
  BOTTOM w0.102: JEDP.19 3.15,90 v2(3.64,90.49)
UART_2_CRXD_DTXD: length 186.9
  IN1 w0.102: v2(160.83,15.04) 160.99,15.21 160.99,15.48 161.23,15.71 162.21,15.71 170.1,23.6 170.1,29.94 171.19,31.04 171.19,35.23 170.33,36.09 170.33,57.42 171.19,58.28 171.19,60.71 172.94,62.46 172.94,66.52 173.2,66.78 173.2,69.52 173.83,70.16 173.83,71.03 173.2,71.66 173.2,76.85 172.17,77.88 172.17,81.08 172.37,81.29 172.68,81.29 v2(172.81,81.41)
  BOTTOM w0.076: 154.87,90.35 154.26,89.74 152.66,89.74 152.58,89.82 UC1.AD1
  BOTTOM w0.102: v2(172.81,81.42) 171.51,82.72 171.51,84.01 167.49,88.03 161.07,88.03 v1(160.87,88.22) 160.65,88.45 160.65,90.58 160.47,90.76 159.68,90.76 RC62.1 158.72,90.76 157.69,90.76 156.95,91.49 156.01,91.49 154.87,90.35 ; JWDB1.2 94.91,8.11 95.26,7.76 95.26,7.54 95.54,7.26 97.29,7.26 98.18,8.14 103.15,8.14 106.58,4.72 110.33,4.72 113.7,1.35 148.23,1.35 148.58,1.71 148.58,3.1 148.77,3.29 158.36,3.29 161.22,6.15 161.22,12.83 162.07,13.68 162.07,15.5 161.87,15.7 161.25,15.7 161.03,15.49 161.03,15.24 v2(160.83,15.04)
UART_2_CTXD_DRXD: length 185.5
  IN1 w0.102: v2(161.41,15.04) 161.22,15.23 161.22,15.38 161.32,15.49 162.31,15.49 170.96,24.14 170.96,30.49 171.42,30.94 171.42,35.32 170.56,36.18 170.56,57.32 171.42,58.18 171.42,60.61 173.17,62.36 173.17,66.43 173.42,66.68 173.42,69.43 174.06,70.06 174.06,71.12 173.42,71.76 173.42,76.94 172.4,77.97 172.4,80.99 172.47,81.06 172.58,81.06 v2(172.81,80.83)
  BOTTOM w0.076: UC1.AD2 151.7,89.82 151.95,89.57 154.41,89.57 154.87,90.03
  BOTTOM w0.102: JWDB1.3 95.71,8.1 95.48,7.88 95.48,7.64 95.64,7.48 97.19,7.48 98.08,8.37 103.24,8.37 106.67,4.94 110.43,4.94 113.79,1.58 120.14,1.58 120.92,2.37 121.95,2.37 122.74,1.58 148.13,1.58 148.35,1.8 148.35,3.2 148.68,3.52 158.27,3.52 160.99,6.25 160.99,12.93 161.84,13.78 161.84,15.4 161.77,15.48 161.34,15.48 161.26,15.39 161.26,15.19 v2(161.41,15.04) ; 154.87,90.03 156.08,91.24 156.88,91.24 157.82,90.3 RC68.1 RC63.1 159.2,88.37 159.77,87.8 167.39,87.8 171.19,84 171.19,82.45 v1(171.97,81.67) 172.81,80.83 v2(172.81,80.83)
UG2_VGA: length 5.9
  IN3 w1.016: 67.62,39.23 73.53,39.23
  vias: v2(66.41,39.11) v2(66.41,38.47) v2(74.42,40.19) v2(74.92,40.5)
UG_1.35V: length 6.3
  IN3 w0.762: 90.16,19.87 90.16,14.91 89.21,13.96
  vias: v2(87.66,14.09) v2(88.26,14.09) v2(90.04,21.26) v2(90.04,20.63)
UGATE_CHG: length 15
  IN3 w1.016: 48.32,17.83 49.59,19.1 49.59,25.39 44.7,30.28
  vias: v2(43.05,30.53) v2(43.68,30.53) v2(47.43,16.5) v2(47.87,16.95)
USB2_COMP: length 1.5
  TOP w0.254: RC119.1 149.04,92.16 v2(149.04,91.94)
  BOTTOM w0.254: v2(149.04,91.94) 149.04,91.76 UC1.AB6
USB2_ID: length 6
  BOTTOM w0.076: UC1.AG3 151.06,88.75 152.25,88.75 152.49,88.51 152.58,88.51 153.22,89.15 154.87,89.15
  BOTTOM w0.102: 154.87,89.15 155.05,89.15 v1(155.16,89.03) 155.61,89.03 RC10.1
USB2_VBUSSENSE: length 8.8
  TOP w0.076: v2(146.74,89.84) v1(147.57,89.84) RC16.1
  BOTTOM w0.076: v2(146.74,89.84) 146.93,89.65 149.6,89.65 149.79,89.46 149.79,88.95 150.15,88.59 UC1.AG4
USB3_CM_P0: length 8.9
  TOP w0.102: v1(25.84,88) 25.52,87.68 v2(25.2,87.68) 24.96,87.44 24.1,87.44 24.01,87.35 23.93,87.35 22.52,85.95 UI8.14
  BOTTOM w0.102: v2(25.2,87.68) 25.39,87.49 25.39,85.72 25,85.32 RI42.2 RI46.2
USB3_CRX_C_RD_DTX_N3: length 1.7
  TOP w0.089: CI22.2 24.98,84.4 24.64,84.4 24.42,84.18 UI8.11
USB3_CRX_C_RD_DTX_P3: length 1.7
  TOP w0.089: CI19.2 24.82,84.59 24.51,84.59 24.42,84.68 UI8.12
USB3_CRX_DTX_N1: length 66.4
  IN3 w0.089: v2(191.05,74.11) 191.2,74.11 191.27,74.18 191.27,74.38 185.44,80.21 180,80.21 168.4,91.81 166.87,91.81 162.93,95.75 162.05,95.75 158.11,99.69 156.03,99.69 155.83,99.48 155.14,99.48 154.36,100.26 150.98,100.26 150.6,100.64 148.71,100.64 148.14,100.07 148.14,99.73 147.63,99.23 147.63,98.69 v2(147.17,98.23)
  BOTTOM w0.076: UC1.H8 147.32,98.23 v2(147.17,98.23)
  BOTTOM w0.089: RI97.1 195.56,70.12 195.56,71.31 195.27,71.6 195.27,73.92 194.87,74.32 191.44,74.32 191.23,74.11 v2(191.05,74.11)
USB3_CRX_DTX_N2: length 80.2
  IN3 w0.089: v2(188.42,50.44) 188.54,50.44 188.63,50.52 188.63,54.68 186.43,56.88 186.43,64.75 185.54,65.63 185.54,72.56 173.9,84.19 173.66,84.19 163.31,94.54 162.38,94.54 160.73,96.19 159.89,96.19 159.25,96.83 159.25,97.67 157.87,99.05 156.28,99.05 156.13,98.9 154.85,98.9 154.19,99.56 153.3,99.56 152.85,99.11 150.06,99.11 149.18,98.24 148.54,98.24 148.23,97.93 148.11,97.93 148.01,97.83 148.01,97.65 v2(148.08,97.59)
  BOTTOM w0.076: UC1.J6 148.68,97.45 148.68,97.57 148.59,97.66 148.41,97.66 148.38,97.69 148.18,97.69 v2(148.08,97.59)
  BOTTOM w0.089: v2(188.42,50.44) 188.43,50.44 188.62,50.25 189.32,50.25 191.29,48.28 192.35,48.28 RI103.1
USB3_CRX_DTX_N3: length 145.4
  TOP w0.089: CI22.1 26.61,84.57 v2(26.79,84.57)
  IN3 w0.089: v2(146.34,97.64) 146.15,97.83 145.01,97.83 144.58,97.4 139.5,97.4 139.08,97.82 127.75,97.82 126.32,96.38 121.68,96.38 121.11,96.96 120.47,96.96 120,96.49 117.89,96.49 116.77,95.37 115.96,95.37 115.77,95.56 115.45,95.56 115.2,95.3 114.1,95.3 113.68,95.72 113.37,95.72 111.94,97.15 109.13,97.15 105.13,101.15 100.55,101.15 96.1,105.59 79.1,105.59 74.34,110.35 43.49,110.35 27.81,94.67 27.81,85.21 27.36,84.76 26.98,84.76 v2(26.79,84.57)
  BOTTOM w0.076: v2(146.34,97.64) 146.69,97.29 UC1.J10
USB3_CRX_DTX_P1: length 66.4
  IN3 w0.089: v2(191.46,73.7) 191.46,74.46 185.52,80.4 180.08,80.4 168.47,92 166.95,92 163.01,95.94 162.12,95.94 158.19,99.88 155.95,99.88 155.75,99.67 155.22,99.67 154.44,100.45 151.06,100.45 150.68,100.83 148.63,100.83 147.95,100.15 147.95,99.81 147.44,99.31 147.44,99.19 v2(147.17,98.92)
  BOTTOM w0.076: UC1.G8 147.28,98.92 v2(147.17,98.92)
  BOTTOM w0.089: RI98.1 195.28,69.85 195.38,69.95 195.38,71.24 195.09,71.52 195.09,73.84 194.8,74.13 191.52,74.13 191.46,74.08 v2(191.46,73.7)
USB3_CRX_DTX_P2: length 80.2
  IN3 w0.089: v2(148.08,98.29) 148.32,98.29 148.46,98.43 149.1,98.43 149.98,99.31 152.77,99.31 153.22,99.75 154.27,99.75 154.93,99.09 156.05,99.09 156.2,99.24 157.95,99.24 159.44,97.75 159.44,96.91 159.97,96.38 160.81,96.38 162.46,94.73 163.39,94.73 173.74,84.38 173.98,84.38 185.73,72.64 185.73,65.71 186.62,64.82 186.62,56.96 188.82,54.76 188.82,50.25 v2(188.43,49.86)
  BOTTOM w0.076: UC1.H6 148.42,97.94 v2(148.08,98.29)
  BOTTOM w0.089: RI104.1 192.22,48.1 191.21,48.1 189.25,50.06 188.63,50.06 v2(188.43,49.86)
USB3_CRX_DTX_P3: length 145.4
  TOP w0.089: CI19.1 26.3,84.89 26.52,84.89 v2(26.79,85.16)
  IN3 w0.089: v2(146.34,98.28) 146.08,98.02 144.93,98.02 144.5,97.59 139.58,97.59 139.16,98.01 127.68,98.01 126.24,96.57 121.76,96.57 121.18,97.15 120.39,97.15 119.92,96.68 117.81,96.68 116.69,95.56 116.04,95.56 115.84,95.75 115.37,95.75 115.12,95.5 114.18,95.5 113.76,95.91 113.45,95.91 112.02,97.34 109.21,97.34 105.21,101.34 100.63,101.34 96.18,105.78 79.18,105.78 74.42,110.54 43.41,110.54 27.62,94.75 27.62,85.29 27.28,84.95 26.99,84.95 v2(26.79,85.16)
  BOTTOM w0.076: UC1.H10 146.67,97.94 v2(146.34,98.28)
USB3_CRX_L_DTX_N3: length 33.6
  TOP w0.089: LI10.1 15.98,80.28 15.67,79.97 15.67,79.26 15.85,79.08 15.85,77.43 16,77.27 DI3.9 DI3.2 16,75.12 15.69,74.81 15.69,73.27 15.32,72.9 14.74,72.9 v2(14.34,72.5)
  BOTTOM w0.089: v2(14.34,72.5) 14.48,72.64 14.72,72.64 14.79,72.56 14.79,71.38 15.16,71.01 15.16,62.17 14.73,61.74 14.73,58.66 15.02,58.37 15.02,55.67 13.54,54.19 10.65,54.19 10.44,54.4 9.57,54.4 JCAM3D.9
USB3_CRX_L_DTX_P3: length 33.6
  TOP w0.089: v2(14.34,73.09) 15.24,73.09 15.5,73.35 15.5,74.03 15.46,74.07 v4(15.46,74.29) 15.46,74.5 15.5,74.54 DI3.1 DI3.10 15.5,77.27 15.66,77.43 15.66,79 15.48,79.18 15.48,79.97 15.18,80.28 LI10.4
  BOTTOM w0.089: JCAM3D.8 13.62,54 15.21,55.59 15.21,58.44 14.92,58.74 14.92,61.66 15.35,62.09 15.35,71.09 14.97,71.46 14.97,72.64 14.79,72.82 14.61,72.82 v2(14.34,73.09)
USB3_CRX_RD_DTX_N3: length 6.1
  TOP w0.089: UI8.20 19.11,84.18 19.02,84.27 19.02,84.42 18.94,84.49 v4(18.6,84.49) 17.82,84.49 17.07,83.75 16.57,83.75 16.54,83.72 15.81,83.72 15.57,83.48 15.57,83.3 15.98,82.9 LI10.2
USB3_CRX_RD_DTX_P3: length 6.1
  TOP w0.089: LI10.3 15.18,82.9 15.39,83.11 15.39,83.56 15.76,83.93 v4(16.19,83.93) 17,83.93 17.74,84.68 18.26,84.68 18.29,84.71 18.97,84.71 19,84.68 UI8.19
USB3_CTX_C_DRX_N3: length 1.4
  TOP w0.102: CI21.2 17.59,81.2 17.59,81.1 17.88,80.81 LI9.2
USB3_CTX_C_DRX_P3: length 1.4
  TOP w0.102: CI24.2 17.34,81.18 17.34,81.08 17.08,80.82 LI9.3
USB3_CTX_C_RD_DRX_N3: length 1.7
  TOP w0.089: CI16.2 24.83,82.77 24.51,82.77 24.42,82.68 UI8.8
USB3_CTX_C_RD_DRX_P3: length 1.7
  TOP w0.089: CI5.2 24.97,82.96 24.52,82.96 24.3,83.18 UI8.9
USB3_CTX_DRX_N1: length 71.8
  IN3 w0.089: v2(194.68,73.11) 194.68,73.12 194.2,73.6 194.2,75.58 193.29,76.5 193.29,77.51 191.51,79.29 191.51,79.86 184.51,86.86 179.12,86.86 166.42,99.56 163.68,99.56 157.45,105.8 147.33,105.8 146.56,105.02 146.56,104.77 v2(146.75,104.58)
  BOTTOM w0.076: UC1.C13 145.18,101.31 145.26,101.39 145.26,101.58 145.19,101.64 144.81,101.64 144.76,101.7 144.76,101.76 144.72,101.86 144.72,102.78 145.86,103.92 146.2,103.92 146.36,104.08 146.36,104.26 146.68,104.58 v2(146.75,104.58)
  BOTTOM w0.089: CI3.2 193.74,73.04 193.74,73.27 193.97,73.5 194.28,73.5 v2(194.68,73.11)
USB3_CTX_DRX_N2: length 97.5
  IN3 w0.089: v2(190.19,47.3) 189.73,47.76 189.73,48.25 190.44,48.96 190.44,65.72 193.62,68.9 193.62,75.34 190.93,78.03 190.93,79.49 184.17,86.25 178.91,86.25 166.18,98.97 163.44,98.97 157.2,105.21 148.15,105.21 147.82,104.88 147.82,104.81 147.89,104.75 v2(148.05,104.59)
  BOTTOM w0.076: v2(148.05,104.59) 147.83,104.37 147.83,104.07 147.25,103.5 146.04,103.5 145.71,103.16 145.71,102.36 145.42,102.08 145.09,102.08 UC1.B13
  BOTTOM w0.089: v2(190.19,47.3) 189.79,47.7 189.57,47.7 189.48,47.61 189.48,46.28 189.59,46.17 190,46.17 190.1,46.27 190.1,46.49 CI10.2
USB3_CTX_DRX_N3: length 152.6
  TOP w0.089: v2(26.79,82.35) 26.6,82.54 26.36,82.54 CI16.1
  IN3 w0.089: v2(26.79,82.35) 27.36,82.35 27.55,82.54 27.55,83.72 27.1,84.17 26.29,84.17 26.09,84.37 26.09,86.03 26.79,86.73 26.79,94.61 43.17,110.99 74.54,110.99 79.36,106.18 96.34,106.18 100.68,101.85 105.47,101.85 109.53,97.78 112.52,97.78 113.91,96.38 116.83,96.38 118.03,97.59 126.62,97.59 127.45,98.42 128.15,98.42 128.45,98.72 128.45,100.89 129.09,101.53 136.77,101.53 139.1,103.85 144.42,103.85 v2(144.46,103.82)
  BOTTOM w0.076: UC1.B15 143.62,102.15 144.01,102.54 144.01,103.88 144.16,104.02 144.25,104.02 v2(144.46,103.82)
USB3_CTX_DRX_P1: length 71.8
  IN3 w0.089: v2(194.68,73.69) 194.48,73.69 194.39,73.78 194.39,75.66 193.48,76.58 193.48,77.59 191.7,79.36 191.7,79.94 184.59,87.05 179.2,87.05 166.5,99.75 163.76,99.75 157.53,105.99 147.25,105.99 146.36,105.1 146.36,104.77 v2(146.17,104.58)
  BOTTOM w0.076: v2(146.17,104.58) 146.19,104.56 146.19,104.15 146.13,104.09 145.78,104.09 144.55,102.86 144.55,101.83 144.59,101.73 144.59,101.28 UC1.D13
  BOTTOM w0.089: CI4.2 193.56,72.65 193.56,73.35 193.9,73.69 v2(194.68,73.69)
USB3_CTX_DRX_P2: length 97.5
  IN3 w0.089: v2(190.19,47.89) 190.04,47.89 189.92,48 189.92,48.17 190.63,48.88 190.63,65.64 193.81,68.82 193.81,75.42 191.12,78.11 191.12,79.57 184.25,86.44 178.99,86.44 166.26,99.16 163.52,99.16 157.28,105.4 148.08,105.4 147.63,104.96 147.63,104.76 v2(147.46,104.59)
  BOTTOM w0.076: v2(147.46,104.59) 147.65,104.4 147.65,104.14 147.18,103.67 145.97,103.67 145.54,103.23 145.54,102.43 145.35,102.25 145.06,102.25 144.97,102.33 UC1.A13
  BOTTOM w0.089: v2(190.19,47.89) 189.49,47.89 189.29,47.68 189.29,46.21 189.51,45.99 189.71,45.99 CI11.2
USB3_CTX_DRX_P3: length 152.6
  TOP w0.089: CI5.1 26.55,82.86 26.71,82.86 v2(26.79,82.94)
  IN3 w0.089: v2(26.79,82.94) 26.93,82.8 27.18,82.54 27.28,82.54 27.36,82.62 27.36,83.64 27.02,83.98 26.21,83.98 25.9,84.29 25.9,86.11 26.6,86.81 26.6,94.69 43.09,111.18 74.62,111.18 79.43,106.37 96.42,106.37 100.75,102.04 105.55,102.04 109.61,97.97 112.59,97.97 113.99,96.57 116.75,96.57 117.96,97.78 126.54,97.78 127.37,98.61 128.07,98.61 128.26,98.8 128.26,100.97 129.01,101.72 136.69,101.72 139.02,104.04 144.16,104.04 144.46,104.34 v2(144.46,104.4)
  BOTTOM w0.076: v2(144.46,104.4) 144.25,104.19 144.08,104.19 143.84,103.95 143.84,102.73 143.72,102.61 UC1.A15
USB3_CTX_L_DRX_N3: length 33.3
  TOP w0.089: RI5.2 17.88,78.89 LI9.1 17.88,78.39 17.58,78.09 17.58,77.75 17.35,77.51 17.35,77.42 17.5,77.27 DI3.6 DI3.5 17.5,75.1 17.26,74.85 17.26,72.19 16.57,71.5 16.33,71.5 v2(16.06,71.23)
  BOTTOM w0.089: v2(16.06,71.23) 16.33,71.5 16.49,71.5 16.64,71.35 16.64,70.74 15.91,70.01 15.91,62.02 15.37,61.48 15.37,58.91 15.6,58.68 15.6,55.43 13.16,52.99 10.65,52.99 10.44,53.2 9.57,53.2 JCAM3D.6
USB3_CTX_L_DRX_P3: length 33.4
  TOP w0.089: RI6.2 17.08,78.9 LI9.4 17.08,78.41 17.39,78.1 17.39,77.82 17.16,77.59 17.16,77.42 17,77.27 DI3.7 DI3.4 17,75.06 17.07,74.98 17.07,73.69 17.01,73.63 v4(17.01,73.4) 17.01,73.14 17.07,73.08 17.07,72.26 16.5,71.68 16.19,71.68 v2(16.06,71.81)
  BOTTOM w0.089: v2(16.06,71.81) 16.19,71.68 16.57,71.68 16.82,71.43 16.82,70.66 16.09,69.93 16.09,61.94 15.55,61.4 15.55,58.99 15.79,58.75 15.79,55.35 13.24,52.8 9.57,52.8 JCAM3D.5
USB3_CTX_RD_DRX_N3: length 3.5
  TOP w0.089: UI8.23 19.11,82.68 18.98,82.81 18.98,82.91 18.89,82.99 18.46,82.99 18.29,83.17 17.59,83.17 17.43,83.01 17.43,82.9 CI21.1
USB3_CTX_RD_DRX_P3: length 3.5
  TOP w0.089: UI8.22 18.54,83.18 18.33,83.39 v4(17.96,83.39) 17.54,83.39 17.24,83.09 17.24,82.66 CI24.1
USB3_DE1_P0: length 2.8
  TOP w0.102: v2(21.63,80.57) 21.63,80.59 21.52,80.7 UI8.3
  BOTTOM w0.102: RI26.2 21.71,80.5 v2(21.63,80.57) 21.65,80.59 RI35.2
USB3_DE2_P0: length 3.3
  TOP w0.102: v2(21.39,86.86) 21.52,86.73 UI8.16
  BOTTOM w0.102: v2(21.39,86.86) 21.66,86.59 RI20.2 21.65,86.28 RI31.2
USB3_EQ1_P0: length 3.6
  TOP w0.102: UI8.2 21.02,80.59 v2(21.01,80.57)
  BOTTOM w0.102: RI23.2 20.82,80.38 v2(21.01,80.57) ; v2(21.01,80.57) 20.76,80.83 RI32.2 ; v2(21.01,80.57) v1(20.34,80.57)
USB3_EQ2_P0: length 5.5
  TOP w0.102: UI8.17 21.02,86.02 20.76,86.29 v2(19.87,86.29) 19.6,86.02 RI21.2
  BOTTOM w0.102: RI36.2 19.88,85.32 19.68,85.53 v1(19.68,85.78) 19.68,86.1 v2(19.87,86.29)
USB3_ERD_P0: length 3
  TOP w0.102: RI44.2 RI48.2 22.98,80.45 22.52,80.9 UI8.5
USB3_OS1_P0: length 4
  TOP w0.102: UI8.4 22.02,80.77 v2(22.22,80.57)
  BOTTOM w0.102: v1(23.56,79.7) RI22.2 22.6,80.19 v2(22.22,80.57) 22.54,80.89 RI40.2
USB3_OS2_P0: length 3.7
  TOP w0.102: UI8.15 22.02,86.15 22.78,86.9 v2(22.89,86.9)
  BOTTOM w0.102: RI87.2 22.54,85.84 22.52,85.86 RI19.2 22.52,86.4 22.89,86.77 v2(22.89,86.9)
USB3_P0_PIN6: length 4.4
  TOP w0.102: UI8.6 23.02,80.91 23.87,80.06 RI49.2 RI53.2 25.19,79.57 v1(25.77,78.99)
USB3_P0_PIN18: length 4.7
  TOP w0.102: RI52.2 RI50.2 19.43,85.27 20.19,86.03 20.38,86.03 20.52,85.89 UI8.18
USB3RN1_JUSB1_R: length 10.7
  BOTTOM w0.089: RI97.2 195.52,68.63 195.52,67.71 195.3,67.49 194.68,67.49 194.55,67.36 194.55,67.06 194.63,66.98 194.75,66.98 194.9,67.13 DI1.10 DI1.1 196.98,67.13 197.16,66.95 197.95,66.95 198.75,67.75 199.57,67.75 200.04,68.22 200.68,68.22 200.79,68.33 JUSB1.5
USB3RN2_JUSB2_R: length 9.1
  BOTTOM w0.089: RI103.2 193.84,48.28 195.07,48.28 195.21,48.43 DI4.10 DI4.1 197.1,48.43 197.27,48.25 197.73,48.25 198.88,49.39 199.51,49.39 200.25,50.14 200.7,50.14 200.79,50.23 JUSB2.5
USB3RP1_JUSB1_R: length 10.7
  BOTTOM w0.089: JUSB1.6 200.79,67.79 200.55,68.03 200.12,68.03 199.65,67.56 198.83,67.56 198,66.73 v4(197.67,66.73) 197.1,66.73 197,66.63 DI1.2 DI1.9 194.91,66.63 194.75,66.79 194.56,66.79 194.37,66.98 194.37,67.44 194.6,67.67 195.22,67.67 195.34,67.79 195.34,68.54 RI98.2
USB3RP2_JUSB2_R: length 9.1
  BOTTOM w0.089: RI104.2 193.97,48.1 195.09,48.1 195.26,47.93 DI4.9 DI4.2 197.09,47.93 197.23,48.07 197.81,48.07 198.95,49.21 199.59,49.21 200.33,49.95 200.62,49.95 200.79,49.79 JUSB2.6
USB3TN1_JUSB1_C: length 2
  BOTTOM w0.089: RI99.1 193.82,70.08 193.82,71.11 CI3.1
USB3TN1_JUSB1_R: length 13.4
  BOTTOM w0.089: RI99.2 193.53,68.42 v4(193.53,67.47) 193.53,66.47 193.92,66.08 193.92,66.03 194.49,65.46 194.67,65.46 194.84,65.63 DI1.7 DI1.4 197.01,65.63 197.17,65.47 197.33,65.47 197.99,64.82 197.99,63.55 198.56,62.98 199.7,62.98 200.35,62.33 200.61,62.33 200.79,62.51 JUSB1.8
USB3TN2_JUSB2_C: length 2
  BOTTOM w0.089: CI10.1 191.15,46.35 192.2,46.35 RI106.1
USB3TN2_JUSB2_R: length 9.9
  BOTTOM w0.089: JUSB2.8 200.79,44.23 200.7,44.14 200.39,44.14 199.57,44.95 198.75,44.95 198.18,45.52 198.18,46.35 197.73,46.79 197.23,46.79 197.1,46.93 DI4.4 DI4.7 195.26,46.93 194.93,46.6 193.75,46.6 RI106.2
USB3TP1_JUSB1_C: length 2
  BOTTOM w0.089: CI4.1 193.63,71.34 193.63,70.33 RI100.1
USB3TP1_JUSB1_R: length 13.5
  BOTTOM w0.089: JUSB1.9 200.79,61.96 200.6,62.15 200.28,62.15 199.62,62.8 198.48,62.8 197.8,63.48 197.8,64.74 197.26,65.29 197.17,65.29 197.01,65.13 DI1.5 DI1.6 194.85,65.13 194.7,65.27 194.42,65.27 v4(193.54,66.15) 193.35,66.34 193.35,67.11 193.32,67.14 193.32,68.78 RI100.2
USB3TP2_JUSB2_C: length 2
  BOTTOM w0.089: RI105.1 192.38,46.16 191.32,46.16 CI11.1
USB3TP2_JUSB2_R: length 10
  BOTTOM w0.089: JUSB2.9 200.79,43.86 200.7,43.95 200.31,43.95 199.5,44.76 198.67,44.76 197.99,45.44 197.99,46.27 197.66,46.61 197.21,46.61 197.03,46.43 DI4.5 DI4.6 195.07,46.43 195.05,46.41 194.06,46.41 RI105.2
USB20_CR_N6_R: length 3.9
  BOTTOM w0.089: RI110.2 29.13,54.89 LI8.2 28.69,54.72 28.5,54.54 v4(27.93,54.54) 26.71,54.54 26.31,54.95 JIO.12
USB20_CR_P6_R: length 3.9
  BOTTOM w0.089: RI109.2 29.13,54.06 LI8.3 28.7,54.22 28.57,54.35 28.32,54.35 28.29,54.32 27.64,54.32 27.61,54.35 26.71,54.35 26.31,53.95 JIO.11
USB20_JUSB1_N0_R: length 12.6
  IN3 w0.102: JUSB1.2 199.29,64.25 199.42,64.37 199.42,65.11 199.31,65.22 198.91,65.22 197.54,63.85 197.54,63.85 196.88,63.18 195.91,63.18 195.66,62.94 195.66,62.49 v2(195.89,62.27)
  BOTTOM w0.089: v2(195.89,62.27) 196.43,61.72 DI2.2 196.01,61.33 195.76,61.07 195.76,60.58 195.97,60.37 196.64,60.37 197.29,59.72 197.29,59.3 196.97,58.98 196.59,58.98 196.47,58.86 LI2.2 196.26,58.83 RI95.2
USB20_JUSB1_P0_R: length 12.7
  IN3 w0.102: JUSB1.3 199.29,65.65 199.08,65.43 198.82,65.43 197.33,63.94 196.79,63.4 195.82,63.4 195.45,63.03 195.45,62.41 v2(195.3,62.26)
  BOTTOM w0.089: v2(195.3,62.26) 194.5,61.46 DI2.3 195.13,61.33 195.57,60.89 195.57,60.51 195.89,60.19 196.56,60.19 197.1,59.65 197.1,59.38 196.89,59.17 196.72,59.17 196.53,59.36 LI2.3 196.26,59.39 RI96.2
USB20_JUSB2_N1_R: length 15.8
  IN3 w0.102: v2(196.08,41.9) 196.26,42.08 196.7,42.08 197.22,42.6 197.22,46.12 198.02,46.92 199.06,46.92 199.29,46.69 JUSB2.2
  BOTTOM w0.089: RI101.2 190.89,43.39 LI5.2 191.45,43.56 191.64,43.74 192.08,43.74 192.55,43.27 192.87,43.27 193.1,43.04 193.1,42.75 DI5.2 193.45,43.18 193.54,43.27 194.13,43.27 194.44,42.97 194.44,42.59 194.87,42.16 195.83,42.16 v2(196.08,41.9)
USB20_JUSB2_P1_R: length 15.8
  IN3 w0.102: v2(196.08,42.54) 196.32,42.3 196.61,42.3 197.01,42.69 197.01,46.21 197.93,47.14 199.03,47.14 199.29,47.39 JUSB2.3
  BOTTOM w0.089: v2(196.08,42.54) 195.89,42.34 194.94,42.34 194.62,42.66 194.62,43.04 194.21,43.45 193.54,43.45 193.45,43.54 DI5.3 193.1,43.97 193.1,43.68 192.87,43.45 192.63,43.45 192.16,43.93 191.7,43.93 191.57,44.06 LI5.3 190.89,44.22 RI102.2
