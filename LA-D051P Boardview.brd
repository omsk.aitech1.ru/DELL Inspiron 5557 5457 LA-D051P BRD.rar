# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
USB20_JUSB3_N4_R: length 3.9
  BOTTOM w0.089: JIO.15 26.3,57.95 26.7,57.55 v4(27.93,57.55) 28.3,57.55 28.46,57.71 LI11.2 29.13,57.88 RI108.2
USB20_JUSB3_P4_R: length 3.9
  BOTTOM w0.089: JIO.14 26.28,56.95 26.7,57.37 27.55,57.37 27.58,57.34 28.33,57.34 28.46,57.21 LI11.3 29.13,57.04 RI107.2
USB20_N1: length 69.4
  IN3 w0.089: v2(147.57,90.95) 147.47,90.95 147.19,90.67 147.19,90.49 147.31,90.37 148.37,90.37 148.9,89.84 149.77,89.84 150.66,90.73 153.68,90.73 154.33,90.09 162.84,90.09 165.26,87.66 166.27,87.66 170.94,82.99 170.94,80.08 175.95,75.06 175.95,70.86 182.49,64.32 182.49,63.82 v2(182.82,63.49)
  BOTTOM w0.089: RI95.1 195.01,58.83 LI2.1 194.74,58.86 194.56,59.05 194.1,59.05 v4(193.85,59.3) 193.67,59.48 193.67,60.68 192.54,61.82 191.08,61.82 188.71,64.19 182.94,64.19 182.62,63.87 182.62,63.69 v2(182.82,63.49)
  BOTTOM w0.102: v2(147.57,90.95) 147.42,91.13 UC1.AB9
USB20_N2: length 77.6
  IN3 w0.089: v2(187.93,42.91) 188.12,43.11 188.33,43.11 188.91,43.68 188.91,46.03 188.14,46.79 188.14,47.68 187.38,48.44 187.38,55.37 184.33,58.42 184.33,63.32 178.24,69.41 178.24,71.3 176.59,72.95 176.59,75.37 171.57,80.38 171.57,83.43 166.76,88.24 165.5,88.24 163.08,90.67 157.6,90.67 157.09,91.18 150.22,91.18 149.52,90.48 149.3,90.48 149.22,90.56 149.22,90.72 v2(149.4,90.9)
  BOTTOM w0.076: v2(149.4,90.9) 149.37,90.87 UC1.AD6
  BOTTOM w0.089: RI101.1 189.97,43.39 LI5.1 189.3,43.56 189.15,43.71 188.95,43.71 188.35,43.11 188.13,43.11 v2(187.93,42.91)
USB20_N4: length 224.2
  IN3 w0.089: v2(153.44,90.1) 153.22,89.87 153.22,89.67 153.39,89.5 162.47,89.5 164.89,87.08 166.02,87.08 170.17,82.92 170.17,79.81 171.55,78.43 171.55,65.3 170.88,64.63 170.88,62.36 169.72,61.2 v2(169.72,60.89)
  BOTTOM w0.076: v2(153.44,90.1) 153.24,90.3 153.24,90.55 153.07,90.72 152.63,90.72 152.16,90.25 151.94,90.25 151.83,90.21 151.67,90.21 151.54,90.25 151.3,90.25 151.17,90.21 151.02,90.21 150.9,90.25 150.65,90.25 150.56,90.2 150.42,90.2 150.36,90.22 150.14,90.29 149.83,90.29 149.57,90.03 147.32,90.03 147.18,90.16 147.18,90.28 147.27,90.37 UC1.AD9
  BOTTOM w0.089: v2(169.72,60.89) 169.53,61.08 169.53,61.27 169.28,61.52 168.46,61.52 168.24,61.3 165.46,61.3 165.12,61.65 164.53,61.65 164.28,61.4 162.15,61.4 161.63,60.87 157.9,60.87 156.9,59.87 101.61,59.87 101.08,60.39 92.22,60.39 89.82,57.99 89.82,53.06 83.01,46.25 83.01,37.42 79.55,33.96 56.64,33.96 48.83,41.77 42.61,41.77 34.6,49.78 34.6,52.63 34.64,52.67 34.64,52.67 v4(34.64,52.98) 34.64,53.29 34.64,53.29 34.6,53.34 34.6,53.85 33.65,54.8 33.65,54.86 33.2,55.3 33.15,55.3 32.31,56.14 32.31,56.91 31.66,57.55 30.87,57.55 30.71,57.71 LI11.1 30.04,57.88 RI108.1
USB20_N5: length 195.1
  TOP w0.089: v2(7.36,83.94) 7.38,83.94 7.76,84.32 7.76,84.63 7.2,85.19 6.64,85.19 6.53,85.08 6.53,84.96 6.47,84.89 LX6.1 6.02,84.8 RX21.1
  IN1 w0.089: v2(153.13,87.25) 153.27,87.39 153.27,87.48 153.11,87.63 153.11,88.14 153.48,88.51 153.95,88.51 154.39,88.95 154.98,88.95 155.82,89.79 155.82,92.89 155.15,93.56 153.4,93.56 152.78,94.18 152.78,94.54 151.79,95.54 151.79,98.83 151.27,99.34 151.27,103.54 149.86,104.95 149.86,108.75 149.32,109.29 143.33,109.29 142.76,109.87 136.05,109.87 135.88,110.04 123.64,110.04 122.31,108.72 103.23,108.72 103.03,108.92 100.34,108.92 98.74,107.33 92.04,107.33 91.79,107.57 80.27,107.57 78.93,106.23 71.8,106.23 67.08,110.96 42,110.96 28.5,97.46 16.37,97.46 10.79,91.87 10.79,84.76 9.95,83.93 8.5,83.93 8.11,83.54 7.76,83.54 v2(7.36,83.94)
  BOTTOM w0.076: v2(153.13,87.25) 153.22,87.25 153.44,87.03 153.44,86.94 153.35,86.85 152.13,86.85 152.01,86.97 152.01,87.08 UC1.AJ1
USB20_N5_L: length 3.7
  TOP w0.089: RX21.2 4.77,84.8 LX6.2 4.12,84.89 v2(3.87,85.14)
  BOTTOM w0.089: v2(3.87,85.14) 3.67,85.34 3.28,85.34 2.97,85.65 2.47,85.65 2.42,85.6 2.42,85.6 2.32,85.5 JEDP.28
USB20_N6: length 217.2
  IN3 w0.089: v2(168.28,59.89) 168.07,60.11 168.07,65.64 170.19,67.76 170.19,71.8 168.94,73.06 168.94,82.51 165.54,85.91 164.41,85.91 163.14,87.18 156.79,87.18 156.08,87.88 155.43,87.88 155.12,88.2 v2(155.12,88.32)
  BOTTOM w0.076: 153.9,88.82 153.88,88.82 153.87,88.81 153.26,88.81 152.76,88.31 152.4,88.31 152.26,88.17 152.1,88.17 151.92,88.26 151.62,88.26 151.52,88.23 151.35,88.23 151.28,88.26 150.98,88.26 150.91,88.23 150.69,88.23 150.66,88.24 150.61,88.26 150.58,88.28 150.39,88.28 150.21,88.21 150.02,88.21 149.84,88.4 149.84,88.47 149.53,88.78 149.23,88.78 149.15,88.85 149.15,89.18 149.27,89.3 UC1.AF6
  BOTTOM w0.089: RI110.1 30.04,54.89 LI8.1 30.37,54.57 31.59,54.57 32.44,53.71 32.51,53.71 32.95,53.27 32.95,53.2 33.71,52.45 33.71,51.43 33.77,51.36 v4(33.77,51.08) 33.77,50.85 33.71,50.79 33.71,49.84 42.61,40.94 48.64,40.94 56.26,33.32 79.86,33.32 83.63,37.09 83.63,45.98 90.49,52.84 90.49,57.83 92.46,59.81 100.14,59.81 100.66,59.29 157.14,59.29 158.15,60.29 161.87,60.29 162.39,60.82 164.15,60.82 164.31,60.66 167.8,60.66 168.06,60.41 168.06,60.12 v2(168.28,59.89) ; 153.9,88.82 154.77,88.82 154.93,88.65 154.93,88.51 v2(155.12,88.32)
USB20_N7: length 194.6
  TOP w0.089: v2(5.84,93.15) 6.55,93.86 DX2.3 6.75,93.07 6.84,92.98 8.71,92.98 v4(9.23,93.5) 9.78,94.05 9.78,94.41 v2(9.58,94.61)
  IN1 w0.089: v2(9.58,94.61) 9.78,94.81 9.78,94.99 13,98.22 28.18,98.22 41.69,111.72 67.4,111.72 72.13,106.99 78.42,106.99 79.75,108.33 92.13,108.33 92.37,108.08 98.43,108.08 100.02,109.68 103.6,109.68 103.8,109.48 122,109.48 123.44,110.93 136.07,110.93 136.37,110.62 143.08,110.62 143.65,110.05 149.7,110.05 150.69,109.06 150.69,105.19 151.88,104.01 151.88,99.76 152.39,99.24 152.39,95.94 153.22,95.11 153.66,95.11 154.46,94.32 155.91,94.32 157.09,93.14 157.09,89.4 155.38,87.68 154.9,87.68 154.83,87.62 154.83,87.49 155.04,87.28 v2(155.12,87.28)
  BOTTOM w0.076: 152.06,87.76 152.04,87.76 152.03,87.75 151.86,87.75 UC1.AH1
  BOTTOM w0.089: JEDP.13 2.55,93 2.71,92.84 4.39,92.84 4.5,92.95 5.64,92.95 v2(5.84,93.15) ; 152.06,87.76 152.34,87.76 152.46,87.87 152.83,87.87 153.43,88.47 153.83,88.47 154.42,87.87 154.69,87.87 154.87,87.69 154.87,87.53 v2(155.12,87.28)
USB20_N8: length 59.7
  IN3 w0.089: v2(168.59,59.38) 168.74,59.53 168.85,59.63 168.85,60.17 168.46,60.55 168.46,65.08 170.11,66.73 170.59,67.21 170.59,71.96 169.33,73.22 169.33,82.67 165.7,86.3 164.57,86.3 163.08,87.79 159.15,87.79 158.21,88.73 154.28,88.73 153.89,88.34 152.38,88.34 151.04,89.67 150.53,89.67 149.94,89.09 148.58,89.09 148.27,89.4 147.65,89.4 147.5,89.26 147.5,88.95 v2(147.76,88.7)
  BOTTOM w0.076: v2(147.76,88.7) 148.07,89.02 UC1.AF8
  BOTTOM w0.089: v2(168.59,59.38) 168.78,59.19 168.78,58.6 171.25,56.13 172.87,56.13 173.32,56.58 173.32,56.75 173.48,56.9 JNGFF.5
USB20_P1: length 69.3
  IN3 w0.089: v2(182.23,63.49) 182.3,63.56 182.3,64.24 175.76,70.78 175.76,74.98 170.74,80 170.74,82.91 166.19,87.47 165.18,87.47 162.76,89.89 154.25,89.89 153.6,90.54 150.74,90.54 149.85,89.65 148.82,89.65 148.29,90.18 147.23,90.18 147,90.42 147,90.82 v2(146.89,90.92)
  BOTTOM w0.089: RI96.1 195.01,59.39 LI2.4 194.75,59.36 194.62,59.23 194.22,59.23 193.86,59.6 193.86,60.76 192.61,62 191.16,62 188.78,64.38 182.86,64.38 182.43,63.95 182.43,63.69 v2(182.23,63.49)
  BOTTOM w0.102: v2(146.89,90.92) 146.77,91.09 UC1.AB10
USB20_P2: length 77.5
  IN3 w0.089: v2(148.74,90.9) 148.99,90.9 149.03,90.86 149.03,90.48 149.22,90.29 149.6,90.29 150.3,90.99 157.01,90.99 157.52,90.48 163,90.48 165.42,88.05 166.68,88.05 171.38,83.35 171.38,80.3 176.4,75.29 176.4,72.87 178.05,71.22 178.05,69.33 184.14,63.24 184.14,58.34 187.19,55.29 187.19,48.36 187.95,47.6 187.95,46.71 188.72,45.95 188.72,43.76 188.26,43.3 188.13,43.3 v2(187.93,43.5)
  BOTTOM w0.076: v2(148.74,90.9) 148.74,90.79 148.72,90.77 UC1.AD7
  BOTTOM w0.089: RI102.1 189.97,44.22 LI5.4 189.3,44.06 189.15,43.9 188.87,43.9 188.27,43.3 188.13,43.3 v2(187.93,43.5)
USB20_P4: length 223.9
  IN3 w0.089: v2(152.86,90.1) 153.03,89.93 153.03,89.59 153.31,89.31 162.39,89.31 164.81,86.88 165.94,86.88 169.98,82.85 169.98,79.73 171.36,78.35 171.36,65.38 170.69,64.71 170.69,62.44 v2(169.14,60.89)
  BOTTOM w0.076: UC1.AD10 146.9,90.37 147.01,90.25 147.01,90.09 147.25,89.86 149.64,89.86 149.9,90.12 150.14,90.12 150.31,90.07 150.39,90.04 150.6,90.04 150.69,90.08 150.88,90.08 151,90.04 151.2,90.04 151.32,90.08 151.52,90.08 151.64,90.05 151.65,90.04 151.85,90.04 151.96,90.08 152.23,90.08 152.7,90.54 153,90.54 153.06,90.48 153.06,90.3 v2(152.86,90.1)
  BOTTOM w0.089: RI107.1 30.04,57.04 LI11.4 30.71,57.21 30.87,57.37 31.59,57.37 32.12,56.83 32.12,56.06 v4(33.27,54.92) 34.41,53.78 34.41,49.7 42.53,41.58 48.75,41.58 56.56,33.77 79.62,33.77 83.19,37.34 83.19,46.17 90,52.98 90,57.91 92.3,60.2 101.01,60.2 101.53,59.68 156.97,59.68 157.98,60.69 161.7,60.69 162.23,61.21 164.35,61.21 164.6,61.46 165.04,61.46 165.38,61.12 168.32,61.12 168.54,61.34 169.2,61.34 169.35,61.19 169.35,61.1 v2(169.14,60.89)
USB20_P5: length 195.1
  TOP w0.089: v2(7.94,83.94) 7.94,84.71 7.28,85.37 6.04,85.37 LX6.4 6.02,85.42 RX22.1
  IN1 w0.089: v2(7.94,83.94) 8.25,83.94 8.42,84.11 9.87,84.11 10.61,84.84 10.61,91.95 16.3,97.64 28.42,97.64 41.93,111.14 67.15,111.14 71.88,106.42 78.86,106.42 80.19,107.75 91.87,107.75 92.11,107.51 98.67,107.51 100.26,109.11 103.11,109.11 103.31,108.91 122.24,108.91 123.56,110.23 135.95,110.23 136.13,110.05 142.84,110.05 143.41,109.47 149.4,109.47 150.04,108.83 150.04,105.03 151.45,103.61 151.45,99.42 151.97,98.91 151.97,95.61 152.96,94.62 152.96,94.25 153.47,93.74 155.22,93.74 156.01,92.96 156.01,89.71 155.06,88.76 154.46,88.76 154.02,88.32 153.55,88.32 153.3,88.07 153.3,87.71 153.52,87.48 153.52,87.44 v2(153.72,87.25)
  BOTTOM w0.076: v2(153.72,87.25) 153.61,87.14 153.61,86.87 153.42,86.68 152.06,86.68 151.57,87.17 UC1.AJ2
USB20_P5_L: length 3.7
  TOP w0.089: v2(3.87,85.73) 4.2,85.39 LX6.3 4.77,85.42 RX22.2
  BOTTOM w0.089: v2(3.87,85.73) 3.66,85.53 3.36,85.53 3.05,85.84 2.47,85.84 2.31,86 JEDP.27
USB20_P6: length 217.1
  IN3 w0.089: v2(154.55,88.26) 154.88,87.92 155.13,87.92 155.35,87.69 156,87.69 156.71,86.99 163.06,86.99 164.33,85.72 165.46,85.72 168.74,82.43 168.74,72.98 170,71.72 170,67.84 167.87,65.72 167.87,60.07 v2(167.7,59.89)
  BOTTOM w0.076: UC1.AF7 148.86,89.3 148.99,89.17 148.99,88.78 149.16,88.61 149.46,88.61 149.67,88.4 149.67,88.33 149.96,88.05 150.24,88.05 150.42,88.11 150.54,88.11 150.61,88.08 150.65,88.06 150.95,88.06 151.02,88.1 151.24,88.1 151.31,88.06 151.55,88.06 151.65,88.1 151.87,88.1 151.88,88.1 152.06,88 152.33,88 152.46,88.13 152.83,88.13 153.34,88.64 153.87,88.64 153.88,88.63 153.9,88.63
  BOTTOM w0.089: RI109.1 30.04,54.06 LI8.4 30.47,54.22 30.63,54.38 31.51,54.38 v4(32.55,53.34) 33.52,52.37 33.52,49.77 42.53,40.76 48.56,40.76 56.18,33.14 79.94,33.14 83.81,37.01 83.81,45.9 90.67,52.76 90.67,57.76 92.54,59.62 100.06,59.62 100.59,59.1 157.22,59.1 158.23,60.11 161.94,60.11 162.47,60.63 164.08,60.63 164.23,60.48 167.73,60.48 167.87,60.33 167.87,60.07 v2(167.7,59.89) ; 153.9,88.63 154.69,88.63 154.75,88.57 154.75,88.46 v2(154.55,88.26)
USB20_P7: length 194.6
  TOP w0.089: v2(10.16,94.61) 9.96,94.41 9.96,93.97 9.59,93.59 9.59,93.55 9.18,93.14 9.13,93.14 8.79,92.8 6.84,92.8 6.75,92.71 DX2.2 6.47,91.93 v2(5.84,92.56)
  IN1 w0.089: v2(10.16,94.61) 9.96,94.81 9.96,94.92 13.08,98.03 28.26,98.03 41.76,111.54 67.33,111.54 72.05,106.81 78.49,106.81 79.83,108.15 92.05,108.15 92.29,107.9 98.5,107.9 100.1,109.5 103.53,109.5 103.73,109.3 122.07,109.3 123.52,110.74 135.99,110.74 136.29,110.44 143,110.44 143.57,109.87 149.62,109.87 150.51,108.98 150.51,105.12 151.69,103.93 151.69,99.68 152.21,99.17 152.21,95.86 153.14,94.93 153.59,94.93 154.38,94.14 155.84,94.14 156.91,93.06 156.91,89.48 155.3,87.87 154.82,87.87 154.65,87.7 154.65,87.47 v2(154.46,87.28)
  BOTTOM w0.076: UC1.AH2 151.66,87.58 152.03,87.58 152.04,87.57 152.06,87.57
  BOTTOM w0.089: v2(5.84,92.56) 5.63,92.76 4.57,92.76 4.47,92.66 2.71,92.66 2.55,92.5 JEDP.14 ; 152.06,87.57 152.42,87.57 152.53,87.68 152.91,87.68 153.51,88.28 153.75,88.28 154.34,87.68 154.62,87.68 154.68,87.62 154.68,87.51 v2(154.46,87.28)
USB20_P8: length 59.7
  IN3 w0.089: v2(169.18,59.38) 169.04,59.52 169.04,60.25 168.65,60.63 168.65,65 170.3,66.65 170.78,67.13 170.78,72.04 169.52,73.3 169.52,82.75 165.78,86.49 164.65,86.49 163.16,87.98 159.23,87.98 158.29,88.92 154.2,88.92 153.81,88.53 152.46,88.53 151.12,89.86 150.45,89.86 149.86,89.28 148.65,89.28 148.34,89.59 147.57,89.59 147.31,89.34 147.31,88.89 v2(147.12,88.7)
  BOTTOM w0.076: UC1.AF9 147.42,89 v2(147.12,88.7)
  BOTTOM w0.089: JNGFF.3 172.98,56.9 173.13,56.75 173.13,56.66 172.79,56.32 171.32,56.32 168.96,58.68 168.96,59.16 169.02,59.22 v2(169.18,59.38)
USB_EN#: length 221.1
  TOP w0.102: CI13.1 191.62,48.78 UI5.4 192.46,47.94 192.46,45.14 ; 192.46,45.14 UI6.4 ; 192.46,45.14 192.84,44.76 CI26.1 193.35,41.28 193.35,39.93 v2(192.84,39.42) ; RE356.1 v1(154.36,11.48) 154.06,11.18 151.39,11.18 v2(151.14,10.93) 150.89,11.18 148.98,11.18 147.95,10.15 UE5.13
  IN1 w0.102: v2(192.84,39.42) 191.83,38.41 189.99,38.41 186.92,35.35 186.92,30.37 185.98,29.43 185.98,25.07 180.02,19.1 176.88,19.1 174.51,16.73 169.86,16.73 168.17,15.04 168.17,13.87 164.05,9.74 152.73,9.74 151.55,10.93 v2(151.14,10.93) 150.97,11.1 148.65,11.1 148.06,10.51 142.46,10.51 141.95,10 140.75,10 140.01,10.74 137.28,10.74 136.87,10.33 136.44,10.33 135.8,10.96 133.6,10.96 132.27,12.29 129.38,12.29 127.1,14.57 121.68,14.57 118.47,17.78 110.85,17.78 109.09,19.55 109.09,20.99 107.76,22.32 105.95,22.32 95.08,33.2 53.54,33.2 52.51,34.23 52.51,35.04 44.23,43.32 39.15,43.32 v2(38.28,44.19)
  BOTTOM w0.102: v2(38.28,44.19) 35.05,47.43 32.38,47.43 32.11,47.16 CI46.1 32.11,46.72 UI7.4
USB_OC#0_1: length 105.7
  TOP w0.102: UI6.3 193.16,45.14 192.72,45.59 192.72,49.39 192.97,49.65 193.41,49.65 193.67,49.39 193.67,49.13 UI5.3 194.19,48.76 194.38,48.95 CI15.1 194.38,51.32 189.71,56 v1(189.6,56) v2(185.98,59.63)
  IN1 w0.102: v2(158.87,108.83) 158.87,106.21 163.47,101.62 168.84,101.62 171.54,98.91 171.54,96.82 176.42,91.94 176.42,85.06 180.53,80.95 180.53,79.75 185.15,75.13 185.15,65.92 185.59,65.47 185.59,60.01 v2(185.98,59.63)
  BOTTOM w0.076: 150.42,105.34 150.2,105.12 149.36,105.12 147.45,103.21 UC1.A9
  BOTTOM w0.102: v2(158.87,108.83) 158.87,109.25 156.76,111.36 153.52,111.36 151.72,109.55 150.19,109.55 149.61,108.97 149.61,107.36 149.86,107.12 150.3,107.12 150.43,106.98 RPC14.3 150.43,105.34 150.42,105.34
USB_OC#2_3: length 220.1
  TOP w0.102: v2(33.71,44.57) 35.24,46.09 35.24,59.22 29.32,65.13 29.32,93.51 29.71,93.91 29.71,98.73 v1(32.98,102) 38.98,108 38.98,112.06 v2(39.12,112.2)
  IN1 w0.102: v2(155.19,109.4) 155.19,110.3 153.66,111.83 144.38,111.83 143.81,112.4 137.1,112.4 136.78,112.72 122.36,112.72 121.52,111.88 120.82,111.88 120.41,111.47 110.09,111.47 109.91,111.28 105.97,111.28 105.09,112.17 105.09,112.89 104.7,113.28 102.99,113.28 102.55,112.83 102.55,112.39 101.7,111.54 99.12,111.54 98.99,111.41 97.46,109.88 94.27,109.88 93.28,110.88 87.98,110.88 87.21,110.1 77.42,110.1 76.65,109.34 75.37,109.34 75.05,109.66 74.29,109.66 73.86,109.22 73.2,109.22 73.02,109.4 73.02,110 70.21,112.81 39.73,112.81 v2(39.12,112.2)
  BOTTOM w0.076: UC1.C9 147.45,101.55 147.95,102.05 147.95,103.24 149.44,104.74 151.16,104.74 151.43,105.01 151.43,105.34
  BOTTOM w0.102: v2(33.71,44.57) 32.82,44.57 32.11,45.28 CI47.1 30.28,45.77 29.33,46.72 UI7.3 ; 151.43,105.34 RPC14.1 151.43,106.79 152.14,107.5 152.14,108.75 153.23,109.85 154.74,109.85 v2(155.19,109.4)
USB_OC#4_5: length 7.2
  BOTTOM w0.076: 149.15,105.34 149,105.18 148.97,105.18 v1(148.82,105.04) 148.65,104.86 148.65,104.64 147.13,103.13 147.13,101.03 147.45,100.71 UC1.D9
  BOTTOM w0.102: RPC14.4 149.93,106.11 149.15,105.34
USB_OC#6_7: length 6.8
  BOTTOM w0.076: UC1.B9 147.76,102.27 147.76,103.28 149.39,104.91 150.7,104.91 150.93,105.15 150.93,105.34
  BOTTOM w0.102: RPC14.2 150.93,106.54 150.93,105.34
VCI_IN1: length 6
  TOP w0.102: RE370.1 147.65,3.74 v1(146.31,2.4) 144.76,2.4 144.2,2.96 UE5.126
VCIN0_PH: length 142.2
  TOP w0.076: HE1.1 112.15,85.72 CE26.1 111.83,79.76 111.31,79.24 108.9,79.24 106.23,76.57 105.76,76.57
  TOP w0.102: RE333.1 RE332.1 ; RE332.1 152.73,18.34 v2(152.35,17.96) ; RE332.1 153.31,17.99 RE375.2 ; v2(94.48,76.19) 94.61,76.19 95.05,76.64 v1(97.21,76.64) 98.86,76.64 99.51,75.99 104.01,75.99 104.59,76.57 105.76,76.57
  IN1 w0.102: v2(152.35,17.96) 152.29,18.02 151.59,18.02 150.53,16.96 147.63,16.96 146.6,15.93 140.28,15.93 139.63,15.28 135.2,15.28 134.17,16.31 133.88,16.31 133.34,16.84 133.11,16.84 132.47,17.49 131.83,17.49 130.77,18.55 129.95,18.55 128.54,19.96 128.17,19.96 127.62,20.5 124.26,20.5 124.07,20.69 123.12,20.69 122.79,21.02 116.08,21.02 115.27,21.84 112.58,21.84 109.08,25.33 107.2,25.33 103.79,28.74 103.79,31.76 99.33,36.22 v2(93.85,36.22)
  IN3 w0.102: v2(94.48,76.19) 94.23,75.94 94.23,73.65 96.45,71.43 96.45,61.65 95.69,60.89 95.69,53.97 94.67,52.95 94.67,46.79 94.23,46.35 94.23,45.39 95.69,43.93 95.69,38.07 v2(93.85,36.22)
VCREF0: length 6.4
  TOP w0.102: v1(148.14,15.17) 148.14,15.14 ; 148.14,15.14 147.94,14.95 UE5.25 ; 148.14,15.14 149.23,16.23 CE81.1 RE383.1 151.56,16.23 151.76,16.44 RE380.2
VGA_EN: length 7.8
  TOP w0.254: v2(74.61,47.49) 73.79,48.3 PC801.1
  BOTTOM w0.203: v2(74.61,47.49) v1(74.61,46.92) 74.61,46.6 75.53,45.67 PU801.3
  BOTTOM w0.254: PR801.1 PR823.1 PC801.1 73.79,48.3 v2(74.61,47.49)
VID_PLLVDD:
  vias: v1(70.29,69.84) v2(71.26,75.95) v2(71.26,75.17)
VIDALERT_N: length 26.5
  IN3 w0.102: v2(97.78,112.89) 97.78,112.83 99.02,111.6 104.52,111.6 106.79,109.33 108.4,109.33 109.15,108.58 109.15,108.43 108.5,107.78 108.5,107.64 108.65,107.49 108.79,107.49 109.24,107.94 109.38,107.94 109.52,107.8 109.52,107.65 109.08,107.21 109.08,107.06 109.22,106.92 109.36,106.92 109.81,107.36 109.96,107.36 110.55,106.77 114.37,106.77 114.99,107.4 v2(114.99,108.32)
  BOTTOM w0.102: PR607.1 97.59,113.08 v2(97.78,112.89) ; RC180.2 v2(114.99,108.32) 114.99,108.75 RC179.2
VIDSCLK: length 29.1
  IN3 w0.102: v2(115.63,108.32) 115.47,108.17 115.47,107.2 114.57,106.29 108.9,106.29 104.07,111.12 98.8,111.12 97.76,112.16 v2(97.76,112.26)
  BOTTOM w0.076: UC1.A63 116.15,102.79 116.15,103.91 116.63,104.39 116.63,104.47 115.83,105.27 115.63,105.27 115.56,105.34
  BOTTOM w0.102: v2(97.76,112.26) 97.71,112.21 PR606.1 ; 115.56,105.34 v1(115.56,105.85) 115.56,108.26 v2(115.63,108.32)
VIDSOUT: length 31.8
  IN3 w0.102: v2(97.78,113.53) 99.23,112.08 104.72,112.08 106.98,109.83 108.73,109.83 111.31,107.26 114.17,107.26 114.51,107.6 114.51,108.17 v2(114.36,108.32)
  BOTTOM w0.076: 113.77,105.34 113.46,105.02 113.46,104.72 113.58,104.59 114.25,104.59 114.52,104.32 115.04,104.32 115.82,103.53 115.82,102.03 116.09,101.76 116.09,101.52 115.8,101.23 UC1.D64
  BOTTOM w0.102: RC181.2 v2(114.36,108.32) 114.48,108.2 114.48,106.35 114.36,106.23 113.9,106.23 113.77,106.1 v1(113.77,105.66) 113.77,105.34 ; PR609.1 97.36,113.72 97.59,113.72 v2(97.78,113.53)
VL: length 1.5
  BOTTOM w0.102: PC126.1 64.83,30.66 v1(65.65,31.49)
VR_ALERT#: length 2.4
  BOTTOM w0.102: PU602.36 93.43,113.64 PR625.2
VR_CAP: length 2.6
  TOP w0.102: UE5.18 148.42,12.15 C5231.1
VR_SCLK: length 2.5
  BOTTOM w0.102: PR618.2 v1(93.02,112.8) 92.59,113.24 PU602.37
VR_SDA: length 2.2
  BOTTOM w0.102: PU602.35 92.7,114.04 92.75,114.08 v1(93.06,114.08) 93.88,114.08 PR626.2
VRALERT#: length 14.9
  TOP w0.076: 144.92,82.08 144.77,82.23 144.77,83.56 144.58,83.75 144.58,84.41 144.88,84.7 144.88,85.49 145.33,85.94 v2(145.33,85.94)
  TOP w0.102: 144.92,82.08 145.09,81.91 145.09,80.82 v1(149.09,76.82) 150.3,75.61 RC115.2
  BOTTOM w0.076: v2(145.33,85.94) 145.74,86.35 UC1.AM11
VRAM_ID1: length 52.9
  IN1 w0.076: v2(147.19,85.25) 147.55,84.89 147.55,81.72 151.55,77.72 152.08,77.72 152.65,77.14
  IN1 w0.102: 152.65,77.14 153.64,76.16 158.55,76.16 158.8,75.91 160.24,75.91 160.71,75.43 v2(161.11,75.43)
  BOTTOM w0.076: UC1.AP8 147.38,85.05 v2(147.19,85.25)
  BOTTOM w0.102: RC317.1 164.6,91.24 RC320.1 166.47,90.75 169.32,90.75 v1(170.76,89.3) 173.63,86.44 173.63,79.1 171.48,76.95 167.91,76.95 166.99,76.03 163.56,76.03 162.96,75.43 v2(161.11,75.43)
VRAM_ID2: length 53.3
  BOTTOM w0.076: 151.19,77.14 151.06,77.14 148.96,79.24 148.46,79.24 147.88,79.81 147.88,80.38 148.08,80.57 148.08,81.65 148.35,81.93 UC1.AW7
  BOTTOM w0.102: 151.19,77.14 151.47,76.86 151.93,76.86 153.28,75.5 154.3,75.5 155.14,74.67 159.31,74.67 159.59,74.39 161.13,74.39 161.69,74.96 163.13,74.96 163.75,75.57 167.18,75.57 168.08,76.47 171.65,76.47 174.19,79.01 v1(174.19,86.03) 174.19,86.82 167.42,93.59 166.54,93.59 RC321.1 RC316.1
VREF_VGA: length 2
  BOTTOM w0.254: 79.43,43.11 80.77,43.11 v1(81.21,43.55)
VSA_SEN+: length 81.2
  TOP w0.254: v2(141.28,114.86) 141.47,114.67 141.47,111.27 140.73,110.53 140.73,106.84 137.92,104.03 137.92,101.78 138.42,101.27 139.12,101.27 139.34,101.06 139.34,99.77 139.18,99.62 RC227.1 139.36,99.38 139.36,98 139.63,97.74 v1(140.28,97.74) v2(140.75,98.21) ; v2(91.75,117.97) 91.63,118.1 PC650.1 PR649.2 91.1,119.02 PC652.1 PC640.2
  IN3 w0.254: v2(91.75,117.97) 91.7,117.97 91.43,118.24 91.43,119.34 92.99,120.9 106.56,120.9 107.45,120.01 121.5,120.01 122.58,118.93 139.5,118.93 140.39,118.04 140.39,116.13 141.38,115.15 141.38,114.96 v2(141.28,114.86)
  BOTTOM w0.254: v2(140.75,98.21) 141.02,97.94 UC1.H20
VSA_SEN-: length 81.8
  TOP w0.254: v2(141.92,114.86) 141.85,114.8 141.85,111.12 141.11,110.37 141.11,106.69 138.3,103.88 138.3,101.94 138.58,101.65 139.38,101.65 140.3,100.73 RC228.1 140.27,100.67 v1(140.27,99.31) 140.27,98.51 139.96,98.19 v2(139.81,98.19) ; PC650.2 89.66,117.54 v2(89.66,117.47) 89.66,116.53 PC649.1
  IN3 w0.254: v2(141.92,114.86) 141.76,115.02 141.76,115.31 140.77,116.29 140.77,118.2 139.66,119.31 122.74,119.31 121.66,120.39 107.61,120.39 106.72,121.28 92.83,121.28 89.66,118.1 v2(89.66,117.47)
  BOTTOM w0.203: v2(89.66,117.47) 89.56,117.37 PU602.26
  BOTTOM w0.254: v2(139.81,98.19) 140.07,97.94 UC1.H21
VTTREF_1.35V: length 1.8
  BOTTOM w0.203: PU200.4 84.9,11.55 84.26,10.91 PC210.1
WL_OFF#_R: length 4.1
  TOP w0.102: RM8.2 186.54,66.27 186.25,66.56 v2(186.19,66.56) 186.79,67.17 DM1.2
  BOTTOM w0.102: JNGFF.48 186.23,66.53 v2(186.19,66.56) v1(186.19,67.31)
WLAN_RADIO_DIS#: length 68.6
  TOP w0.102: DM1.1 187.06,71.17 189.29,73.4 189.29,80.13 v1(186.11,83.3) 185.1,84.32 182.3,84.32 180.02,86.61 177.66,86.61 175.18,89.08 v2(174.55,89.08)
  IN1 w0.076: v2(153.88,104.82) 153.78,104.72 153.78,103.98 153.91,103.85 154.39,103.85 154.46,103.78 154.87,103.78
  IN1 w0.102: v2(174.55,89.08) 174.65,89.18 174.65,91.84 166.21,100.28 162.89,100.28 159.38,103.78 154.87,103.78
  BOTTOM w0.076: UC1.B7 148.58,102.08 149.74,103.24 149.74,103.51 150.12,103.89 153.05,103.89 153.88,104.71 v2(153.88,104.82) 154.08,104.82 154.6,105.34
  BOTTOM w0.102: RC224.2 155.48,106.21 154.6,105.34
XCLK_BIASREF: length 3.2
  TOP w0.254: RC96.1 126.89,100.44 RC124.1 128.34,100.44 128.87,99.91 v2(128.87,99.53)
  BOTTOM w0.254: UC1.E42 128.51,99.89 v2(128.87,99.53)
XDP_ITP_PMODE: length 10.6
  BOTTOM w0.076: 152.88,105.34 152.74,105.2 152.74,104.61 152.34,104.22 149.98,104.22 149.41,103.65 149.41,103.37 148.94,102.91 148.44,102.91 148.3,102.77 148.3,101.51 148.23,101.43 148.23,101.21 148.3,101.13 148.3,100.85 147.61,100.16 UC1.E8
  BOTTOM w0.102: RC31.2 153.66,106.13 152.88,105.34
XDP_OBS0_R: length 6.9
  BOTTOM w0.076: 122.75,105.34 122.12,104.7 122.08,104.7 121.02,103.65 121.02,103.12 120.72,102.81 120.72,101.68 UC1.C55
  BOTTOM w0.102: T16.1 122.8,107.5 122.8,105.39 122.75,105.34
XDP_OBS1_R: length 6.5
  BOTTOM w0.076: T19.1 123.63,104 122.23,104 122.04,103.81 122.04,102.98 121.58,102.51 121.58,101.8 121.55,101.74 121.55,101.49 121.63,101.33 121.63,101.22 121.4,100.99 UC1.D55
XDP_OBS2_R: length 5.7
  BOTTOM w0.076: UC1.B54 121.05,102.24 121.05,102.82 121.24,103.01 121.24,103.63 122.12,104.51 122.74,104.51 123.56,105.34
  BOTTOM w0.102: 123.56,105.34 123.69,105.46 T10.1
XDP_OBS3_R: length 5.9
  BOTTOM w0.076: UC1.C56 120.19,101.49 120.55,101.85 120.55,102.9 120.83,103.18 120.83,103.81 122.36,105.34
  BOTTOM w0.102: 122.36,105.34 T11.1
XDP_PRDY#: length 5.6
  BOTTOM w0.076: UC1.D56 119.98,100.99 119.9,101.26 119.9,101.37 119.82,101.65 119.78,101.8 119.76,101.85 119.76,102.1 119.77,102.12 119.78,102.13 119.78,102.16 119.8,102.19 119.8,102.4 119.76,102.47 119.76,102.84 120.04,103.12 120.04,103.22 120.26,103.44 120.26,105.34
  BOTTOM w0.102: T4964.1 120.26,105.78 120.26,105.34
XDP_PREQ#: length 5
  BOTTOM w0.076: UC1.D61 117.99,100.93 117.99,101.11 118.01,101.13 118.01,101.5 117.99,101.52 117.99,101.76 118.01,101.78 118.01,102.75 117.78,102.97 117.78,103.06 117.76,103.08 117.76,104.8 T4963.1
XDP_SPI_IO2: length 1.8
  BOTTOM w0.102: RC21.2 157.09,78.92 157.98,78.03 RC46.1
XDP_SPI_SI: length 1.8
  BOTTOM w0.102: RC9.2 157.33,78.03 RC44.2
XTAL24_IN: length 11.4
  BOTTOM w0.076: UC1.E37 131.54,100.27 v1(131.54,104.89) 131.54,105.34
  BOTTOM w0.102: 131.54,105.34 131.56,105.36 CC13.1 RC92.2 132.43,106.97 132.7,107.24 132.7,108.86 YC1.1
XTAL24_OUT: length 9.7
  BOTTOM w0.076: 133.34,105.34 v1(133.34,105.02) 133.34,104.94 132.3,103.9 132.3,100.52 132.07,100.29 UC1.E35
  BOTTOM w0.102: YC1.3 134.2,107.86 CC12.1 RC92.1 133.34,105.34
XTAL_OUT: length 15.4
  BOTTOM w0.102: UV1.B10 68.24,84.6 67.63,85.21 67.63,87.33 68.81,88.51 68.89,88.51 68.99,88.61 68.99,89.03 69.09,89.13 69.3,89.13 69.4,89.03 69.4,88.61 69.5,88.51 69.7,88.51 69.8,88.61 v1(69.8,88.89) 69.8,89.03 69.91,89.13 70.11,89.13 70.21,89.03 70.21,88.67 70.31,88.57 73.27,88.57 75.67,90.97 RV24.1
XTAL_OUT_R: length 4.5
  BOTTOM w0.102: YV1.3 76.96,94.74 76.96,93.07 CV36.1 RV24.2
XTAL_OUTBUFF: length 12.3
  TOP w0.102: v2(75.91,89.04) 75.91,89.23 RV23.1
  BOTTOM w0.102: UV1.C10 68.75,84.23 69.3,84.23 69.54,84.47 69.54,84.73 69.84,85.03 69.84,85.79 70.43,86.38 73.02,86.38 v1(75.26,88.62) 75.68,89.04 v2(75.91,89.04) RV20.1
XTALIN: length 19.1
  BOTTOM w0.102: UV1.C11 67.88,84.2 68.44,84.2 68.71,84.48 68.71,84.88 68.61,84.98 68.14,84.98 67.86,85.27 67.86,87.24 68.91,88.28 73.49,88.28 v1(75.62,90.42) 76.52,91.31 77.22,91.31 77.51,91.61 CV37.1 77.51,93.47 YV1.1
XTLI: length 4.2
  BOTTOM w0.102: YL2.1 176.04,108.6 175.88,108.44 175.88,107.75 CL36.2 175.77,106.88 UL1.29
XTLO: length 5.1
  BOTTOM w0.102: UL1.28 175.37,107.35 CL37.2 175.57,107.55 175.57,109.34 174.71,110.2 YL2.3
N16662246: length 6.3
  TOP w0.102: v1(196.34,25.07) 196.16,24.9 v2(196.16,24.54)
  TOP w0.203: v2(196.16,24.54) 195.82,24.54 195.38,24.1 RA12.2
  BOTTOM w0.203: UA1.27 195.13,23.07 194.72,23.48 194.72,23.48 194.18,24.02 CA62.2 194.53,24.79 195.91,24.79 v2(196.16,24.54)
N16662258: length 5
  BOTTOM w0.203: CA63.2 201.86,23.61 201.86,22.33 v1(201.1,21.58) 200.48,20.95 200.23,20.95 200.17,20.89 UA1.39
N16662270: length 3.1
  TOP w0.102: CA64.2 196.02,15.68 v2(196.53,15.17) v1(197.03,15.17)
  BOTTOM w0.102: UA1.7 196.33,15.37 v2(196.53,15.17)
N16662316: length 3
  TOP w0.254: CA24.1 199.78,22.28 v2(200.34,22.28)
  BOTTOM w0.102: v2(200.34,22.28) 200.84,22.79 v1(200.84,23.04)
  BOTTOM w0.254: v2(200.34,22.28) 200.34,22.15 199.87,21.69 UA1.37
N16662328: length 2.9
  TOP w0.102: CA24.2 v1(197.54,22.53)
  TOP w0.254: v2(198.61,23.37) CA24.2
  BOTTOM w0.203: v2(198.61,23.37) 198.61,23.23 198.33,22.95 UA1.35
N16662332: length 3.9
  BOTTOM w0.102: CA25.2 200.01,23.85 v1(200.53,24.38)
  BOTTOM w0.203: CA25.2 198.41,23.85 198.15,23.6 198.15,23.25 197.93,23.03 UA1.34
N16662348: length 1.8
  BOTTOM w0.203: UA1.28 195.53,23.16 195.26,23.43 CA23.2
N16662926: length 4.7
  BOTTOM w0.102: UA1.4 197.53,15.73 198.81,14.44 RA1113.2 198.81,13.96 199.89,12.88 v1(199.89,12.69)
N17072999: length 3
  TOP w0.203: U2301.12 170.22,15.59 169.96,15.85 v2(169.96,15.93)
  BOTTOM w0.254: C5216.1 168.84,16.63 v1(169.13,16.34) 169.54,15.93 v2(169.96,15.93)
N17073002: length 3.2
  TOP w0.203: v2(171.18,15.96) 171.02,15.8 U2301.10
  BOTTOM w0.254: C5217.1 169.73,16.88 170.07,16.54 v1(170.53,16.54) 170.64,16.54 171.18,16.01 v2(171.18,15.96)
N17200666: length 2
  TOP w0.102: US2.7 185.72,14.85 RS19.2
N17200720: length 6.6
  TOP w0.102: RS25.2 179.88,15.47 179.63,15.23 v1(179.63,14.98) 179.83,14.79 182.56,14.79 182.94,14.41 184.08,14.41 184.22,14.26 US2.10
N17335389: length 4.1
  BOTTOM w0.102: RM14.2 183.65,55.87 184.18,56.4 v1(184.58,56.4) 185.36,56.4 185.98,57.02 JNGFF.47
N17415515:
  vias: v3(24.06,113.91)
N17932877: length 2.4
  TOP w0.102: RX10.2 v1(24.46,72.87)
  TOP w0.508: RX10.2 23.98,73.97 23.87,74.08 UX4.3
N17933717: length 2.2
  BOTTOM w0.102: v1(186.44,94.49) RL40.2 187.51,94.96 187.57,95.03 UL3.3
N18624295: length 12.1
  TOP w0.102: QI2.3 14.9,42.17 14.45,42.63 v3(14.45,49.97) 14.45,51.9 14.04,52.3 JLED.7
N18624308: length 14.5
  TOP w0.102: JLED.6 13.93,53.3 v2(14.15,53.08) 14.66,52.57 v3(15.17,52.57) ; RI1.3 v2(16.88,43.11)
  IN2 w0.102: v2(14.15,53.08) 14.41,52.82 14.41,50.22 16.88,47.75 v2(16.88,43.11)
N18894766: length 2.9
  TOP w0.102: PC640.1 v1(89.33,121.01)
  TOP w0.254: v2(88.52,119.57) 88.51,119.57 88.94,120.01 PC640.1
  BOTTOM w0.254: v2(88.52,119.57) 89.03,119.07 PR646.2
N18894780: length 3
  TOP w0.102: PC601.1 87.23,118.74 v1(86.86,118.74)
  TOP w0.254: PR652.2 88.42,118.15 PC601.1
N18894857: length 4.2
  BOTTOM w0.203: PU602.28 90.36,116.9 90.94,117.48 v1(91.88,117.48)
  BOTTOM w0.254: PR636.1 PC632.1 92.31,117.71 92.08,117.48 v1(91.88,117.48)
N18894871: length 67.2
  IN2 w0.254: v2(156.84,120.45) 156.71,120.45 156.08,121.09 145.34,121.09 144.58,120.32 144.58,119.39 144.25,119.05 123.16,119.05 121.82,120.39 98.8,120.39 97.59,119.18 97.59,118.03 v2(97.94,117.69)
  BOTTOM w0.254: PH604.1 156.84,121.31 v2(156.84,120.45) ; v2(97.94,117.69) 97.84,117.78 95.87,117.78 PR642.2
N19050685: length 3.6
  TOP w0.102: RI57.1 18.73,79.82 18.73,81.78 19.11,82.16 19.11,82.18 UI8.24
N19050753: length 2.8
  TOP w0.102: UI8.7 24.54,82.18 RI56.1 v1(25.25,80.45)
N19073745: length 4.3
  TOP w0.102: UC5.12 177.76,78.63 177.86,78.73 CC95.1 177.41,80.05 176.03,80.05 v1(175.76,80.32)
N19073816: length 3.7
  TOP w0.102: v1(179.89,80.57) 179.89,80.26 179.24,79.61 CC94.1 178.56,79.42 UC5.10
N19607621: length 4.7
  TOP w0.102: v1(194.24,70.86) 194.24,72.06 194.61,72.43 QX5.2
  TOP w0.254: QX5.2 195.94,72.43 196.84,73.33 RX15.1
N19675639: length 3.2
  TOP w0.102: v1(18.22,68.89) 18.97,68.14 C5220.1 18.91,67.37 U2409.6
N19901660: length 2.1
  TOP w0.102: CE76.1 134.5,22.75 R2454.1 134.16,22.41 v1(133.44,22.41)
N20173639: length 19.9
  TOP w0.102: v2(155.81,4.39) RE369.1 RE371.1 155.81,1.91 v1(156.2,1.52) ; UE5.120 v2(141.8,5.45)
  IN1 w0.102: v2(155.81,4.39) 154.92,3.5 143.76,3.5 v2(141.8,5.45)
N20440449: length 3.6
  TOP w0.102: CE73.1 RE346.1 v1(137.22,20.88) 136.6,20.27 UE5.54
N20880735: length 0.9
  BOTTOM w0.254: PR308.1 181.78,49.09 PC307.2
N21609269: length 4.6
  TOP w0.102: RV111.2 63.77,100.19 v1(64.13,100.19) 64.57,100.19 65.3,100.93 65.83,100.93 65.9,100.85 66.62,100.85 UV5.L8
N23042445: length 4.7
  TOP w0.102: v1(66.99,87.68) RV21.1 67.88,86.62 v2(68.27,87)
  BOTTOM w0.102: UV1.A10 68.51,85.59 68.51,86.41 68.77,86.67 68.77,86.87 68.64,87 v2(68.27,87)
N23677896: length 2.5
  TOP w0.102: v1(87.81,60.51) 87.81,61.13 CV83.1
  TOP w0.203: CV83.1 88.2,61.51 UV10.12
N23677916: length 3.5
  TOP w0.102: v1(86.29,62.86) 87.64,62.86 CV67.1
  TOP w0.203: UV10.10 88.18,62.31 CV67.1
N23700319: length 6.9
  TOP w0.508: PR6.2 v1(19.67,102.92) 19.67,103.67 20.38,104.39 PL2.1 21.7,105.23 21.96,105.49 PQ6.1
N24017484:
  vias: v1(68.45,80.76) v2(67.17,80.36) v2(67.76,80.47)
N24019691: length 2.3
  BOTTOM w0.254: v2(71.16,79.87) 70.59,79.87 UV1.G8 69.9,80.56 UV1.G9
  vias: v1(76.07,78.99)
N24050156: length 2
  TOP w0.076: v1(57.52,81.33) 57.93,81.74 v2(57.98,81.74) 58.09,81.85 RV82.1
  BOTTOM w0.102: v2(57.98,81.74) 57.98,81.71 UV1.F22
N24050174: length 1.9
  TOP w0.076: v1(59.11,78.92) 58.75,78.56 v2(58.75,78.43)
  TOP w0.102: v2(58.75,78.43) 58.72,78.4 RV83.1
  BOTTOM w0.127: v2(58.75,78.43) 58.36,78.82 UV1.J22
N25003853: length 9.2
  TOP w0.076: T14.1 119.25,74.81 v2(118.53,75.53)
  BOTTOM w0.076: v2(118.53,75.53) 118.28,75.78 118.28,76.28 118.51,76.52 118.6,76.52 119.48,77.4 119.52,77.4 120.52,78.4 120.52,78.98 120.31,79.18 120.31,79.65 120.45,79.79 120.45,80.09 120.4,80.2 120.4,80.42 120.45,80.53 120.45,80.74 120.42,80.82 120.42,81.1 120.42,81.1 120.45,81.16 120.45,81.47 120.4,81.52 120.4,81.72 UC1.AW56
N25003855: length 8.9
  BOTTOM w0.076: UC1.AY56 120.19,81.08 119.92,80.82 119.92,80.53 119.77,80.17 119.77,80.15 119.77,79.73 119.82,79.68 119.82,78.89
  BOTTOM w0.102: 119.82,78.89 117.57,76.64 117.57,73.61 T15.1
N25004858: length 2.3
  TOP w0.076: T22.1 122.93,85.59 122.93,84.49 v2(122.52,84.09)
  BOTTOM w0.076: UC1.AT52 122.59,84.09 v2(122.52,84.09)
N26262691:
  vias: v1(194.87,83.56)
N26277151: length 2.2
  TOP w0.102: RL39.2 174.3,105.87 v2(174.3,106.43) 174.3,106.61 v1(174.62,106.93)
  BOTTOM w0.102: v2(174.3,106.43) 174.57,106.16 UL1.26
N26278721: length 2.4
  TOP w0.102: v2(176.84,106.51) v1(176.84,107.05)
  TOP w0.254: v2(176.84,106.51) 176.59,106.25 RL31.2
  BOTTOM w0.254: UL1.31 176.57,106.24 v2(176.84,106.51)
N26280117: length 9.4
  TOP w0.102: v2(182.05,108.39) v1(182.05,109.02)
  TOP w0.508: v2(182.05,108.39) 181.78,108.12 CL41.2
  BOTTOM w0.508: TL2.3 182.17,104.58 182.94,105.34 182.94,107.5 v2(182.05,108.39) TL2.6
N26468807: length 2.6
  TOP w0.102: RS22.2 RS20.2 185.35,8.6 185.22,8.73 185.22,9.97
N26505655: length 3.5
  TOP w0.102: PR604.2 v2(95.56,113.08) v1(93.97,113.08)
  BOTTOM w0.102: PR607.2 v2(95.56,113.08) PR625.1
N26505659: length 2.5
  TOP w0.102: v1(95.03,112.22) v2(95.54,112.22) 96.16,112.22 PR601.2
  BOTTOM w0.102: PR618.1 v2(95.54,112.22) 96.19,112.22 PR606.2
N26505677: length 2.5
  TOP w0.102: PR605.2 95.56,113.97 v2(95.56,113.97) v1(94.99,113.97)
  BOTTOM w0.102: PR609.2 95.57,113.96 v2(95.56,113.97) PR626.1
N26506002: length 5.8
  BOTTOM w0.102: v1(95.5,108.26) 95.22,108.26 PR616.2
  BOTTOM w0.203: PU602.40 92.36,112.04 92.58,111.81 92.58,111.24 93.49,110.33 93.49,110 PR616.2
N26506037: length 3.2
  BOTTOM w0.203: PU602.39 92.4,112.44 93.02,111.81 v1(93.02,111.37) 93.04,111.37 PR612.2
N26506689: length 2.8
  BOTTOM w0.203: PU602.38 92.45,112.84 93.31,111.97 93.34,111.97 PR678.2
N26508248: length 5
  TOP w0.102: PR602.1 93.5,115.47 v1(93.34,115.31)
  TOP w0.254: v2(93.72,114.67) 94.32,115.27 PR602.1
  BOTTOM w0.203: PU602.34 93.48,114.44 v2(93.72,114.67) 94.24,115.19 PC603.1
N26508256: length 6
  TOP w0.102: v1(94.32,117.66) PR603.1
  TOP w0.254: PR603.1 93.87,116.67 v2(93.47,116.26)
  BOTTOM w0.203: PC604.1 93.61,116.66 93.47,116.51 v2(93.47,116.26) 93.47,116.13 93.59,116.01 93.59,115.37 93.06,114.84 PU602.33
N26509112: length 3.5
  TOP w0.102: PR608.1 92.08,114.09 v1(92.64,113.53)
  TOP w0.254: PR608.1 92.45,114.48 92.77,114.8 v2(92.77,115.31)
  BOTTOM w0.203: PU602.32 92.69,115.24 v2(92.77,115.31)
N26509117: length 3.6
  TOP w0.102: v1(92.32,116.39) 92.08,116.15 PR611.1
  TOP w0.254: v2(93.08,115.82) 92.53,115.82 PR611.1
  BOTTOM w0.203: PU602.31 92.33,115.64 92.51,115.82 v2(93.08,115.82)
N26519264: length 39.3
  TOP w0.254: v2(82.99,119.43) 82.23,119.43 v2(81.41,118.62)
  BOTTOM w0.254: PR657.2 v2(81.41,118.62) ; PH605.1 116.9,120.39 111.22,120.39 v1(111.12,120.29) 96.74,120.29 95.66,121.37 83.84,121.37 82.99,120.51 v2(82.99,119.43)
N26519948: length 6.8
  TOP w0.254: v2(86.1,117.47) 85.27,118.29 v2(85.27,119.43)
  BOTTOM w0.203: PU602.20 86.6,115.64 86.43,115.8 86.43,116.82 86.1,117.15 v2(86.1,117.47) 86.22,117.47 PR640.1
  BOTTOM w0.254: PC630.1 85.27,119.99 v2(85.27,119.43)
N26522108: length 0.9
  BOTTOM w0.254: PR645.1 84.97,114.61 PC639.2
N26523008: length 2.3
  TOP w0.102: PC647.2 v1(83.17,111.19)
  TOP w0.254: PR650.2 83.18,112.15 PC647.2
N26523611: length 2.5
  BOTTOM w0.102: v1(81.78,112.83) 82.43,112.83 PC629.2
  BOTTOM w0.254: PR639.1 83.1,112.16 PC629.2
N26527807: length 28.4
  TOP w0.254: PR628.2 86.73,108.58 86.5,108.34 v2(86.5,106.99)
  IN1 w0.254: v2(87.81,96.51) 86.77,96.51 85.91,97.37 80.77,97.37 80.13,98 80.13,105.21 81.4,106.48 85.99,106.48 v2(86.5,106.99)
  BOTTOM w0.254: PH602.1 90.02,97.15 88.13,97.15 87.81,96.83 v2(87.81,96.51)
N26528911: length 4.9
  BOTTOM w0.203: PU602.8 88.36,110.77 87.62,110.04 86.72,110.04 86.48,109.8 v1(86.48,109.53)
  BOTTOM w0.254: v1(86.48,109.53) PR638.2 PC627.2
N26532119: length 2.3
  TOP w0.102: v1(91.71,106.56) 91.65,106.62 91.65,107.13 91.23,107.55 PC621.2
  TOP w0.254: PR623.1 90.86,108.18 90.86,107.93 PC621.2
N26532121: length 4.3
  TOP w0.254: PR623.2 90.43,109.53 90.1,109.53 89.59,110.04 v2(89.59,110.1)
  BOTTOM w0.203: PR622.2 89.59,109.73 v2(89.59,110.1) 89.56,110.13 PU602.5
  BOTTOM w0.254: PR621.2 90.21,109.46 PR622.2
N26533060: length 5.4
  TOP w0.102: PR617.2 92.36,110.2 v1(92.86,110.7)
  TOP w0.254: PR617.2 92.34,109.36 PC616.2 90.76,110.1 v2(90.23,110.1)
  BOTTOM w0.203: v2(90.23,110.1) 90.23,110.29 89.96,110.56 PU602.4
N26533062: length 1.9
  TOP w0.102: v1(93.34,107.43) 93.34,108.41 PC614.2
  TOP w0.254: PC614.2 93.27,108.47 PR617.1
N26533293: length 2.3
  BOTTOM w0.203: PU602.3 90.36,110.67 91.26,109.77 PR610.2
N26533871: length 4.5
  TOP w0.102: PC613.2 v1(90.04,110.87)
  TOP w0.254: v2(91.56,110.23) 91.03,110.76 PC613.2
  BOTTOM w0.203: PU602.2 90.76,110.77 91.31,110.23 v2(91.56,110.23)
  BOTTOM w0.254: v2(91.56,110.23) 91.56,110.1 92.13,109.53 PR613.2
N26554964: length 2.4
  BOTTOM w0.102: PC617.2 90.61,107.26 v1(90.61,106.35)
  BOTTOM w0.254: PR621.1 90.23,107.64 PC617.2
N26566701: length 2.2
  BOTTOM w0.102: PC631.1 88.33,120.45 v1(88.89,120.45)
  BOTTOM w0.254: PR630.2 87.8,119.91 PC631.1
N26806678: length 5.6
  BOTTOM w0.102: RV112.2 60.89,98.71 v1(60.73,98.54) 60.54,98.54 58.36,100.72 57.73,100.72 UV4.L8
N26836211: length 4.1
  TOP w0.102: UV7.L8 38.98,80.44 38.98,79.81 39.3,79.49 39.3,77.7 RV97.2
N26836537: length 5.7
  TOP w0.102: UV6.L8 38.92,66.03 38.92,63 RV98.2 38.86,62.68 38.4,62.22 38.4,61.83 v1(37.9,61.33)
N26838068: length 4.5
  BOTTOM w0.102: RV114.2 75.23,101.97 v1(74.54,101.97) 73.34,100.77 72.32,100.77 71.91,101.18 UV8.L8
N26838394: length 4.1
  TOP w0.102: UV9.L8 52.13,101.18 51.78,100.83 v1(49.65,100.83) 49.28,100.83 RV116.2
N26894462: length 4.1
  BOTTOM w0.102: UV15.L8 38.52,86.05 38.93,86.46 38.93,86.86 38.98,86.91 v1(38.98,88.48) 38.98,88.93 RV101.2
N26894764: length 6.1
  BOTTOM w0.102: UV14.L8 38.84,71.55 38.84,72.27 38.77,72.34 38.77,72.68 40.09,74 40.86,74 v1(41.08,74.22) 41.08,74.73 40.95,74.86 RV99.2
N27802877: length 12.2
  TOP w0.102: RC127.2 152.27,74.92 147.06,80.13 v1(147.06,80.51) 147.06,82.59 v2(146.24,83.4)
  BOTTOM w0.076: v2(146.24,83.4) 146.59,83.75 UC1.AT10
N27802878: length 15.2
  TOP w0.089: v2(148.07,83.32) 147.88,83.13 147.88,81.12 149.83,79.18 149.83,78.67 151.12,77.37
  TOP w0.102: 151.12,77.37 151.9,76.6 155.54,76.6 v1(155.87,76.27) 156.27,75.87 RC126.2
  BOTTOM w0.076: UC1.AU8 147.83,83.32 v2(148.07,83.32)
N27802879: length 16.1
  TOP w0.076: v2(148.98,83.32) 149.53,82.77 149.53,80.31 150.66,79.18
  TOP w0.089: 154.87,77.4 152.11,77.4 150.66,78.84 150.66,79.18
  TOP w0.102: 154.87,77.4 156.27,77.4 v1(158.2,75.46) 158.93,74.73 RC125.2
  BOTTOM w0.076: UC1.AU7 148.77,83.1 v2(148.98,83.32)
N27811001: length 9.7
  IN3 w0.102: v2(109.85,112.01) 109.85,110.74 112.26,108.32 v2(112.83,108.32)
  BOTTOM w0.102: v2(109.85,112.01) 109.85,111.12 109.61,110.88 UC12.4 ; RC113.2 v2(112.83,108.32) RC116.1 112.19,106.99 v1(111.75,106.99)
N27812400: length 8.2
  BOTTOM w0.076: UC1.A7 148.88,102.61 149.57,103.31 149.57,103.58 150.05,104.06 152.56,104.06 152.84,104.34 153.22,104.34 153.5,104.61 153.5,105.02 153.82,105.34 154.11,105.34
  BOTTOM w0.102: RC402.2 154.68,105.91 154.11,105.34
N27817142: length 2.4
  TOP w0.254: RC361.2 145.94,92.8 v2(145.94,93.02)
  BOTTOM w0.254: UC1.U12 145.52,93.57 145.94,93.15 v2(145.94,93.02) 146.15,93.22 146.15,93.54 UC1.U11
N27871984: length 8.1
  TOP w0.102: RC192.2 30.75,8.61 DC1.2 ; RC192.2 RC400.1 33.39,8.17 QC4.2 ; RC192.2 32.06,7.8 v1(32.38,7.48)
N27876104: length 11.4
  TOP w0.102: JKBBL.2 119.47,15.82 119.28,15.64 119.28,13.59 119.6,13.28 121.58,13.28 122.1,13.8 v3(122.1,16.88) 122.61,17.39 123.36,17.39 RE61.2
N28100651: length 2.7
  BOTTOM w0.102: RA1112.2 197.03,12.89 CA21.1 196.49,12.35 v1(195.32,12.35)
N28103940: length 4.8
  TOP w0.254: v2(189.31,23.61) 189.36,23.61 189.99,24.24 v1(189.99,25.67) 189.03,26.62 RA82.1
  BOTTOM w0.254: v2(189.31,23.61) 189.67,23.61 CA68.2
N28103942: length 3.8
  TOP w0.254: v2(189.31,24.25) v1(188.95,24.61) 188.72,24.85 188.72,25.79 188.14,26.36 RA80.1
  BOTTOM w0.254: v2(189.31,24.25) 189.79,24.25 CA67.2
N28204071: length 4.3
  TOP w0.102: CA65.2 v1(193.27,11.82)
  TOP w0.254: RA79.1 CA69.1 RA81.2 192.33,13.64 193.1,12.88 CA65.2
N28215693: length 15.6
  TOP w0.381: RL19.2 188.52,105.93 188.61,106.02 RL20.2 188.61,109.55 189.99,110.93 v1(192.27,110.93) 193.48,110.93 195.19,109.21 CL33.1
N28438430: length 1.3
  BOTTOM w0.102: PC304.1 v1(183.89,53.65)
N28438489: length 0.6
  TOP w0.102: v1(144.84,114.16) 145.28,114.16 v2(145.41,114.29)
  vias: v2(146.04,114.29)
N28438498: length 1.1
  TOP w0.102: PC611.1 v1(148.9,116.32)
N28483985:
  vias: v1(35.11,110.29)
N28484391: length 4.2
  TOP w0.102: v1(38.73,113.91) 37.95,114.69 PR28.2
  TOP w0.254: PR28.2 PC16.1 36.44,114.62 PQ2.3
N28484395: length 3.9
  TOP w0.102: v1(36.56,111.7) PR29.1
  TOP w0.254: PQ2.2 36.3,113.97 PC16.2 36.51,112.88 PR29.1
N28484412: length 4.8
  TOP w0.254: PQ2.5 32.51,113.97 32,113.47 PR33.2 PR31.1 31.57,112.01 32.38,112.01 v1(32.51,112.13)
N28484439: length 5.5
  BOTTOM w0.102: PR32.1 19.23,16.18 19.87,16.82 v1(19.87,18.09)
  BOTTOM w0.254: PQ3.5 20.11,16.36 19.75,16.01 PR32.1 18.36,15.13 PC14.2
N28484451:
  vias: v1(31.24,107.05)
N28656203: length 1.6
  TOP w0.102: FX1.2 v1(200.4,76.51)
N28656603: length 4.5
  BOTTOM w0.102: v1(199.38,74.41) 199.38,74.03 199.13,73.78 198.68,73.78 197.88,74.58 DX4.3 197.2,74.58 196.58,75.2 RX16.2
N28656604: length 4.5
  BOTTOM w0.102: v1(193.67,76.57) 193.67,76.16 194.49,75.33 195.11,75.33 195.58,75.81 RX17.2 196.32,75.2 DX4.2
N28712235: length 3.2
  BOTTOM w0.102: v1(77.91,105.08) 77.91,104.89 79.24,103.56 PC671.1
N28714854: length 3
  BOTTOM w0.102: v1(98.1,116.51) 98.41,116.82 99.7,116.82 100.36,116.16 PC655.2
N28714858: length 1.2
  BOTTOM w0.102: PR660.1 v1(98.1,114.95)
N28714964: length 3.3
  BOTTOM w0.102: PR659.1 v1(99.57,111.94)
  BOTTOM w0.254: PU603.1 101.85,113.98 101.02,113.15 100.78,113.15 PR659.1
N28745337: length 1.9
  BOTTOM w0.203: PU703.3 46.68,9.77 PR769.2
N28745341: length 1.9
  BOTTOM w0.203: PU703.4 46.28,10.34 46.09,10.15 PR770.2
N28745344: length 3.6
  TOP w0.381: PR737.1 28.72,35.02 PQ709.1
  TOP w0.508: v2(27.23,34.92) 27.43,34.73 PR737.1 28.43,33.86 PR763.1
  vias: v1(26.28,37.52) v2(26.79,37.33) v2(26.79,36.69) v2(26.79,36.06)
N28745361: length 6.9
  BOTTOM w0.102: PC750.1 51.3,15.87 v1(52.19,16.76)
  BOTTOM w0.203: PC750.1 50.6,14.66 49.46,14.66 48.72,13.92 PU703.27
N28745372: length 3.7
  BOTTOM w0.254: PC752.2 40.14,8.94 39.55,8.94 39.24,9.26 v2(39.24,9.55) 39.24,9.83 39.81,10.41 PR754.1
N28745397: length 2.1
  BOTTOM w0.203: PU703.5 45.88,10.57 45.21,9.9 PR777.2
N28745398: length 2.3
  BOTTOM w0.203: PU703.6 45.48,10.68 44.32,9.52 PR774.2
N28745401: length 2.7
  BOTTOM w0.203: PU703.7 45.08,10.79 44.38,10.09 44.06,10.09 43.44,9.47 PR775.2
N28745403: length 1.3
  BOTTOM w0.102: PR771.2 v1(48.44,20.76)
N28745412: length 1.5
  BOTTOM w0.102: v1(42.79,20.44) 43.17,20.06 PC757.2
N28745424: length 3.9
  BOTTOM w0.203: PU703.12 42.28,13.12 42.04,12.88 42.04,11.98 PR755.2
N28745425: length 2.6
  BOTTOM w0.203: PC708.1 42.7,13.92 PU703.14
  BOTTOM w0.254: PR776.1 41.56,14.14 PC708.1
N28745427: length 2.8
  BOTTOM w0.203: PU703.15 43.21,14.32 PC708.2
  BOTTOM w0.254: PC708.2 41.64,15.06 PR742.1
N28745442: length 3
  BOTTOM w0.203: PU703.31 48.62,12.32 48.82,12.12 49.26,12.12 PC747.1
  BOTTOM w0.254: PR740.2 50.79,12.77 PC747.1
N28745443: length 4.2
  BOTTOM w0.102: PR772.2 50.8,11.43 v1(50.09,10.72)
  BOTTOM w0.203: PU703.32 48.51,11.92 48.7,11.74 49.79,11.74 PC747.2
  BOTTOM w0.254: PC747.2 50.72,11.85 PR772.2
N28745445: length 2
  BOTTOM w0.203: PC750.2 49.33,13.96 48.89,13.52 PU703.28
N28745448: length 41.3
  TOP w0.254: v2(28.57,14.79) 26.54,16.82 26.54,19.36 25.9,19.99 24.31,19.99 23.42,20.88 v1(23.42,21.96) 23.42,24.38 PR773.1
  IN1 w0.254: v2(48.82,15.23) 48.82,13.83 48,13.01 48,12.18 47.17,11.36 39.36,11.36 37.62,9.62 32.78,9.62 28.57,13.83 v2(28.57,14.79)
  BOTTOM w0.203: PU703.25 48.51,14.72 48.82,15.04 v2(48.82,15.23)
N28745452: length 4
  BOTTOM w0.102: v1(50.41,16.82) 49.89,16.3 PR745.1
  BOTTOM w0.203: PR745.1 49.7,15.04 49.33,15.04 48.61,14.32 PU703.26
N28745458:
  vias: v1(48.57,16.76)
N28745460: length 3
  TOP w0.102: v2(43.87,15.99) v1(42.79,15.99)
  TOP w0.254: v2(43.87,15.99) 43.86,15.98 PR757.2
  BOTTOM w0.203: PU703.17 44.68,15.75 44.44,15.99 v2(43.87,15.99)
N28745463:
  vias: v1(35.74,37.84)
N28745469: length 1.8
  TOP w0.102: PR757.1 v1(44.77,16.3)
  TOP w0.254: PR779.2 PR757.1
N28745471: length 9.8
  TOP w0.102: v2(27.04,38.6) v1(27.04,38.03)
  TOP w0.381: PQ709.6 28.72,38.32 27.87,39.17 PR762.1
  TOP w0.508: PR762.1 27.35,39.6 27.04,39.3 v2(27.04,38.6)
  IN3 w0.254: v2(25.58,35.87) 25.58,37.14 v2(27.04,38.6)
  BOTTOM w0.381: v2(25.58,35.87) 25.42,36.03 PQ740.4
  BOTTOM w0.508: v2(27.04,38.6) 27.55,38.1 PQ718.4
N28745480: length 3.5
  TOP w0.508: v1(26.47,23.61) v2(26.47,24.18) 26.52,24.24 PC779.2 PR773.2
  BOTTOM w0.508: PQ717.4 v2(26.47,24.18)
N28745481:
  vias: v1(52.06,28.12) v2(48.44,27.99) v2(49.08,27.99) v2(50.29,27.99) v2(50.92,27.99)
N28745526: length 1
  TOP w0.508: PC779.1 v2(27.44,24.18)
  vias: v1(33.2,21.71)
N28745552: length 20.7
  BOTTOM w0.254: PR742.2 40.35,14.85 35.36,14.85 34.3,15.92 33.09,15.92 32.29,16.72 v1(28.57,16.72) 27.34,16.72 26.73,17.33 26.73,21.71 27.03,22.01 PR765.2
N28745555: length 21.4
  BOTTOM w0.254: PR776.2 40.32,14.47 35.2,14.47 34.16,15.51 v1(33.52,15.51) 32.96,15.51 32.16,16.31 27.2,16.31 26.35,17.17 26.35,21.71 26.04,22.01 PR765.3
N28745573: length 4
  TOP w0.102: PR738.1 29.81,33.37 30.31,33.37 v1(30.73,32.95)
  TOP w0.254: PQ709.2 29.37,34.75 PR737.2 29.34,33.86 PR738.1
N28745582: length 48.3
  IN3 w0.254: v2(37.52,34.6) 37.27,34.6 37.01,34.85 37.01,38.22 38.6,39.81 48.35,39.81 52.51,35.65 52.51,15.49 v2(52.63,15.36)
  BOTTOM w0.254: v2(37.52,34.6) 37.39,34.6 37.08,34.92 PR703.2 ; PR772.1 52.03,12.09 52.43,12.09 53.08,12.74 v1(53.08,13.33) 53.08,14.91 v2(52.63,15.36)
N28745583: length 45.4
  IN3 w0.254: v2(37.52,35.23) 37.39,35.36 37.39,38.06 38.76,39.42 48.19,39.42 52.13,35.49 52.13,15.49 v2(52,15.36)
  BOTTOM w0.254: PR703.3 37.97,34.92 37.65,35.23 v2(37.52,35.23) ; PR740.1 52.03,12.47 52.27,12.47 52.63,12.83 52.63,14.47 v1(52.38,14.72) 52,15.1 v2(52,15.36)
N28745613:
  vias: v1(41.14,20.69)
N28745644: length 4.7
  TOP w0.102: v1(31.62,40.5) 31.24,40.5 30.33,39.6 PR739.1
  TOP w0.254: PQ709.5 29.37,38.69 29.2,38.85 PR746.2 PR739.1
N28745648: length 1.4
  BOTTOM w0.102: PD704.1 v1(39.3,19.61)
N28745659: length 3.6
  TOP w0.102: PR744.1 30.68,34.28 v1(32.19,34.28)
  TOP w0.254: PQ709.3 30.02,34.94 PR744.1
N28745660: length 2.7
  BOTTOM w0.203: PU703.13 41.76,13.52 PR764.2
N28745668: length 2.5
  TOP w0.254: PQ711.1 35.13,14.75 35.49,15.1 v1(35.68,15.1) 36.44,15.1 PQ710.2
N28745686: length 1.7
  TOP w0.102: PR720.2 v1(22.66,40)
N28783709: length 2.9
  TOP w0.102: v1(22.21,70.53) RE400.2 CE61.2 22.2,68.63 QE9.3
N28784713: length 6.9
  TOP w0.102: RE402.2 21.33,70.41 21.77,70.86 24.19,70.86 v1(24.47,70.57) 24.82,70.22 QE8.1
N28883037: length 3.6
  TOP w0.102: 15.55,37.45 15.55,37.08 15.42,36.95 15.04,36.95 14.9,37.09 QI1.3 14.78,37.58 RI93.1 14.78,38.76 v1(14.28,39.26)
N28911604: length 3.9
  TOP w0.102: 16.2,39.36 QI2.6 ; 16.2,39.36 17.19,39.36 RI91.1 17.33,38.28 v1(17.27,38.22) ; 16.2,39.36 15.68,39.36 15.55,39.49 15.55,39.94
N28917899: length 106
  TOP w0.102: RPC5.5 182.29,25.59 179.89,27.99 v1(178.66,27.99) v2(177.6,27.99)
  IN3 w0.102: v2(154.72,81.03) 152.9,81.03 152.77,80.91 152.77,80.33 152.9,80.2 155.09,80.2 155.19,80.31 155.19,81.68 155.29,81.78 155.49,81.78 155.59,81.68 155.59,79.89 155.5,79.8 152.77,79.8 152.65,79.68 152.65,79.51 152.77,79.39 155.85,79.39 155.95,79.29 155.95,79.09 155.85,78.99 152.58,78.99 152.46,78.86 152.46,78.67 152.56,78.57 155.7,78.57 155.82,78.44 155.82,76.45 161.14,71.13 161.14,68.15 164.12,65.18 164.12,64.36 164.87,63.6 165.13,63.6 165.37,63.36 165.37,62.44 164.84,61.91 164.84,61.59 165.41,61.02 165.41,58.94 167.27,57.09 168.91,57.09 170.74,55.26 172.63,55.26 173.08,55.71 173.08,56.04 173.57,56.53 177.65,56.53 178.99,55.19 183.16,55.19 184.85,53.49 184.85,40.96 182.28,38.38 181.69,38.38 177.23,33.93 177.23,28.84 177.79,28.28 177.79,28.19 v2(177.6,27.99)
  BOTTOM w0.076: v2(154.72,81.03) 154.81,80.94 154.87,80.94
  BOTTOM w0.102: RC60.2 154.87,80.94
N29150944: length 0.9
  BOTTOM w0.254: PC630.2 84.64,120.27 PR644.1
N29151042: length 2
  BOTTOM w0.254: v1(83.62,108.64) 84.65,108.64 PC627.1 84.69,107.74 PR632.2
N29151125: length 0.9
  BOTTOM w0.254: PC632.2 92.77,119.49 PR641.1
N29151735: length 3.5
  BOTTOM w0.254: PR664.2 PR658.2 ; PR658.2 102.55,111.8 v1(102.55,110.93) ; PR658.2 102.53,112.82 102.83,113.12 PU603.12
N29151788: length 6.3
  BOTTOM w0.102: PU605.12 82.64,98 v1(82.23,97.59) 82.16,97.53 81.84,97.53 81.65,97.34 PR683.2 80.27,96.83 79.05,96.83 PR682.2
N29207759: length 46.8
  TOP w0.254: v2(91.24,106.93) 91.24,106.43 91.57,106.1 92.77,106.1 94.35,107.69 v1(94.35,109.66) 93.85,110.16 v2(92.96,110.16) 93.29,110.49 93.29,110.88 93.01,111.15 92.25,111.15 PR631.2
  IN3 w0.254: v2(92.96,110.16) 92.39,110.74 87.94,110.74 87.24,110.04 82.54,110.04 82.35,110.23 v2(82.35,110.54) ; v2(85.91,105.08) 83.69,105.08 83.24,104.64 83.24,103.62 82.16,102.54 82.16,97.97 82.8,97.34 86.92,97.34 v2(87.43,97.84)
  BOTTOM w0.254: v2(91.24,106.93) 91.23,106.94 91.23,108.52 PR610.1 ; PH601.2 v2(87.43,97.84) ; v2(82.35,110.54) 82.35,109.08 85.65,105.78 85.65,105.34 v2(85.91,105.08)
N29270847: length 30.4
  IN1 w0.254: v2(107.75,112.64) 106.8,113.59 102.8,113.59 102.23,113.02 102.23,112.58 101.88,112.23 100.67,112.23 99.43,113.47 98.74,113.47 98.29,113.02 98.29,112.01 97.78,111.5 97.08,111.5 96.01,110.42 94.67,110.42 93.53,111.56 86.54,111.56 86.29,111.31 85.72,111.31 v2(85.65,111.37)
  BOTTOM w0.102: v1(83.05,110.01) 83.62,110.01 PR647.2
  BOTTOM w0.254: PH603.2 107.24,112.13 v2(107.75,112.64) ; PR647.2 84.88,110.39 PR635.1 84.92,110.38 85.65,111.12 v2(85.65,111.37)
