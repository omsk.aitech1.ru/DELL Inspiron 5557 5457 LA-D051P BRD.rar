# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
+VCC_GT_L: length 33
  TOP w0.254: PR675.2 87.49,106.61 v2(87.12,106.99) 87.48,107.36 PC641.1
  IN1 w0.254: v2(88.45,96.51) 88.45,96.64 88.07,97.02 86.86,97.02 86.13,97.75 80.92,97.75 80.51,98.16 80.51,105.02 81.59,106.1 86.48,106.1 87.12,106.73 v2(87.12,106.99)
  BOTTOM w0.254: PH602.2 90.9,96.09 89.9,96.09 v1(89.49,96.5) 89.48,96.51 v2(88.45,96.51) ; PC626.2 87.48,109.44 PC624.2 PC641.1 PR638.1 ; PR638.1 86.44,107.73 PR632.1 ; PR638.1 87.12,107.05 v2(87.12,106.99)
+VCC_SA: length 86.2
  IN2 w0.254: v2(156.84,119.82) 156.77,119.82 155.89,120.7 145.5,120.7 144.96,120.17 144.96,119.23 144.41,118.67 123,118.67 121.66,120.01 98.99,120.01 97.97,118.99 97.97,118.36 98.55,117.78 v2(98.55,117.72)
  BOTTOM w0.254: PC637.2 PC633.2 90.98,119.14 PC644.1 93.36,120.04 93.67,119.74 PR641.2 93.67,118.63 PR636.2 93.83,118.62 94.24,118.22 PR643.1 94.54,118.16 95.31,117.4 97.08,117.4 97.34,117.15 98.23,117.15 98.55,117.47 v2(98.55,117.72) ; PL601.2 156.97,117.72 156.58,118.1 156.58,119.56 v2(156.84,119.82) 156.94,119.82 157.78,120.65 PH604.2
  BOTTOM w0.508: PC1145.1 162.62,113.97 v2(162.62,114.35) ; PC1141.1 160.9,113.97 v2(160.9,114.35) ; v2(164.33,114.35) 164.33,113.97 PC1144.1 ; v2(166.05,114.35) 166.05,113.97 PC1140.1 ; v2(161.66,117.45) 161.66,117.08 PC1142.1 ; v2(163.36,117.47) 163.36,117.09 PC1143.1 ; PC1139.1 165.03,117.08 v2(165.03,117.45)
  vias: v2(135.31,96.7) v2(135.95,92) v2(135.95,89.84) v2(136.18,98.84) v2(136.18,97.44) v2(136.71,96.32) v2(136.71,94.99) v2(136.71,93.72) v2(136.71,92.45) v2(137.09,97.4) v2(137.12,87.55) v2(137.99,97.37) v2(138.01,87.55) v2(138.8,97.27) v2(138.87,98.92) v3(136.39,88.51)
+VDD_TOUCH: length 18.5
  TOP w0.254: RX47.1 5.21,89.4 4.74,89.87 v2(4.73,89.87)
  IN3 w0.508: v2(7.99,94.99) 7.99,94.48 7.8,94.29 5.26,94.29 4.95,94.61 3.87,94.61 3.42,94.16 v2(3.42,93.53) 3.42,92.51 4.73,91.2 v2(4.73,89.87) 4.73,89.64 2.82,87.73 v2(2.82,86.4)
  BOTTOM w0.254: v2(3.42,93.53) 3.42,93.78 3.2,94 JEDP.11 ; v2(2.82,86.4) 2.72,86.5 JEDP.26
  vias: v1(7.93,96.45)
GND: length 2892.5
  TOP w0.203: v2(145.22,12.01) 145.22,11.87 145.34,11.75 UE5.17 ; v2(170.54,15.96) 170.54,15.93 170.62,15.85 U2301.11 ; CE78.2 133.9,2.5 133.8,2.59 UE5.100 ; v2(115.03,96.95) 115.38,96.6 PC1044.2 ; v2(132.52,10.21) 132.45,10.15 UE5.84 ; v2(132.1,18.77) 132.1,18.79 132.35,18.53 132.52,18.53 132.6,18.62 UE5.64 ; US2.3 187.78,11.87 187.99,11.65 v2(188.04,11.65) ; UE5.124 143.4,2.44 v2(143.5,2.34) ; UE5.51 137.8,20.56 v2(137.85,20.6)
  TOP w0.254: UV5.D8 v2(67.35,95.98) ; UV5.T1 72.55,105.18 v2(72.15,105.58) ; PC1092.2 135.01,100.16 v2(135.24,100.16) 135.38,100.03 135.38,99.68 PC1093.2 ; UC3.3 164.35,62.45 v2(164.1,62.69) ; UV7.A9 46.52,80.03 v2(46.84,79.71) ; RPV16.8 44.77,97.03 44.44,96.7 v2(43.81,96.7) ; UV7.G1 v2(42.12,86.91) ; HE1.2 114.03,85.72 v2(114.21,85.89) ; UV7.E8 43.32,80.9 v2(43.72,80.5) ; RC80.1 145.79,100.64 145.33,100.18 v2(145.33,100.11) ; RC7.2 113.93,98.84 v2(113.93,98.84) ; UV9.E8 52.47,96.38 v2(52.87,95.98) UV9.D8 ; UV6.A9 46.52,65.62 v2(46.92,65.22) ; v2(43.72,66.03) 43.32,66.43 UV6.E8 ; UV6.B1 v2(46.12,72.43) ; v2(58.47,95.98) UV9.E1 57.67,96.78 v2(57.67,96.78) ; v2(58.47,101.58) UV9.M1 ; RPV12.5 48.11,90.05 48.38,89.78 v2(50.09,89.78) ; UV7.M1 37.72,86.67 v2(38.31,87.27) ; CC126.2 147.88,102.99 148.38,103.48 v2(148.77,103.48) ; CV75.1 38.83,102.38 39.22,101.98 RPV17.5 ; v2(22.47,83.8) 22.59,83.68 UI8.10 ; UV5.E1 v2(72.95,95.98) ; UV9.B9 v2(51.27,93.58) 51.67,93.18 UV9.A9 ; UV6.F9 42.52,65.62 v2(42.92,65.23) ; CV74.1 47.75,91.6 47.7,91.55 RPV12.8 ; UV6.B9 45.72,65.62 v2(46.12,65.22) ; CV79.1 38.45,95.69 39.16,96.4 RPV8.8 ; v2(42.98,100.13) 43.11,100.26 RPV13.8 ; v2(128.86,98.84) 128.65,98.84 PC1083.2 ; UV5.M9 65.6,101.98 v2(65.52,101.9) ; CV19.2 70.68,64.26 v2(69.89,63.47) ; CC79.2 141.02,85.04 v2(140.69,85.37) ; UV6.M9 v2(38.12,65.22) ; RPV9.8 45.85,94.24 45.67,94.06 45.38,94.06 v2(45.02,94.42) ; v2(39.72,66.81) 40.11,66.43 UV6.J8 ; UV7.J8 v2(40.52,81.3) 40.52,81.3 41.12,81.3 41.52,80.9 UV7.G8 ; RPC11.6 157.54,62.6 157.82,62.32 v2(157.82,61.72) ; RPV16.5 46.27,98.02 46.7,98.45 CV80.1 ; UV6.G8 41.72,66.42 v2(42.12,66.02) ; v2(54.88,93.24) 55.73,93.24 UV9.B3 v2(56.87,94.38) ; v2(72.95,103.98) 72.55,103.58 UV5.P1 ; UV6.G9 41.72,65.62 v2(42.12,65.23) ; v2(59.06,104.89) 59.06,104.57 UV9.P1 ; CV78.1 42.34,102.4 RPV15.5 ; UV7.B9 45.72,80.04 v2(46.06,79.7) ; v2(69.35,93.27) 70.24,93.27 UV5.B3 ; 131.7,98.89 131.73,98.93 PC1036.2 ; RPV17.8 v2(37.72,102.16) ; UV5.G9 66.15,97.98 v2(65.75,97.58) 66.15,97.18 66.15,97.18 UV5.F9 ; RPV10.5 35.11,98.34 v2(35.11,98.84) ; CC73.2 142.85,93.35 CC80.2 142.69,93.91 v2(142.33,94.27) ; UV9.M9 51.5,101.98 v2(50.91,101.38) ; UV6.T9 34.52,65.62 v2(34.12,66.02) ; UV6.D8 44.12,66.42 v2(44.52,66.02) ; RPV10.8 34.87,96.4 34.75,96.28 CV72.1 ; CC14.2 162.24,60.93 162.24,61.97 v2(161.66,62.54) ; v2(127.04,85.96) 127.08,86 CC31.2 ; UV7.J2 40.02,85.7 v2(39.72,86.01) ; UV7.E2 43.32,85.7 v2(43.72,85.3) ; RC223.1 146.38,95.96 v2(146.38,96.21) ; UV9.B1 58.07,93.98 v2(58.47,93.58) ; RPV7.8 v2(83.14,78.01) ; UV5.G8 67.35,98.38 67.35,99.16 v2(67.3,99.21) 66.95,99.56 UV5.J8 ; v2(116.98,100.11) 116.98,100.72 RC185.2 ; UV9.G8 52.47,97.98 51.67,97.18 UV9.F9 v2(51.27,97.58) 51.67,97.98 UV9.G9 ; v2(40.06,95.11) 40.26,94.91 RPV11.5 ; v2(35.94,87) 35.94,86.68 UV7.P1 ; v2(42.12,79.7) 41.72,80.1 UV7.G9 ; UV6.G1 41.72,72.03 v2(42.12,72.43) ; v2(51.18,103.75) 51.49,103.75 UV9.P9 ; UV5.D1 72.55,95.58 v2(72.15,95.98) UV5.E2 ; RC205.2 134.09,101.13 v2(134.13,101.1) ; RC8.2 115.93,98.81 v2(115.96,98.84) ; UV6.B3 v2(45.32,70.82) ; CE26.2 110.92,85.86 v2(110.67,86.1) ; v2(37.79,72.65) 37.72,72.58 UV6.M1 ; UV6.P1 36.12,72.06 36.45,72.39 v2(36.51,72.39) ; UV5.B1 72.55,93.98 v2(72.95,93.58) ; v2(43.72,81.3) 44.12,80.91 UV7.D8 ; UV9.E2 v2(57.67,95.98) 58.07,95.58 UV9.D1 ; U2407.6 157.97,13.31 158.11,13.45 v2(158.49,13.45) ; v2(72.95,101.58) UV5.M1 ; RPV18.8 37.16,91.85 36.83,91.85 CV73.1 ; RPV7.5 v2(83.21,79.51) ; RPV18.5 36.27,93.09 v2(36.27,92.62) ; DI3.8 DI3.3 16.5,72.89 v2(16.06,72.44) ; v2(34.82,80.51) 34.82,80.5 34.52,80.19 UV7.T9 ; UV7.B3 45.72,84.9 v2(45.32,85.3) ; CV250.2 47.87,95.5 47.35,94.98 RPV9.5 ; UV6.J2 40.14,71.23 v2(40.49,70.88) ; UV5.B9 v2(65.75,93.58) ; UV9.J8 52.47,99.68 v2(52.17,99.98) ; UV6.E1 v2(43.72,72.43) ; CC78.2 147.6,87.88 v2(147.71,87.78) 148.52,88.59 CC77.2 ; UV5.G1 v2(72.15,97.58) ; CV81.1 45.37,100.96 45.13,100.72 RPV13.5 ; UV5.A9 v2(65.75,92.78) ; RPV8.5 39.24,97.9 38.97,98.16 v2(38.97,99.14) ; RPC11.8 158.54,62.74 158.83,62.45 158.83,61.87 v2(158.62,61.65) ; v2(66.47,105.67) 66.47,105.61 66.15,105.29 UV5.T9 ; CV82.1 40.56,90.36 RPV14.8 ; v2(65.78,103.19) 65.78,103.25 66.11,103.58 UV5.P9 ; UV9.G1 58.07,97.98 v2(58.47,97.58) ; CE58.2 26.4,61.92 26.98,61.33 v2(26.98,61.21) ; UI8.21 v2(18.85,83.68) ; UV9.T9 v2(52.04,105.55) ; v2(34.03,71.7) 34.09,71.7 34.41,72.03 UV6.T1 ; UV9.J2 v2(56.87,99.18) ; UV7.D1 v2(43.72,86.9) UV7.E1 ; 19.41,66.78 U2409.5 ; v2(35.72,65.22) 36.12,65.62 UV6.P9 ; CV77.1 39.82,93.41 RPV11.8 ; UV5.J2 71.75,99.59 v2(71.36,99.97) ; RPV14.5 v2(39.99,91.86) ; RPV15.8 v2(40.84,102.21) ; PC861.2 62.19,76.55 v2(61.56,77.18) ; CC61.2 142.97,96.56 v2(142.36,95.95) ; UV7.F9 v2(42.92,80.5) ; v2(34.8,79.19) 35.21,79.19 UV7.P9 ; UV9.T1 57.98,105.18 57.67,104.87 v2(57.67,104.87) ; UV6.E2 v2(43.72,71.63) UV6.D1 ; UV5.E8 v2(66.55,95.98) ; UV7.T1 v2(34.15,86.13) ; UV7.M9 v2(38.12,79.7) ; UV7.B1 v2(46.12,86.91)
  TOP w0.305: UC4.5 187.72,79.89 v2(188.09,80.26) ; CC93.1 129.46,23.17 129.28,23.17 128.81,23.64 UC13.3 ; UC6.5 165.27,46.9 165.74,47.37 v2(167.93,47.37) ; JKB.1 93.34,47.75 v2(94.04,47.04) ; 131.7,98.89 v2(131.66,98.85)
  TOP w0.356: CC47.2 128.67,88.25 v2(128.67,88.85) ; v2(126.12,98.86) 126.57,98.41 PC1084.2 PC1038.2 ; CV73.1 36.35,91.37 35.56,91.37 v2(35.08,91.85) ; CC32.2 135.92,87.78 v2(136.03,87.9) ; CC56.2 137.47,100.83 v2(137.08,101.22) ; PC1049.2 116.58,96.7 v2(116.33,96.95) ; CV79.1 38.45,95.34 38.09,94.99 v2(37.27,94.99) ; CV82.1 40.51,89.78 v2(40.7,89.59) ; CV198.2 v2(62.29,93.78) ; CV81.1 45.37,101.93 45.14,102.16 v2(44.95,102.16) ; CV77.1 39.81,92.04 v2(39.99,91.86) ; v2(45.46,76.45) 45.12,76.79 CV258.2 ; v2(158.62,61.65) 158.62,61.55 158.53,61.46 CC57.2 ; v2(144.4,95.02) 144.68,95.31 CC68.2 ; CV164.2 62.41,94.54 v2(62.29,94.42) ; CV257.2 43.78,76.88 43.5,76.88 v2(43.3,77.08) ; CV253.2 v2(30.54,81.4) ; v2(39.43,102.73) CV75.1 ; CV72.1 33.94,96.28 v2(33.88,96.22) ; CV199.2 v2(76.54,99.62) ; v2(42.13,103.15) CV78.1 ; CV80.1 47.24,98.14 v2(47.24,97.97) ; CV76.1 48.51,94.33 v2(48.51,94.86) 48.34,95.03 CV250.2 ; PQ707.4 v2(25.73,39.93)
  TOP w0.381: PC1052.2 129.49,97.72 v2(129.78,97.44) ; PC1042.2 114.18,94.66 v2(113.75,95.1) 113.75,94.97 113.31,94.54 PC1043.2 ; v2(129.43,101.11) 129.5,101.17 PC1085.2 PC1050.2 ; PC1026.2 106.18,97.07 v2(106.61,97.07) ; CC74.2 144.71,92.5 v2(144.71,91.98) 145.5,91.98 CC103.2 ; v2(33.14,112.64) 33.65,112.64 34.33,113.32 PQ2.1 ; PC1176.2 123.78,95.41 v2(123.78,95.81) ; PC1089.2 133.25,98.71 v2(133.43,98.89) 133.43,98.89 PC1088.2 ; CA60.2 v2(195.76,12.75) ; v2(110.84,102.09) 110.59,101.85 PC1016.2 ; PC1090.2 131.4,98.59 v2(131.66,98.85) 132.07,98.44 PC1034.2 ; CA30.2 206.38,16.06 v2(206.76,15.68) 207.24,16.16 CA31.2 ; PC1130.2 122.51,95.41 v2(122.51,95.81) ; PC1039.2 131.34,102.9 v2(131.12,103.12) ; PC1152.2 137.1,99.31 v2(137.1,98.97) 137.01,98.88 PC1153.2 ; PC1134.2 120.59,94.58 v2(120.96,94.58) ; v2(23.87,35.61) 24,35.61 24.43,36.04 PQ707.1 ; UC15.3 172.51,48.58 172.64,48.45 172.67,48.45 172.98,48.15 172.98,48.12 v2(173.03,48.12) ; v2(110.79,100.33) 111.21,99.91 PC1041.2 ; v2(126.93,116.13) 126.93,116.58 PC1012.2 ; PC1129.2 122.51,92.99 v2(122.51,93.4) ; PC1135.2 121.37,93.35 v2(120.96,93.35) ; CC8.2 180.4,21.24 v2(180.59,21.43) ; PC823.2 67.62,75.33 v2(67.49,75.21) ; v2(143.59,91.73) 143.59,91.52 142.92,90.85 CC72.2 142.92,90.15 v2(143.01,90.05) ; v2(118.93,95.11) 118.93,95.5 PC1138.2 ; v2(147.06,92.89) 147.52,93.35 RC220.1 ; v2(136.1,74.14) 135.94,74.3 CC43.2 ; PC1048.2 PC1056.2 115.87,91.27 v2(115.7,91.44) ; v2(130.65,74.22) 130,74.22 CC45.2 ; CC49.2 139.27,86.39 139.55,86.11 CC63.2 ; v2(48.76,91.18) 48.76,91.3 48.47,91.6 CV74.1 ; PC1094.2 PC1087.2 131.82,101.05 v2(131.91,101.14) ; PQ1.4 32.62,106.62 32.46,106.78 v2(32.46,107.18) ; v2(123.78,93.4) 123.78,92.99 PC1177.2 ; v2(120.64,98.84) 120.72,98.77 PC1040.2 ; QI2.4 v2(14.9,40.71) ; PC1137.2 121.35,90.85 v2(120.95,90.85) ; UC7.3 158.82,57.09 v2(158.24,56.51) ; CC46.2 125.81,73.53 v2(126.47,73.53) ; v2(135.27,97.44) 135,97.7 PC1095.2 135.24,98.52 PC1151.2 ; v2(63.56,75.14) 63.96,74.74 PC835.2 ; PC1047.2 113.67,93.34 v2(113.75,93.27) ; v2(67.05,85) 66.99,85.06 RV21.2 ; v2(120.96,92.07) 120.59,92.07 PC1136.2 ; UV23.3 83.37,76.15 83.17,75.95 v2(82.81,75.95) ; v2(123.93,74.51) 123.88,74.45 CC44.2 ; v2(55.54,75.14) 55.51,75.14 54.92,75.73 CV43.2 CV39.2 ; v2(32.06,114.35) 32.33,114.62 PQ2.4 ; v2(118.36,92.64) 118.36,92.26 118.61,92 PC1224.2 ; RC119.2 150.37,92.33 149.98,91.94 v2(149.66,91.94) ; CV50.2 CV69.2 70.11,81.3 v2(69.64,81.77) ; PC822.2 65.62,75.27 v2(65.53,75.17) ; PC1096.2 133.24,103.03 v2(133.37,103.15) ; PC1181.2 117.68,98.63 v2(117.89,98.84) ; v2(143.05,88.36) 143.05,88.82 CC102.2 ; CC84.2 143.25,86.73 v2(143.49,86.49) ; v2(120.64,85.96) 120,86.6 CC33.2 ; v2(112.45,90.56) 112.44,90.57 PC1046.2 ; PC1131.2 121.32,95.93 v2(120.92,95.93) ; 125.28,90.42 125.63,90.06 v2(125.98,90.06) ; v2(148.23,96.18) 148.36,96.05 CC87.2 149.03,95.29 RC312.1 ; UE6.3 124.47,12.12 RE388.1 ; CV246.2 CV247.2 v2(47.8,96.89) ; v2(126.95,101.14) 126.64,101.46 PC1033.2 ; PC1004.2 128.32,90.03 v2(128.64,90.03) ; PC1055.2 111.57,93.04 v2(111.8,93.27) ; PC1030.2 129.85,98.84 v2(129.78,98.84) 129.92,98.99 PC1086.2 ; CC92.2 126.46,21.05 v2(126.61,21.2) ; PC1178.2 114.24,91.44 v2(113.75,91.44) 113.72,91.41 PC1045.2
  TOP w0.406: RI1.1 v2(14.9,43.92) ; RC76.1 147.38,92.57 v2(147.06,92.89) ; QI2.1 v2(16.2,41.14)
  TOP w0.457: PC1076.2 125.28,116.51 v2(125.28,116.13) ; PC618.1 88.97,106.66 v2(88.64,106.99) 88.4,107.23 PC641.2 ; v2(124.39,113.47) 124.39,113.85 PC1081.2 ; PC1082.2 123.56,116.51 v2(123.56,116.13) ; PC1059.2 136.33,95.69 v2(136.71,95.69) ; v2(136.71,94.42) 136.33,94.42 PC1058.2 ; PC801.2 73.77,49.33 v2(74.48,49.33) ; PC1075.2 126.17,113.85 v2(126.17,113.47) ; CV200.2 82.96,73.65 83.2,73.89 83.83,73.89 v2(83.89,73.96) ; PC601.2 87.99,118.89 v2(88.48,118.89) ; v2(83.19,81.93) 83.24,81.98 UV12.3 ; CE76.2 133.52,23.74 v2(132.84,23.74) ; v2(155.76,66.41) 155.65,66.52 UC11.3 154.17,66.52 CC142.2 ; PC1057.2 136.33,93.15 v2(136.71,93.15) ; CC104.2 159.4,64.79 159.08,65.11 159.08,65.89 v2(159.1,65.9)
  TOP w0.508: v2(132.39,70.22) 133.28,69.33 CC37.2 ; v2(154.13,5.06) 153.79,5.06 153.55,4.82 CE79.2 ; RV111.1 63.34,100.4 v2(63.8,100.85) ; v2(200.73,82.02) 200.69,82.02 200.65,81.98 CX21.2 RX13.2 ; CV2.2 60.12,66.8 v2(60.49,66.8) ; RA19.2 189.36,13.82 v2(188.98,13.44) ; JLED.8 v2(13.77,51.3) ; v2(50.29,101.4) 49.33,102.35 CV244.2 ; CA29.2 202.42,16.11 v2(202.11,15.8) ; v2(36.98,108.58) 36.98,106.7 36.62,106.34 PR2.2 36.25,105.91 35.67,105.32 PQ1.1 ; CD10.2 129.58,45.77 v2(129.66,45.86) ; v2(185.82,17.07) 185.82,16.55 RS35.2 ; CD7.2 128.64,41.27 128.23,41.69 v2(127.95,41.69) ; 136.58,37.9 136.58,37.96 136.12,38.42 CD17.2 135.4,38.9 CD8.2 ; 136.58,37.9 137.1,38.42 CD18.2 ; 136.58,37.9 v2(136.58,37.62) ; v2(146.17,27.99) 146.49,27.68 CD38.2 ; v2(142,116.39) 142,116.81 PC1174.2 ; CD12.2 123.99,45.38 v2(123.65,45.38) ; v2(24.89,61.33) 24.66,61.1 JTP.5 ; CL33.2 v2(197.92,112.83) ; CC10.1 145.08,72.71 v2(145.79,72) ; v2(95.92,52.67) 96.85,51.74 RD12.2 97.77,50.88 RD11.2 ; CC125.2 145.98,102.92 v2(146.17,103.12) ; v2(6.65,62.79) 6.79,62.94 UE3.8 ; CD23.2 v2(161.61,40.62) ; DE3.2 126.75,1.72 127.17,2.14 CE74.2 v2(127.17,3.55) CE75.2 ; CD27.2 157.21,46.41 v2(156.95,46.16) ; RA81.1 CA69.2 191.45,15.1 v2(191.13,15.42) ; v2(58.73,75.12) 58.54,74.94 CV55.2 ; PC858.2 63.8,72.9 v2(63.51,73.19) ; PQ5.3 23.68,99.71 v2(23.83,99.56) ; v2(12.96,63.99) 12.96,64.09 C94.1 ; v2(147.19,99.62) 147.38,99.62 CC130.2 ; RE371.2 v2(157.35,2.72) ; v2(5.8,79.73) 5.47,80.06 RX9.2 ; CI13.2 192.54,50.49 v2(192.97,50.92) 193.47,50.42 CI15.2 ; CE22.2 v2(8.44,72.89) ; v2(131.26,45.48) 131.71,45.48 CD11.2 ; RV88.1 v2(82.81,75.95) ; PR746.1 28.62,40.52 v2(28.57,40.57) ; RX14.2 198.32,74.92 v2(199.21,74.92) ; v2(12.88,88.65) 13.19,88.95 RX48.2 ; PC128.2 60.2,31.12 v2(60.06,30.98) ; CX3.2 7.42,90.61 v2(7.8,90.99) ; CX1.2 6.56,86.67 6.79,86.9 v2(6.79,86.92) ; CV265.2 v2(33.97,63.55) ; CC50.2 174.16,98.98 173.86,98.67 v2(173.09,98.67) CC51.2 ; RE355.2 CE88.2 132.52,23.42 v2(132.84,23.74) ; PR203.2 96.58,17.07 v2(96.26,17.39) ; v2(196.34,86.03) 198,86.03 QX3.3 ; v2(110.79,98.48) 110.74,98.43 PC1017.2 ; RA31.2 200.5,24.24 199.02,24.24 v2(198.81,24.44) ; v2(144.4,95.02) 145,94.42 CC81.2 ; PC1003.2 129,91.31 v2(128.62,91.31) ; v2(126.42,68.83) 127.06,68.19 CC41.2 ; CC114.2 v2(138.11,90.61) ; CD50.2 CD53.2 173.68,33.47 v2(173.67,33.46) ; RI1.4 v2(16.2,44.33) ; v2(19.89,60.53) 18.89,60.53 18.73,60.7 RI90.2 ; v2(109.66,38.14) 109.59,38.14 CD29.2 CD28.2 ; v2(139.72,69.59) 140.48,68.83 CA26.2 ; v2(139.7,32.49) 139.87,32.49 CD45.2 ; v2(144.26,28.68) 144.12,28.68 143.63,28.19 CD36.2 ; CD43.2 135.74,32.49 v2(135.56,32.49) ; CE25.2 9.07,69.14 v2(8.95,69.02) ; CC39.2 122.1,68.32 v2(121.47,68.95) ; CC94.2 CC95.2 CC96.2 176.57,80.52 v2(176.27,80.83) ; v2(159.1,65.9) 158.87,66.13 RC105.2 ; CV41.2 55.03,79.35 55.5,79.82 v2(55.5,80.08) ; RX26.2 v2(5.77,81.08) ; v2(133.28,2.28) 133.28,1.77 133.47,1.58 CE78.2 ; SW1.2 176.04,113.17 v2(175.76,112.89) ; CV256.2 31.24,88 31.11,87.88 v2(30.54,87.88) ; v2(131.04,91.31) 131.42,91.31 PC1173.2 ; CE23.2 v2(3.54,72.39) ; CV264.2 v2(40.89,61.27) ; 19.41,66.78 19.88,67.25 C5220.2 20.45,67.43 v2(20.69,67.19) ; CC112.2 140.26,93.56 v2(140.42,93.4) ; CX9.2 12.44,92.45 v2(12.99,93) ; RV65.2 67.77,85.7 RV21.2 ; v2(75.31,64.45) 75.38,64.38 CV5.2 ; v2(126.12,98.86) 126.11,98.88 PC1175.2 ; v2(22.15,106.48) PC3.2 PC4.2 ; CD52.2 CD51.2 170.67,25.06 v2(170.55,24.95) ; v2(137.42,32.49) 137.58,32.49 138.11,33.01 CD32.2 ; v2(139.7,28.68) 139.49,28.68 139.06,28.25 CD35.2 ; v2(6.65,62.03) 6.39,62.03 5.52,62.91 UE3.7 ; UE3.6 4.25,63.3 v2(3.99,63.05) ; CV260.2 v2(46.68,76.43) ; v2(96.32,115.69) 96.18,115.55 PC602.2 ; v2(138.68,2.35) 138.68,1.69 CE63.2 ; PC1006.2 126.36,91.3 v2(125.98,91.3) ; v2(6.13,90.48) CX2.2 ; CI7.2 v2(191.89,40.19) ; v2(33.84,12.82) 33.53,13.12 PQ711.3 ; CS27.2 180.02,6.98 v2(180.46,6.53) 180.9,6.98 RS36.2 ; C5233.2 152.28,3.92 v2(151.63,4.56) ; v2(125.28,12.25) 125.09,12.06 RE388.1 ; v2(11.3,48.06) 9.94,48.06 JLED.9 ; CD3.2 CD30.2 106.88,36.55 106.29,37.14 106.29,37.58 106.74,38.04 v2(107.04,38.04) ; PC843.2 67.78,72.92 v2(67.44,73.26) ; v2(169.35,63.75) 168.01,63.75 167.82,63.94 RC99.1 RC182.2 ; v2(169.15,36.41) 169.18,36.44 CD55.2 CD54.2 ; v2(87.75,81.84) 87.75,81.83 87.36,82.22 CV292.2 CV57.2 ; v2(70.35,85) 70.49,85.14 RV63.2 ; v2(150.64,86.55) 151.17,86.01 CC85.2 ; CC64.2 156.98,99.36 157.22,99.11 v2(157.22,98.61) ; CL12.2 178.34,103.64 CL5.2 ; QI1.4 v2(14.9,36.3) ; CV59.2 96.01,68.69 v2(96.01,68.19) 97.14,68.19 CV117.2 CV290.2 ; CV67.2 CV83.2 v2(87.23,60.68) ; CC88.2 170.31,46.28 v2(169.88,46.72) 169.16,47.44 CC101.2 ; v2(123.37,21.26) 123.48,21.37 123.48,22 123.71,22.23 QE5.4 ; v2(40.63,76.59) 40.63,77.19 RV2437.1 RV2439.1 ; v2(3.06,89.42) 3.03,89.45 CX4.2 ; v2(126.95,101.14) 127.16,101.35 RC124.2 ; v2(140.67,113.59) 140.67,114.01 PC1013.2 ; RD16.2 109.65,36.18 v2(109.66,36.2) 109.48,36.38 CD28.2 ; UC8.2 176.38,93.48 v2(176.78,93.09) ; CV268.2 v2(41.9,61.27) ; DX2.1 4.69,92.89 v2(5.45,93.65) ; CV295.2 CV64.2 v2(90.35,66.92) 90.34,66.93 CV66.1 ; v2(3.99,62.16) 3.74,62.16 3.36,62.54 3.36,63.17 2.98,63.55 UE3.5 ; CX50.2 v2(7.09,96.97) ; CD34.2 133.53,32.5 v2(133.53,32.49) ; QV5.1 89.97,70.19 89.97,70.79 v2(90.29,71.11) 90.29,71.71 QV5.4 ; v2(62.12,67.62) 62.18,67.57 CV23.2 ; RV2438.1 61.19,100.4 60.89,100.7 v2(60.89,101.01) ; v2(125.87,42.33) 126.12,42.33 126.49,41.96 126.49,40.44 CD14.2 ; CD20.2 130.3,40.57 130.3,43.23 129.96,43.57 v2(129.66,43.57) ; CA57.2 198.57,13.2 CA58.2 198.13,13.19 v2(197.86,13.45) ; v2(186.49,6.53) 186.62,6.53 187.13,7.04 RS23.2 RS31.2 ; v2(30.66,58.67) JTP.9 ; RC101.2 153.16,65.54 RC95.1 CC142.2 ; v2(123.31,90.48) 122.99,90.48 PC1073.2 ; v2(133.64,45.48) 133.88,45.48 CD9.2 ; CC9.2 181.91,20.36 v2(181.92,20.37) ; CD25.2 v2(161.61,38.28) ; RS18.2 183.58,7.07 v2(184.02,6.63) 184.11,6.72 184.13,6.72 184.47,7.07 RS22.1 ; v2(58.35,57.27) 58.35,57.8 PC849.2 ; CC59.2 CC52.2 v2(187.32,73.41) ; v2(131.06,90.03) 130.74,90.03 130.36,90.42 ; CV42.2 RV43.1 55.49,82.72 v2(55.49,82.56) ; CV105.2 v2(30.28,78.29) ; PC1005.2 129.05,88.85 v2(128.67,88.85) ; RE359.2 124.77,9.26 125.34,8.69 v2(125.34,8.3) ; CD19.2 132.45,41.46 133.43,42.43 v2(133.64,42.43) ; v2(58.78,69.3) 58.99,69.08 CV51.2 ; PC1011.2 143.27,114.01 v2(143.27,113.59) ; RL35.1 173.23,101.91 CL13.2 ; PR10.1 v2(30.14,106.42) ; v2(24.06,78.03) 23.87,78.22 RI49.1 RI48.1 ; v2(144.1,116.39) 144.1,116.81 PC1001.2 ; v2(136.26,23.74) 136.33,23.68 CE73.2 CE85.2 ; CE67.2 v2(149.03,15.42) 149.92,15.42 CE62.2 ; CV252.2 RV116.1 47.1,101.34 v2(46.09,102.34) ; CD37.2 142.95,33.17 v2(142.95,31.46) ; RV42.1 57.79,85.36 v2(57.19,85.97) ; CA32.2 211.94,16.44 v2(212.2,16.69) ; v2(110.76,83.79) 111,84.04 RC183.2 ; RI57.2 v2(19.69,78.66) CI20.1 ; PC1184.2 PC1133.2 123.37,100.13 v2(123.38,100.12) ; v2(147.57,2.21) 147.77,2.42 C5232.2 ; RA30.2 185.29,25.71 v2(184.84,25.26) ; v2(125.22,100.12) 125.72,100.62 PC1132.2 PC1182.2 ; v2(157.35,49.08) 157.21,48.93 CD26.2 ; CL39.2 188.13,96.61 v2(188.33,96.41) ; PD101.1 v2(65.53,30.6) ; v2(74.49,64.45) 74.42,64.38 CV4.2 ; CV52.1 56.73,79.7 v2(57.11,80.08) ; v2(133.53,27.91) 133.53,27.91 CD39.2 ; PC829.2 56.83,57.65 v2(56.83,57.27) ; CV269.2 v2(42.92,61.27) ; PC1222.2 PC1223.2 119.63,100.21 v2(119.72,100.11) ; v2(20.95,64.95) 20.95,64.71 21.24,64.42 CE91.1 CE92.1 ; v2(121.73,45.38) 122.09,45.38 122.42,45.71 CD4.2 ; v2(17.53,64.88) 17.54,64.89 U2409.9 ; v2(148.82,28.93) 148.42,28.53 CD47.2 149.33,26.73 CD48.2 149.33,26.75 RD20.2 ; CV262.2 v2(39.87,61.27) ; CC113.2 v2(136.9,90.61) ; CV261.2 v2(30.6,84.19) ; RE357.2 127.23,12.98 v2(127.25,12.97) 127.23,12.96 CE65.1 ; v2(6.2,81.97) 5.72,81.97 CA22.2 ; v2(35.94,99.12) 36.06,98.99 RV2447.1 ; v2(125.87,45.38) 126.28,45.38 126.61,45.71 CD6.2 ; CV259.2 v2(49.09,79.25) ; CX8.2 v2(11.55,87.43) ; v2(121.73,42.33) 121.93,42.33 122.36,41.9 122.36,40.44 CD13.2 ; PC1074.2 122.99,89.21 v2(123.31,89.21) ; v2(62.48,95.18) 62.81,95.18 RV2440.1 ; v2(83.78,65.65) 85.92,65.65 QV8.4 ; v2(178.81,70.79) 178.6,70.79 178.09,71.3 178.09,72.09 177.73,72.44 CC98.2 ; UX4.2 v2(22.22,73.27) ; RE58.2 122.87,17.96 v2(122.74,18.09) ; v2(182.16,106.38) 182.7,106.91 CL41.1 ; QV8.1 85.16,67.63 v2(85.46,67.94) ; RC40.2 RC39.2 RC38.2 140.39,72.64 139.96,72.21 v2(139.68,72.21) ; v2(126.61,21.2) CE68.2 CE69.2 ; RD15.2 CD28.2 ; CV166.2 v2(76.96,97.02) ; JKBBL.6 v2(116.2,11.17) ; RC228.2 141.21,100.57 v2(141.67,100.11) 141.81,100.26 CC129.2 142.36,100.88 CC48.2 CC75.2 143.78,101.11 v2(144.25,101.11) ; JKB.32 v2(84.64,50.1) ; v2(31.03,71.68) CV106.2 RV96.2 ; PC1066.2 134.08,91.62 133.79,91.33 v2(133.41,91.33) ; CE86.2 143.77,22.03 v2(144.27,22.03) 144.27,22.41 143.96,22.71 CE82.2 ; JKBBL.5 v2(116.18,19.47) ; RI56.2 26.6,81.46 v2(26.79,81.65) ; v2(123.65,42.33) 123.84,42.33 124.33,41.84 124.33,40.26 CD5.2 ; PR103.2 v2(63.94,16.69) ; v2(129.6,23.93) 129.53,23.87 CC93.1 ; CE77.2 141.22,22.88 v2(140.73,23.36) 140.26,22.89 CE70.2 ; CC71.2 158.49,68.7 v2(158.3,68.51) ; RV97.1 37.78,77.44 v2(36.91,77.44) ; PC647.1 84.08,112.78 v2(84.13,112.83) PC651.1 ; v2(174.3,10.09) 174.11,9.9 C2322.2 ; PR738.2 v2(30.02,32.94) ; 145.09,33.07 144.5,32.49 v2(144.26,32.49) ; v2(92.09,118.48) 92.02,118.56 PC652.2 ; v2(171.82,64.51) CM4.2 173.55,64.51 CM5.2 ; v2(151.63,7.29) 151.63,7.22 CE66.2 ; PC1025.2 109.72,96.59 v2(110,96.32) ; 113.4,21.9 114.04,21.26 v2(114.55,21.26) ; C2309.2 v2(170.87,9.2) ; v2(95.29,52.67) 95.29,51.52 CD2.2 CD1.2 ; CV204.2 v2(76.96,97.91) ; CX6.2 4.37,74.29 v2(4.63,74.03) ; C5221.2 14.42,61.26 v2(14.28,61.4) ; v2(151.69,17.01) 151.19,17.01 151.05,17.15 RE383.2 CE81.2 ; v2(152.5,89.02) 152.09,89.43 RC16.2 ; CX5.2 2.31,76.99 2.79,76.51 v2(2.79,76.25) ; v2(193.15,49.2) 193.15,48.2 193.54,47.81 UI5.2 ; QV74.3 87.92,72.49 v2(86.42,70.98) ; CC38.2 v2(132.52,68.89) ; UI6.2 v2(194.87,44.19) ; QC1.3 149.69,67.4 v2(149.6,67.49) ; v2(33.39,10.34) 32.95,9.9 RC400.2 ; CC117.2 167.9,41.32 v2(167.89,41.33) CC89.2 ; CV270.2 v2(37.78,63.55) ; JLED.10 v2(9.7,59.61) ; v2(156.01,5.13) 155.47,5.68 C2498.2 ; CV254.2 v2(30.41,83.18) ; v2(46.79,107.69) 48.25,106.23 CV245.2 ; v2(55.56,57.27) 55.56,57.65 PC828.2 ; RS37.2 v2(177.31,9.83) ; v2(167.7,14.28) 167.9,14.48 C5222.2 ; v2(81.28,82.76) 81.08,82.57 RV44.2 ; v2(63.56,77.14) 63.85,77.44 PC841.2 64.4,78 v2(64.58,78.18) ; PR9.1 19.67,99.42 v2(19.61,99.37) ; CD33.2 135.57,27.91 v2(135.56,27.91) ; RV98.1 v2(38.86,61.27) ; PC1.2 PC2.2 17.53,103.19 v2(17.33,102.99) ; CC58.2 v2(184.71,83.11) ; QC4.3 v2(35.67,10.1) ; v2(9.65,90.22) 9.2,90.22 8.95,89.97 CX11.2 ; v2(139.85,116.39) 139.85,116.81 PC1071.2 ; RV94.2 v2(30.28,79.18) ; v2(62.49,78.98) 62.49,79.07 PC844.2 ; RS24.2 182.43,16.76 v2(182.87,17.2) 183.32,16.76 RS21.2 ; CC126.2 147.35,101.38 CC86.2 ; v2(119.78,45.38) 120.18,45.77 CD15.2 ; C2306.2 v2(168.33,8.63) ; v2(54.54,85.3) 54.05,85.8 CV40.2 ; RE385.2 v2(114.55,3.99) ; JTP.10 v2(20.19,57.2) ; RI50.1 v2(16.62,84.62) ; v2(60.13,57.27) 60.13,57.8 PC840.2 ; SW1.6 v2(174.48,118.37) ; CV255.2 v2(30.41,82.22) ; CE84.2 123.09,16.18 122.87,16.41 v2(122.87,16.95) ; CD40.2 137.41,27.91 v2(137.42,27.91) ; CI26.2 v2(192.84,40.19) ; CD41.2 141.92,28.28 v2(141.9,28.3) ; PC645.2 v2(82.24,112.02) ; RM9.2 180.78,64.44 v2(180.95,64.27) ; CE89.1 v2(150.3,4.63) ; v2(197.48,71.43) 197.48,72.18 RX34.2 ; RC5.2 RC6.2 143.88,73.45 143.88,72.7 145.28,71.3 v2(145.89,71.3) 146.03,71.16 RC121.2 ; C5231.2 150.49,12.69 151.06,12.69 v2(151.19,12.82) ; v2(67.93,81.75) 67.92,81.75 67.84,81.75 67.11,82.48 CV54.2 ; CC141.2 125.98,88.18 v2(125.98,88.83) 126.36,88.83 126.68,89.15 PC1069.2 ; JKB.31 v2(87.79,22.2) ; CD44.2 132,33.07 v2(132,32.47) ; RX49.2 v2(11.87,89.65) ; RD21.2 151.12,29.63 v2(150.68,30.07) ; v2(65.42,81.8) 64.6,80.98 CV53.2 ; SW1.1 v2(172.28,113.96) ; v2(65.53,73.17) 65.87,72.83 PC821.2 ; CX51.2 v2(13.9,100.85) ; CC42.2 v2(126.49,69.46) ; v2(119.18,24.12) 119.37,23.93 CE57.2 ; C2305.2 v2(169.6,8.69) ; CS42.2 v2(179.13,6.53) ; CV301.1 v2(94.35,89.72) ; CE72.2 141.47,1.85 v2(141.47,2.28) ; CE87.2 126.74,18.47 126.58,18.31 v2(126.58,17.77) ; PR29.2 37.59,112.72 v2(37.59,112.07) ; RA32.2 187.5,21.52 v2(187.76,21.26) ; CV293.2 94.42,61.08 v2(94.86,61.52) 94.42,61.97 CV63.2 ; QI1.1 v2(16.2,36.69) ; CA54.2 v2(201.22,14.41) ; SW1.5 v2(173.5,112.5) ; QE8.3 25.47,68.01 v2(26.16,68.7) ; CE24.2 2.52,75.29 v2(2.79,75.56) ; CV162.2 v2(63.82,91.93) ; v2(47.24,97.97) 47.55,97.65 CV248.2 CV249.2 CV251.2 ; CX22.2 198.38,82.16 v2(197.82,81.6) ; PR33.1 v2(29.14,113.47) ; CC40.2 v2(126.49,70.73) ; v2(149.17,75.1) CC11.1 ; CI23.1 v2(26.03,86.99) ; CV205.2 v2(76.96,98.8) ; CE64.1 v2(139.38,23.49)
  GND1 w0.254: 181.17,32.1 H4.1 ; H4.1 183,30.27 ; H4.1 184.34,33.44 ; H4.1 184.34,30.76 ; H4.1 181.66,33.44 ; H4.1 184.83,32.1 ; H4.1 181.66,30.76 ; H4.1 183,33.93 ; 99.66,2.16 H6.1 ; H6.1 99.17,3.5 ; H6.1 102.34,4.84 ; H6.1 102.34,2.16 ; H6.1 99.66,4.84 ; H6.1 101,5.33 ; H6.1 102.83,3.5 ; H6.1 101,1.67 ; 13.95,11.44 PBATT.1 ; PBATT.1 13.14,13.33 ; PBATT.1 15.03,12.52 ; PBATT.1 14.76,13.33 ; PBATT.1 13.14,11.71 ; PBATT.1 14.76,11.71 ; PBATT.1 12.87,12.52 ; 20.76,93.44 H11.1 ; H11.1 20.27,92.1 ; H11.1 22.1,90.27 ; H11.1 23.44,93.44 ; H11.1 23.93,92.1 ; H11.1 20.76,90.76 ; H11.1 22.1,93.93 ; H11.1 23.44,90.76 ; 199.89,73.1 JUSB1.12 ; JUSB1.12 203.45,73.97 ; JUSB1.12 199.89,73.97 ; JUSB1.12 201.67,73.97 ; JUSB1.12 203.45,73.1 ; JUSB1.12 199.89,72.22 ; H14.1 166.63,82.73 ; H14.1 163.37,79.47 ; H14.1 162.76,81.1 ; H14.1 167.24,81.1 ; H14.1 163.37,82.73 ; H14.1 166.63,79.47 ; H14.1 165,78.86 ; H14.1 165,83.34 ; PBATT.2 15.03,14.52 ; PBATT.2 14.76,15.33 ; PBATT.2 13.14,13.71 ; PBATT.2 14.76,13.71 ; PBATT.2 13.14,15.33 ; PBATT.2 12.87,14.52 ; 204.58,97.55 JLAN.10 ; JLAN.10 207.62,97.55 ; JLAN.10 206.1,96.83 ; JLAN.10 207.62,96.83 ; JLAN.10 204.58,96.83 ; JUSB2.10 203.45,39.2 ; JUSB2.10 199.89,39.2 ; JUSB2.10 199.89,40.07 ; 162.76,105.4 H13.1 ; H13.1 163.37,107.03 ; H13.1 163.37,103.77 ; H13.1 166.63,103.77 ; H13.1 165,107.64 ; H13.1 165,103.16 ; H13.1 167.24,105.4 ; H13.1 166.63,107.03 ; 180.21,89.83 H19.1 ; H19.1 181.73,93.43 ; H19.1 180.21,92.87 ; H19.1 183.25,89.83 ; H19.1 181.73,89.27 ; H19.1 183.25,92.87 ; H19.1 179.65,91.35 ; H19.1 183.81,91.35 ; 81.46,56.46 H8.1 ; H8.1 82.8,59.63 ; H8.1 84.14,59.14 ; H8.1 84.63,57.8 ; H8.1 81.46,59.14 ; H8.1 84.14,56.46 ; H8.1 80.97,57.8 ; H8.1 82.8,55.97 ; H3.1 196.84,97.74 ; H3.1 194.16,97.74 ; H3.1 195.5,94.57 ; H3.1 194.16,95.06 ; H3.1 197.33,96.4 ; H3.1 196.84,95.06 ; H3.1 193.67,96.4 ; H3.1 195.5,98.23 ; 13.14,17.71 PBATT.4 ; PBATT.4 13.14,19.33 ; PBATT.4 12.87,18.52 ; PBATT.4 15.03,18.52 ; PBATT.4 14.76,19.33 ; PBATT.4 14.76,17.71 ; JUSB1.13 208.77,73.97 ; JUSB1.13 207.4,73.1 ; JUSB1.13 210.14,73.97 ; JUSB1.13 210.14,73.1 ; 199.29,49.72 JUSB2.4 ; JUSB2.4 198.65,51.18 ; JUSB2.4 198.65,49.91 ; JUSB2.4 199.92,49.91 ; JUSB2.4 199.29,51.37 ; JUSB2.4 198.46,50.55 ; 164.46,68.46 H12.1 ; H12.1 163.97,69.8 ; H12.1 164.46,71.14 ; H12.1 167.14,71.14 ; H12.1 165.8,71.63 ; H12.1 167.63,69.8 ; H12.1 167.14,68.46 ; H12.1 165.8,67.97 ; 200.57,78.88 JHDMI.22 ; JHDMI.22 201.85,78.88 ; JHDMI.22 200.57,77.95 ; JHDMI.22 203.13,77.02 ; JHDMI.22 201.85,77.02 ; JHDMI.22 203.13,78.88 ; JHDMI.22 203.13,77.95 ; JHDMI.22 200.57,77.02 ; 193.17,4 H5.1 ; H5.1 196.83,4 ; H5.1 196.34,2.66 ; H5.1 193.66,2.66 ; H5.1 193.66,5.34 ; H5.1 195,2.17 ; H5.1 195,5.83 ; H5.1 196.34,5.34 ; H16.1 103.43,82.73 ; H16.1 101.8,83.34 ; H16.1 104.04,81.1 ; H16.1 100.17,79.47 ; H16.1 103.43,79.47 ; H16.1 100.17,82.73 ; H16.1 101.8,78.86 ; H16.1 99.56,81.1 ; 81.93,91.83 H17.1 ; H17.1 83.45,91.27 ; H17.1 83.45,95.43 ; H17.1 84.97,91.83 ; H17.1 85.53,93.35 ; H17.1 81.93,94.87 ; H17.1 81.37,93.35 ; H17.1 84.97,94.87 ; H9.1 29.14,120.14 ; H9.1 29.63,118.8 ; H9.1 25.97,118.8 ; H9.1 27.8,120.63 ; H9.1 26.46,120.14 ; H9.1 29.14,117.46 ; H9.1 27.8,116.97 ; H9.1 26.46,117.46 ; 207.4,57.4 JUSB1.11 ; JUSB1.11 210.14,57.4 ; JUSB1.11 207.4,56.52 ; JUSB1.11 210.14,56.52 ; JUSB1.11 208.77,56.52 ; 201.42,86.2 JHDMI.8 ; JHDMI.8 202.46,85.74 ; JHDMI.8 201.54,86.66 ; JHDMI.8 201.54,85.74 ; JHDMI.8 202.58,86.2 ; JHDMI.8 202.46,86.66 ; JHDMI.21 210.05,95.28 ; JHDMI.21 208.77,95.28 ; JHDMI.21 210.05,93.42 ; JHDMI.21 211.33,93.42 ; JHDMI.21 208.77,94.35 ; JHDMI.21 211.33,94.35 ; JHDMI.21 211.33,95.28 ; JHDMI.21 208.77,93.42 ; JUSB2.12 203.45,54.9 ; JUSB2.12 199.89,54.9 ; JUSB2.12 201.67,55.77 ; JUSB2.12 203.45,55.77 ; JUSB2.12 199.89,55.77 ; JUSB2.12 199.89,54.02 ; PBATT.10 14.2,32.62 ; PBATT.10 14.2,30.67 ; PBATT.10 16.08,31.64 ; PBATT.10 12.32,30.67 ; PBATT.10 16.08,32.62 ; PBATT.10 12.32,31.64 ; PBATT.10 12.32,32.62 ; PBATT.10 16.08,30.67 ; JHDMI.11 204.01,84.24 ; JHDMI.11 202.97,84.7 ; JHDMI.11 204.01,85.16 ; JHDMI.11 204.13,84.7 ; JHDMI.11 203.09,84.24 ; JHDMI.11 203.09,85.16 ; 44.47,56.05 H18.1 ; H18.1 46.55,58.13 ; H18.1 45.03,57.57 ; H18.1 45.03,54.53 ; H18.1 48.63,56.05 ; H18.1 46.55,53.97 ; H18.1 48.07,57.57 ; H18.1 48.07,54.53 ; 201.54,88.74 JHDMI.2 ; JHDMI.2 202.46,89.66 ; JHDMI.2 202.46,88.74 ; JHDMI.2 202,89.78 ; JHDMI.2 201.54,89.66 ; JHDMI.2 202.58,89.2 ; JHDMI.2 201.42,89.2 ; JUSB2.7 200.79,47.87 ; JUSB2.7 200.16,46.41 ; JUSB2.7 200.79,46.22 ; JUSB2.7 199.96,47.05 ; JUSB2.7 200.16,47.68 ; 203.09,88.16 JHDMI.5 ; JHDMI.5 204.01,87.24 ; JHDMI.5 203.09,87.24 ; JHDMI.5 202.97,87.7 ; JHDMI.5 204.13,87.7 ; JHDMI.5 204.01,88.16 ; 21.8,7.97 H7.1 ; H7.1 20.46,8.46 ; H7.1 23.14,8.46 ; H7.1 19.97,9.8 ; H7.1 21.8,11.63 ; H7.1 23.14,11.14 ; H7.1 23.63,9.8 ; H7.1 20.46,11.14 ; 210.02,76.05 JHDMI.23 ; JHDMI.23 210.02,75.12 ; JHDMI.23 211.3,76.98 ; JHDMI.23 212.58,75.12 ; JHDMI.23 212.58,76.05 ; JHDMI.23 211.3,75.12 ; JHDMI.23 210.02,76.98 ; JHDMI.23 212.58,76.98 ; JUSB1.10 203.45,56.52 ; JUSB1.10 203.45,57.4 ; JUSB1.10 201.67,56.52 ; JUSB1.10 199.89,57.4 ; JUSB1.10 199.89,56.52 ; JUSB1.10 199.89,58.27 ; 200.79,64.42 JUSB1.7 ; JUSB1.7 200.16,65.88 ; JUSB1.7 199.96,65.25 ; JUSB1.7 200.16,64.61 ; JUSB1.7 200.79,66.07 ; PBATT.11 14.2,10.37 ; PBATT.11 12.32,10.37 ; PBATT.11 12.32,8.42 ; PBATT.11 14.2,8.42 ; PBATT.11 16.08,8.42 ; PBATT.11 16.08,9.39 ; PBATT.11 12.32,9.39 ; PBATT.11 16.08,10.37 ; 198.46,68.75 JUSB1.4 ; JUSB1.4 198.65,69.38 ; JUSB1.4 199.29,67.92 ; JUSB1.4 199.29,69.57 ; JUSB1.4 198.65,68.11 ; JUSB1.4 199.92,68.11 ; JHDMI.17 204.01,81.24 ; JHDMI.17 203.09,82.16 ; JHDMI.17 203.09,81.24 ; JHDMI.17 202.97,81.7 ; JHDMI.17 204.01,82.16 ; JHDMI.17 204.13,81.7 ; JHDMI.20 203.13,93.38 ; JHDMI.20 203.13,91.52 ; JHDMI.20 203.13,92.45 ; JHDMI.20 201.85,91.52 ; JHDMI.20 200.57,92.45 ; JHDMI.20 201.85,93.38 ; JHDMI.20 200.57,93.38 ; JHDMI.20 200.57,91.52 ; 197.06,117.46 H2.1 ; H2.1 199.74,117.46 ; H2.1 199.74,120.14 ; H2.1 197.06,120.14 ; H2.1 196.57,118.8 ; H2.1 198.4,120.63 ; H2.1 198.4,116.97 ; H2.1 200.23,118.8 ; H15.1 103.44,107.05 ; H15.1 101.81,107.66 ; H15.1 100.18,107.05 ; H15.1 100.18,103.79 ; H15.1 99.57,105.42 ; H15.1 103.44,103.79 ; H15.1 101.81,103.19 ; H15.1 104.04,105.42 ; JLAN.9 207.62,114.27 ; JLAN.9 206.1,114.27 ; JLAN.9 204.58,114.27 ; JLAN.9 204.58,113.55 ; JLAN.9 207.62,113.55 ; JUSB2.13 210.14,55.77 ; JUSB2.13 208.77,55.77 ; JUSB2.13 207.4,55.77 ; JUSB2.13 210.14,54.9 ; JUSB2.13 207.4,54.9
  VCC w0.254: H2.1 200.23,118.8 ; H2.1 199.74,117.46 ; H2.1 199.74,120.14 ; H2.1 198.4,120.63 ; H2.1 197.06,117.46 ; H2.1 197.06,120.14 ; H2.1 198.4,116.97 ; 201.42,86.2 JHDMI.8 ; JHDMI.8 202.58,86.2 ; JHDMI.8 202.46,85.74 ; JHDMI.8 201.54,85.74 ; JHDMI.8 202.46,86.66 ; JHDMI.8 201.54,86.66 ; H8.1 84.14,56.46 ; H8.1 81.46,59.14 ; H8.1 80.97,57.8 ; H8.1 82.8,59.63 ; H8.1 82.8,55.97 ; H8.1 84.14,59.14 ; H8.1 81.46,56.46 ; H8.1 84.63,57.8 ; 14.2,30.67 PBATT.10 ; PBATT.10 16.08,31.64 ; PBATT.10 16.08,32.62 ; PBATT.10 16.08,30.67 ; PBATT.10 14.2,32.62 ; 22.1,90.27 H11.1 ; H11.1 22.1,93.93 ; H11.1 23.93,92.1 ; H11.1 23.44,90.76 ; H11.1 23.44,93.44 ; H11.1 20.76,90.76 ; H11.1 20.27,92.1 ; H11.1 20.76,93.44 ; JHDMI.21 210.05,95.28 ; JHDMI.21 208.77,95.28 ; JHDMI.21 208.77,94.35 ; JUSB2.12 201.67,55.77 ; JUSB2.12 199.89,54.9 ; JUSB2.12 199.89,54.02 ; JUSB2.12 203.45,55.77 ; JUSB2.12 199.89,55.77 ; PBATT.11 16.08,8.42 ; PBATT.11 14.2,8.42 ; PBATT.11 14.2,10.37 ; PBATT.11 16.08,9.39 ; PBATT.11 16.08,10.37 ; JLAN.10 207.62,96.83 ; JLAN.10 206.1,96.83 ; JLAN.10 204.58,96.83 ; 201.85,77.02 JHDMI.22 ; JHDMI.22 200.57,77.02 ; JHDMI.22 201.85,78.88 ; JHDMI.22 200.57,78.88 ; JHDMI.22 200.57,77.95 ; H9.1 27.8,120.63 ; H9.1 26.46,117.46 ; H9.1 29.63,118.8 ; H9.1 25.97,118.8 ; H9.1 29.14,120.14 ; H9.1 26.46,120.14 ; H9.1 29.14,117.46 ; H9.1 27.8,116.97 ; JUSB1.4 199.92,68.11 ; JUSB1.4 198.65,68.11 ; JUSB1.4 199.29,67.92 ; JUSB1.4 198.65,69.38 ; JUSB1.4 199.29,69.57 ; JUSB1.4 198.46,68.75 ; 194.16,97.74 H3.1 ; H3.1 195.5,98.23 ; H3.1 196.84,97.74 ; H3.1 195.5,94.57 ; H3.1 196.84,95.06 ; H3.1 197.33,96.4 ; H3.1 193.67,96.4 ; H3.1 194.16,95.06 ; 199.89,57.4 JUSB1.10 ; JUSB1.10 199.89,56.52 ; JUSB1.10 201.67,56.52 ; JUSB1.10 199.89,58.27 ; JUSB1.10 203.45,56.52 ; 210.02,75.12 JHDMI.23 ; JHDMI.23 211.3,75.12 ; JHDMI.23 210.02,76.05 ; H19.1 183.81,91.35 ; H19.1 183.25,92.87 ; H19.1 180.21,92.87 ; H19.1 181.73,93.43 ; H19.1 179.65,91.35 ; H19.1 183.25,89.83 ; H19.1 180.21,89.83 ; H19.1 181.73,89.27 ; 203.09,87.24 JHDMI.5 ; JHDMI.5 202.97,87.7 ; JHDMI.5 203.09,88.16 ; 99.56,81.1 H16.1 ; H16.1 103.43,82.73 ; H16.1 101.8,83.34 ; H16.1 103.43,79.47 ; H16.1 104.04,81.1 ; H16.1 100.17,79.47 ; H16.1 101.8,78.86 ; H16.1 100.17,82.73 ; 21.8,7.97 H7.1 ; H7.1 23.14,11.14 ; H7.1 20.46,8.46 ; H7.1 19.97,9.8 ; H7.1 23.63,9.8 ; H7.1 21.8,11.63 ; H7.1 20.46,11.14 ; H7.1 23.14,8.46 ; JHDMI.20 201.85,93.38 ; JHDMI.20 201.85,91.52 ; JHDMI.20 200.57,91.52 ; JHDMI.20 200.57,93.38 ; JHDMI.20 200.57,92.45 ; 207.4,55.77 JUSB2.13 ; JUSB2.13 208.77,55.77 ; JUSB2.13 210.14,55.77 ; PBATT.2 14.76,13.71 ; PBATT.2 14.76,15.33 ; PBATT.2 15.03,14.52 ; 201.54,89.66 JHDMI.2 ; JHDMI.2 202.58,89.2 ; JHDMI.2 202.46,89.66 ; JHDMI.2 202.46,88.74 ; JHDMI.2 201.42,89.2 ; JHDMI.2 202,89.78 ; JHDMI.2 201.54,88.74 ; 81.37,93.35 H17.1 ; H17.1 84.97,94.87 ; H17.1 81.93,91.83 ; H17.1 83.45,95.43 ; H17.1 84.97,91.83 ; H17.1 85.53,93.35 ; H17.1 83.45,91.27 ; H17.1 81.93,94.87 ; JUSB2.4 199.29,51.37 ; JUSB2.4 199.92,49.91 ; JUSB2.4 199.29,49.72 ; JUSB2.4 198.65,49.91 ; JUSB2.4 198.46,50.55 ; JUSB2.4 198.65,51.18 ; 200.16,64.61 JUSB1.7 ; JUSB1.7 199.96,65.25 ; JUSB1.7 200.16,65.88 ; 203.09,85.16 JHDMI.11 ; JHDMI.11 203.09,84.24 ; JHDMI.11 202.97,84.7 ; PBATT.1 14.76,13.33 ; PBATT.1 14.76,11.71 ; PBATT.1 15.03,12.52 ; PBATT.1 13.95,11.44 ; 204.58,114.27 JLAN.9 ; JLAN.9 207.62,114.27 ; JLAN.9 206.1,114.27 ; PBATT.4 14.76,19.33 ; PBATT.4 14.76,17.71 ; PBATT.4 15.03,18.52 ; JUSB1.12 203.45,73.97 ; JUSB1.12 199.89,73.97 ; JUSB1.12 201.67,73.97 ; JUSB1.12 199.89,73.1 ; JUSB1.12 199.89,72.22 ; 200.16,46.41 JUSB2.7 ; JUSB2.7 199.96,47.05 ; JUSB2.7 200.16,47.68 ; 202.97,81.7 JHDMI.17 ; JHDMI.17 203.09,82.16 ; JHDMI.17 203.09,81.24 ; 208.77,56.52 JUSB1.11 ; JUSB1.11 207.4,56.52 ; JUSB1.11 210.14,56.52
  GND2 w0.254: JUSB2.12 201.67,55.77 ; JUSB2.12 199.89,54.02 ; JUSB2.12 199.89,55.77 ; JUSB2.12 199.89,54.9 ; JUSB2.12 203.45,54.9 ; JUSB2.12 203.45,55.77 ; 199.89,58.27 JUSB1.10 ; JUSB1.10 199.89,57.4 ; JUSB1.10 201.67,56.52 ; JUSB1.10 203.45,57.4 ; JUSB1.10 203.45,56.52 ; JUSB1.10 199.89,56.52 ; JLAN.9 206.1,114.27 ; JLAN.9 204.58,113.55 ; JLAN.9 207.62,113.55 ; JLAN.9 204.58,114.27 ; JLAN.9 207.62,114.27 ; H16.1 103.43,82.73 ; H16.1 100.17,82.73 ; H16.1 103.43,79.47 ; H16.1 100.17,79.47 ; H16.1 101.8,78.86 ; H16.1 101.8,83.34 ; H16.1 99.56,81.1 ; H16.1 104.04,81.1 ; 162.76,81.1 H14.1 ; H14.1 165,83.34 ; H14.1 165,78.86 ; H14.1 166.63,82.73 ; H14.1 167.24,81.1 ; H14.1 163.37,82.73 ; H14.1 166.63,79.47 ; H14.1 163.37,79.47 ; H15.1 104.04,105.42 ; H15.1 101.81,107.66 ; H15.1 100.18,107.05 ; H15.1 103.44,107.05 ; H15.1 101.81,103.19 ; H15.1 103.44,103.79 ; H15.1 100.18,103.79 ; H15.1 99.57,105.42 ; JHDMI.17 204.01,81.24 ; JHDMI.17 203.09,82.16 ; JHDMI.17 202.97,81.7 ; JHDMI.17 204.01,82.16 ; JHDMI.17 203.09,81.24 ; JHDMI.17 204.13,81.7 ; 14.2,8.42 PBATT.11 ; PBATT.11 12.32,9.39 ; PBATT.11 16.08,9.39 ; PBATT.11 12.32,8.42 ; PBATT.11 14.2,10.37 ; PBATT.11 16.08,10.37 ; PBATT.11 16.08,8.42 ; PBATT.11 12.32,10.37 ; 198.65,49.91 JUSB2.4 ; JUSB2.4 198.65,51.18 ; JUSB2.4 199.29,51.37 ; JUSB2.4 198.46,50.55 ; JUSB2.4 199.92,49.91 ; JUSB2.4 199.29,49.72 ; 13.14,13.33 PBATT.1 ; PBATT.1 12.87,12.52 ; PBATT.1 14.76,11.71 ; PBATT.1 13.14,11.71 ; PBATT.1 13.95,11.44 ; PBATT.1 14.76,13.33 ; PBATT.1 15.03,12.52 ; 13.14,17.71 PBATT.4 ; PBATT.4 13.14,19.33 ; PBATT.4 14.76,19.33 ; PBATT.4 14.76,17.71 ; PBATT.4 12.87,18.52 ; PBATT.4 15.03,18.52 ; 201.42,89.2 JHDMI.2 ; JHDMI.2 202.58,89.2 ; JHDMI.2 201.54,88.74 ; JHDMI.2 202,89.78 ; JHDMI.2 202.46,89.66 ; JHDMI.2 202.46,88.74 ; JHDMI.2 201.54,89.66 ; 199.89,72.22 JUSB1.12 ; JUSB1.12 199.89,73.1 ; JUSB1.12 203.45,73.97 ; JUSB1.12 201.67,73.97 ; JUSB1.12 203.45,73.1 ; JUSB1.12 199.89,73.97 ; 99.66,4.84 H6.1 ; H6.1 102.34,4.84 ; H6.1 102.83,3.5 ; H6.1 99.17,3.5 ; H6.1 99.66,2.16 ; H6.1 101,1.67 ; H6.1 102.34,2.16 ; H6.1 101,5.33 ; JHDMI.20 201.85,93.38 ; JHDMI.20 203.13,91.52 ; JHDMI.20 203.13,93.38 ; JHDMI.20 203.13,92.45 ; JHDMI.20 201.85,91.52 ; JHDMI.20 200.57,92.45 ; JHDMI.20 200.57,91.52 ; JHDMI.20 200.57,93.38 ; JHDMI.22 203.13,77.95 ; JHDMI.22 201.85,77.02 ; JHDMI.22 201.85,78.88 ; JHDMI.22 200.57,77.95 ; JHDMI.22 203.13,78.88 ; JHDMI.22 203.13,77.02 ; JHDMI.22 200.57,77.02 ; JHDMI.22 200.57,78.88 ; JUSB1.4 199.29,69.57 ; JUSB1.4 198.65,68.11 ; JUSB1.4 198.46,68.75 ; JUSB1.4 199.29,67.92 ; JUSB1.4 198.65,69.38 ; JUSB1.4 199.92,68.11 ; H5.1 196.83,4 ; H5.1 196.34,5.34 ; H5.1 195,5.83 ; H5.1 195,2.17 ; H5.1 193.66,2.66 ; H5.1 196.34,2.66 ; H5.1 193.17,4 ; H5.1 193.66,5.34 ; JHDMI.11 204.01,84.24 ; JHDMI.11 204.13,84.7 ; JHDMI.11 202.97,84.7 ; JHDMI.11 204.01,85.16 ; JHDMI.11 203.09,84.24 ; JHDMI.11 203.09,85.16 ; H12.1 167.14,71.14 ; H12.1 163.97,69.8 ; H12.1 164.46,68.46 ; H12.1 165.8,67.97 ; H12.1 165.8,71.63 ; H12.1 167.63,69.8 ; H12.1 167.14,68.46 ; H12.1 164.46,71.14 ; 208.77,56.52 JUSB1.11 ; JUSB1.11 210.14,56.52 ; JUSB1.11 210.14,57.4 ; JUSB1.11 207.4,56.52 ; JUSB1.11 207.4,57.4 ; 20.27,92.1 H11.1 ; H11.1 23.44,90.76 ; H11.1 20.76,90.76 ; H11.1 22.1,93.93 ; H11.1 23.44,93.44 ; H11.1 22.1,90.27 ; H11.1 20.76,93.44 ; H11.1 23.93,92.1 ; 12.32,32.62 PBATT.10 ; PBATT.10 14.2,32.62 ; PBATT.10 16.08,32.62 ; PBATT.10 14.2,30.67 ; PBATT.10 16.08,31.64 ; PBATT.10 12.32,31.64 ; PBATT.10 16.08,30.67 ; PBATT.10 12.32,30.67 ; 210.02,76.98 JHDMI.23 ; JHDMI.23 212.58,75.12 ; JHDMI.23 211.3,75.12 ; JHDMI.23 210.02,76.05 ; JHDMI.23 212.58,76.05 ; JHDMI.23 210.02,75.12 ; JHDMI.23 212.58,76.98 ; JHDMI.23 211.3,76.98 ; H9.1 27.8,120.63 ; H9.1 29.14,120.14 ; H9.1 26.46,117.46 ; H9.1 26.46,120.14 ; H9.1 27.8,116.97 ; H9.1 25.97,118.8 ; H9.1 29.63,118.8 ; H9.1 29.14,117.46 ; H18.1 48.07,57.57 ; H18.1 45.03,57.57 ; H18.1 44.47,56.05 ; H18.1 45.03,54.53 ; H18.1 46.55,58.13 ; H18.1 48.63,56.05 ; H18.1 48.07,54.53 ; H18.1 46.55,53.97 ; H7.1 21.8,11.63 ; H7.1 20.46,11.14 ; H7.1 20.46,8.46 ; H7.1 23.63,9.8 ; H7.1 19.97,9.8 ; H7.1 23.14,11.14 ; H7.1 23.14,8.46 ; H7.1 21.8,7.97 ; H17.1 84.97,94.87 ; H17.1 83.45,95.43 ; H17.1 81.37,93.35 ; H17.1 83.45,91.27 ; H17.1 81.93,91.83 ; H17.1 81.93,94.87 ; H17.1 85.53,93.35 ; H17.1 84.97,91.83 ; JUSB2.13 210.14,55.77 ; JUSB2.13 208.77,55.77 ; JUSB2.13 207.4,55.77 ; JUSB2.13 210.14,54.9 ; JUSB2.13 207.4,54.9 ; 201.54,86.66 JHDMI.8 ; JHDMI.8 202.46,85.74 ; JHDMI.8 201.42,86.2 ; JHDMI.8 201.54,85.74 ; JHDMI.8 202.46,86.66 ; JHDMI.8 202.58,86.2 ; H3.1 197.33,96.4 ; H3.1 196.84,95.06 ; H3.1 193.67,96.4 ; H3.1 194.16,95.06 ; H3.1 195.5,98.23 ; H3.1 195.5,94.57 ; H3.1 196.84,97.74 ; H3.1 194.16,97.74 ; H2.1 199.74,120.14 ; H2.1 196.57,118.8 ; H2.1 197.06,117.46 ; H2.1 199.74,117.46 ; H2.1 200.23,118.8 ; H2.1 198.4,120.63 ; H2.1 198.4,116.97 ; H2.1 197.06,120.14 ; 199.96,65.25 JUSB1.7 ; JUSB1.7 200.16,64.61 ; JUSB1.7 200.79,66.07 ; JUSB1.7 200.16,65.88 ; JUSB1.7 200.79,64.42 ; 81.46,56.46 H8.1 ; H8.1 80.97,57.8 ; H8.1 81.46,59.14 ; H8.1 82.8,55.97 ; H8.1 84.63,57.8 ; H8.1 82.8,59.63 ; H8.1 84.14,56.46 ; H8.1 84.14,59.14 ; 181.73,89.27 H19.1 ; H19.1 183.25,92.87 ; H19.1 179.65,91.35 ; H19.1 181.73,93.43 ; H19.1 180.21,89.83 ; H19.1 183.81,91.35 ; H19.1 180.21,92.87 ; H19.1 183.25,89.83 ; 165,103.16 H13.1 ; H13.1 162.76,105.4 ; H13.1 165,107.64 ; H13.1 166.63,107.03 ; H13.1 167.24,105.4 ; H13.1 163.37,103.77 ; H13.1 163.37,107.03 ; H13.1 166.63,103.77 ; 203.09,88.16 JHDMI.5 ; JHDMI.5 203.09,87.24 ; JHDMI.5 202.97,87.7 ; JHDMI.5 204.13,87.7 ; JHDMI.5 204.01,87.24 ; JHDMI.5 204.01,88.16 ; 204.58,96.83 JLAN.10 ; JLAN.10 207.62,96.83 ; JLAN.10 204.58,97.55 ; JLAN.10 206.1,96.83 ; JLAN.10 207.62,97.55 ; 181.17,32.1 H4.1 ; H4.1 181.66,30.76 ; H4.1 184.34,30.76 ; H4.1 181.66,33.44 ; H4.1 184.34,33.44 ; H4.1 183,33.93 ; H4.1 183,30.27 ; H4.1 184.83,32.1 ; 13.14,13.71 PBATT.2 ; PBATT.2 14.76,13.71 ; PBATT.2 13.14,15.33 ; PBATT.2 15.03,14.52 ; PBATT.2 12.87,14.52 ; PBATT.2 14.76,15.33 ; JUSB1.13 210.14,73.1 ; JUSB1.13 207.4,73.1 ; JUSB1.13 208.77,73.97 ; JUSB1.13 210.14,73.97 ; 210.05,93.42 JHDMI.21 ; JHDMI.21 211.33,95.28 ; JHDMI.21 210.05,95.28 ; JHDMI.21 208.77,95.28 ; JHDMI.21 211.33,94.35 ; JHDMI.21 211.33,93.42 ; JHDMI.21 208.77,93.42 ; JHDMI.21 208.77,94.35 ; 199.89,40.07 JUSB2.10 ; JUSB2.10 199.89,39.2 ; JUSB2.10 203.45,39.2 ; 200.16,47.68 JUSB2.7 ; JUSB2.7 200.79,47.87 ; JUSB2.7 200.79,46.22 ; JUSB2.7 200.16,46.41 ; JUSB2.7 199.96,47.05
  BOTTOM w0.127: UC1.B39 129.09,101.98 129.09,102.48 129.6,102.99 129.6,104.26 129.47,104.39 128.07,104.39 127.85,104.61 127.85,108.86 v2(127.18,109.53) 126.87,109.85 126.29,109.85 v2(126.04,109.59) v2(126.04,108.51) 125.79,108.26 124.71,108.26 v2(124.45,108) v2(124.45,106.8) 124.45,106.16 124.83,105.78 124.83,101.91 124.56,101.64 UC1.B48 ; DI2.1 195.47,64.49 195.26,64.7 194.56,64.7 194.49,64.76 193.92,64.76 192.65,66.03 192.65,71.62 190.38,73.89 190.38,74.3 v2(190.56,74.48) 191,74.92 v3(192.91,74.92) 194.94,74.92 195.83,74.03 195.83,71.71 196.46,71.07 196.46,67.81 196.65,67.62 197.67,67.62 198.8,68.75 JUSB1.4
  BOTTOM w0.152: v2(118.21,79.4) 118.23,79.42 118.23,80.29 UC1.BB60 ; UC1.AT71 v2(110.76,83.79)
  BOTTOM w0.178: v2(110.79,98.48) 110.88,98.4 UC1.H71 ; UC1.BB34 132.97,80.04 132.97,78.76 v2(132.93,78.72) ; UC1.BB30 135.6,79.66 135.6,79.27 v2(135.73,79.14) ; v2(127.95,79.4) 128.02,79.47 UC1.BB43 ; v2(115.89,79.4) 115.89,79.78 UC1.BB64 ; UC1.BB26 137.95,79.91 137.95,79.4 v2(138,79.35) ; UC1.AG71 110.92,88.8 v2(110.7,89.02) ; v2(110.67,86.1) 110.72,86.14 111.51,86.14 UC1.AM71 ; UC1.BB38 130.63,80.3 130.63,79.41 v2(130.67,79.38) ; v2(120.89,79.4) 120.85,79.44 120.85,79.92 UC1.BB55 ; v2(141.73,79.39) 141.7,79.42 UC1.BB18
  BOTTOM w0.2: v2(65.44,85.05) 65,84.61 UV1.B14 ; v2(60.09,85.62) 60.16,85.55 60.16,84.72 UV1.B20 ; v2(57.19,85.97) 57.43,85.72 57.43,84.72 UV1.B23
  BOTTOM w0.203: UC1.F40 v2(129.78,98.84) UC1.F38 ; UC1.AW43 128.04,82.19 127.68,82.19 127.58,82.29 127.3,82.29 127.27,82.26 UC1.AW45 126.4,82.26 126.37,82.29 126.08,82.29 126.05,82.26 UC1.AW47 125.24,82.26 125.21,82.29 124.91,82.29 124.88,82.26 UC1.AW49 123.98,82.26 123.95,82.29 123.66,82.29 123.63,82.26 UC1.AW51 122.82,82.26 122.79,82.29 122.49,82.29 122.46,82.26 UC1.AW53 121.59,82.26 121.56,82.29 121.26,82.29 121.23,82.26 UC1.AW55 120.36,82.26 120.33,82.29 120.04,82.29 120.01,82.26 UC1.AW57 119.09,82.26 119.06,82.29 118.76,82.29 118.73,82.26 UC1.AW60 117.86,82.26 117.83,82.29 117.54,82.29 117.51,82.26 UC1.AW62 116.63,82.26 116.6,82.29 116.31,82.29 116.28,82.26 UC1.AW64 115.74,82.31 114.78,82.31 UC1.AW66 114.55,82.26 v2(114.18,82.26) ; v2(110,96.32) 110.14,96.32 110.43,96.61 110.76,96.61 111.19,97.04 UC1.K71 ; UC1.AT28 135.55,83.75 v2(135.25,84.06) 135.4,84.21 135.54,84.21 UC1.AR28 ; UC1.AL66 114.82,86.45 114.86,86.41 115.24,86.41 115.29,86.45 UC1.AL65 115.45,86.45 115.5,86.41 115.88,86.41 115.92,86.45 UC1.AL64 ; UC1.D53 122.15,100.78 122.15,101.48 UC1.B53 ; UC1.AF63 116.77,89.06 116.77,88.33 UC1.AH63 ; v2(122.9,88.37) 123.38,87.89 UC1.AL52 ; UC1.K70 112.78,97.04 112.94,97.25 ; UC1.AW34 132.59,82.26 132.55,82.29 132.26,82.29 132.23,82.26 UC1.AW36 131.62,82.44 131.01,82.44 130.83,82.26 UC1.AW38 130.26,82.26 v2(129.9,82.62) ; UC1.J28 v2(135.27,97.44) ; UC1.T2 UC1.T4 149.9,94.46 v2(149.66,94.23) 149.37,94.52 UC1.R6 UC1.N6 ; UV1.AB14 64.6,68.44 63.79,68.44 v2(63.77,68.46) ; UC1.D45 UC1.D44 ; UC1.AF4 150.42,88.89 150.86,88.89 UC1.AF2 UC1.AF1 152.36,89.16 v2(152.5,89.02) ; v2(10.72,54.8) 9.57,54.8 JCAM3D.10 ; UC1.J38 v2(129.78,97.44) ; v2(114.18,82.26) 114.09,82.26 UC1.AV68 113.27,82.59 v2(113.14,82.72) ; v2(114.18,82.26) 114.2,82.23 114.57,81.64 UC1.AY66 UC1.BA66 ; UV1.AF8 69.96,63.54 v2(69.89,63.47) ; UC1.AV1 152.53,82.47 v2(152.67,82.33) ; UC1.AM68 113.75,85.76 113.78,85.73 113.78,85.43 113.75,85.4 UC1.AP68 113.75,84.53 113.78,84.5 113.78,84.21 113.75,84.18 UC1.AT68 ; UC1.AM68 113.86,86.24 v2(114.21,85.89) ; UC1.AM68 113.75,86.63 113.83,86.72 113.83,86.99 113.42,87.4 UC1.AK68 113.46,87.47 v2(113.8,87.81) 113.8,87.93 114.07,88.2 UC1.AH67 ; v2(133.29,82.73) 133.75,82.26 UC1.AW32 134.76,82.26 134.79,82.29 135.08,82.29 135.11,82.26 UC1.AW30 135.56,82.2 135.93,82.2 136.01,82.29 136.31,82.29 136.34,82.26 UC1.AW28 137.21,82.26 137.24,82.29 137.54,82.29 137.57,82.26 UC1.AW26 138.44,82.26 138.47,82.29 138.76,82.29 138.79,82.26 UC1.AW23 139.76,82.26 139.79,82.29 140.09,82.29 140.12,82.26 UC1.AW21 140.91,82.26 140.94,82.29 141.24,82.29 141.27,82.26 UC1.AW18 142.18,82.26 142.21,82.29 142.51,82.29 142.54,82.26 UC1.AW16 142.99,82.26 v2(143.5,82.77) 144.01,82.26 UC1.AW14 144.6,82.26 144.64,82.29 144.93,82.29 144.96,82.26 UC1.AW12 145.73,82.26 v2(146.24,82.77) 146.54,82.47 UC1.AW10 147.03,82.26 147.06,82.29 147.35,82.29 147.38,82.26 UC1.AW8 148.17,82.26 148.2,82.29 148.5,82.29 148.53,82.26 UC1.AW6 ; v2(136.64,87.92) UC1.AK27 ; UC1.F1 152.5,99.77 v2(152.54,99.81) ; UC1.AU20 UC1.AT20 141.1,83.75 v2(140.77,84.09) ; UC1.K61 117.52,97.66 v2(118.1,97.08) ; JCAM3D.7 9.57,53.6 v2(10.74,53.6) ; v2(131.61,97.44) UC1.J35 ; v2(152.1,79.74) UC1.BA1 151.64,80.45 UC1.BA2 ; UC1.AL55 121.55,87.34 v2(121.12,87.78) ; v2(133.44,97.44) UC1.J32 ; v2(113.19,79.22) 113.37,79.22 113.89,79.74 UC1.BB67 ; UC1.W13 144.82,92.07 144.71,91.96 v2(144.71,91.98) ; UC1.AJ4 UC1.AL4 150.6,86.51 v2(150.64,86.55) 150.68,86.51 UC1.AL2 ; v2(119.72,87.52) UC1.AL58
  BOTTOM w0.25: v2(54.16,71.94) 54.51,72.29 55.03,72.29 UV1.U26
  BOTTOM w0.254: v2(143.5,82.77) UC1.AU15 ; v2(56.87,95.98) 57.27,95.58 UV4.D8 ; v2(46.33,83.3) 46.33,82.32 UV15.B3 ; UC1.AR50 123.97,84.4 v2(124.34,84.03) UC1.AR48 ; v2(34.12,66.02) 34.52,65.62 UV6.T9 ; UC1.AP63 116.29,85.05 v2(116.07,85.27) ; UC1.G58 v2(118.81,98.84) ; UV5.B9 v2(65.75,93.58) ; JDIMM2.128 149.05,27.49 148.42,28.12 148.42,28.53 v2(148.82,28.93) ; v2(147.19,99.62) 147.57,99.24 UC1.F8 148.26,99.89 UC1.E6 ; UC1.L18 142.02,96.28 v2(142.36,95.95) 142.36,96.02 UC1.L17 142.82,96.48 143.18,96.48 UC1.L16 ; UC1.D14 144.25,100.67 v2(144.25,101.11) 144.25,101.59 UC1.B14 ; UC1.AJ15 144.33,87.6 v2(144.33,87.56) 144.82,88.05 UC1.AH13 144.82,88.51 143.98,89.35 UC1.AF15 ; UC1.P17 142.64,94.66 v2(142.35,95.03) ; UC1.AW36 v2(131.79,81.75) UC1.BA36 ; UV9.M1 v2(58.47,101.58) ; UV9.J8 52.47,99.68 v2(52.17,99.98) ; UC1.P19 141.37,94.7 v2(141.05,95.03) ; UC1.C1 152.33,101.88 v2(152.33,102.23) ; v2(54.65,69.32) 55.07,69.74 UV1.Y26 ; v2(46.23,68.83) 46.23,67.74 UV14.B3 ; UC1.AT58 v2(118.83,84.08) UC1.AR58 ; v2(42.92,80.5) 42.92,80.5 UV15.E1 v2(43.72,79.7) ; v2(72.08,79.24) UV1.H5 ; UC1.B66 UC1.D66 114.56,100.5 v2(114.95,100.11) UC1.E65 ; v2(70.35,85) 69.96,84.61 UV1.B8 ; v2(114.21,85.89) 114.72,86.41 UC1.AL66 ; UC1.AR45 v2(126.1,84.04) UC1.AR46 ; UV5.M1 v2(72.95,101.58) ; v2(148.23,96.18) 148.07,96.44 UC1.L8 147.61,97.1 UC1.J8 ; UV7.G9 41.72,80.1 v2(42.12,79.7) ; UC1.AN28 v2(135.27,85.31) UC1.AN30 ; 142.35,89.21 142.68,88.89 UC1.AG17 ; 142.35,89.21 UC1.AF17 ; 142.35,89.21 UC1.AG18 141.93,88.79 141.89,88.76 141.51,88.76 141.47,88.79 UC1.AG19 ; UC1.D25 137.5,100.62 UC1.D26 136.86,101 v2(137.08,101.22) 137.17,101.31 UC1.C25 ; UV5.P9 66.11,103.58 65.78,103.25 v2(65.78,103.19) ; UC1.E15 144.38,99.51 v2(144.41,99.51) 144.6,99.51 UC1.F13 ; RPV6.7 81.43,69.68 v2(81.83,70.08) 81.72,70.18 RPV6.6 ; v2(110.84,102.09) 110.89,102.15 111.47,102.15 UC1.B71 ; v2(149.66,91.94) 149.66,92.01 ; 149.66,92.01 149.57,92.11 149.37,92.44 UC1.W6 ; 149.66,92.01 149.86,91.81 UC1.AA4 UC1.AA2 ; UC1.AW53 v2(122.03,81.75) UC1.BA53 ; UV4.G8 57.27,98.18 56.87,98.58 56.87,99.18 v2(56.87,99.18) UV9.J2 ; UC1.F23 138.6,99.37 139.25,99.37 UC1.F22 139.44,99.24 v2(139.82,98.86) 139.55,98.59 UC1.G22 ; v2(3.42,98.45) 3.03,98.45 2.57,98 JEDP.3 ; v2(52.87,95.98) 52.47,96.38 UV9.E8 ; UC1.AM25 v2(137.1,85.96) ; v2(57.67,95.98) 57.27,96.38 UV9.E2 ; UC1.B22 UC1.D22 139.34,100.59 v2(139.81,100.12) 139.84,100.12 139.84,100.11 UC1.E21 ; v2(37.79,72.65) 37.72,72.58 UV6.M1 ; UC1.AT42 v2(127.93,84.19) UC1.AR42 ; UV14.E1 v2(43.72,65.22) ; UV15.D8 v2(43.72,85.3) 43.32,85.7 UV7.E2 ; v2(72.95,103.98) 72.55,103.58 UV5.P1 ; UC1.AN38 v2(130.7,85.31) UC1.AN37 ; UC1.C5 149.84,101.23 UC1.D6 149.61,100.24 v2(150.31,100.24) 150.15,100.08 UC1.F4 UC1.F2 ; v2(143.01,90.05) UC1.AD16 142.91,90.89 142.36,90.89 UC1.AB18 ; v2(60.49,67.65) 60.1,68.04 UV1.AB20 ; v2(140.69,85.37) 141.02,85.7 UC1.AN20 ; v2(140.69,85.37) 141.01,85.05 UC1.AP20 ; v2(140.69,85.37) 140.69,85.99 140.33,86.35 UC1.AM21 ; UC1.K65 v2(115.03,96.95) UC1.K66 ; v2(141.64,98.23) UC1.H18 142.05,97.4 UC1.K18 ; UC1.G63 v2(115.96,98.84) ; UC1.U64 v2(116.35,93.27) UC1.U63 ; UV1.E8 69.96,82.09 v2(69.64,81.77) ; JEDP.20 2.98,89.5 v2(3.06,89.42) ; UC1.AT23 v2(138.01,84.04) UC1.AR23 ; v2(65.75,97.58) 66.15,97.98 UV5.G9 ; v2(125.21,85.96) UC1.AM46 125.21,86.81 UC1.AL48 ; v2(197.54,47.43) DI4.3 DI4.8 ; UC1.AF15 UC1.AG16 143.33,88.64 v2(143.05,88.36) 142.68,88.74 UC1.AG17 ; UC1.AF15 144.71,90.37 UC1.AD13 ; UC1.G43 127.5,98.58 UC1.J42 v2(127.95,97.46) ; UC1.A67 113.89,102.82 113.56,103.14 v2(113.56,103.24) ; UC1.P20 140.78,94.66 v2(141.05,95.03) ; v2(112.45,93.27) UC1.U69 ; UC1.A5 149.84,102.74 150.26,103.16 v2(150.26,103.26) ; UC1.AP38 v2(129.78,84.67) ; v2(114.4,93.27) UC1.U66 ; v2(112.7,100.11) 112.86,100.27 UC1.D69 UC1.F68 ; v2(147.71,87.78) 148.07,87.41 UC1.AK8 147.61,86.83 UC1.AM8 ; UV9.P9 51.49,103.75 v2(51.18,103.75) ; UV5.E8 v2(66.55,95.98) UV8.D1 v2(65.75,95.18) ; UC1.AG17 142.02,88.14 UC1.AJ18 142.02,87.96 141.84,87.77 141.84,87.31 UC1.AK18 ; UV6.J2 40.14,71.23 v2(40.49,70.88) 40.54,70.83 41.32,70.83 UV14.G8 ; UV1.AC8 69.98,67.2 v2(70.4,67.62) 70.8,68.02 UV1.AB7 ; v2(113.14,82.72) 113.14,82.7 112.84,82.4 UC1.AV69 UC1.AV70 UC1.AV71 110.93,82.4 v2(110.75,82.22) ; UC1.U70 v2(111.8,93.27) ; v2(131.12,103.12) 131.15,103.14 131.15,105.66 130.65,106.15 130.65,106.26 ; UC1.AM27 v2(136.18,85.96) ; UC1.AD62 v2(117.56,90.28) ; UV1.AD13 v2(66.26,66.82) 66.64,66.44 UV1.AD12 ; v2(71.35,97.58) UV8.G8 71.75,97.98 v2(72.15,97.58) ; v2(121.55,84.04) UC1.AR53 ; v2(66.47,105.67) 66.47,105.61 66.15,105.29 UV5.T9 ; v2(2.91,95.18) 2.74,95 JEDP.9 ; v2(67.86,68.51) 67.48,68.13 UV1.AB11 ; UV7.J8 v2(40.52,81.3) ; UV6.G9 v2(42.12,66.02) ; v2(133.37,103.15) 133.27,103.26 133.27,104.39 133.83,104.94 133.83,105.49 135.12,106.78 ; UC1.E71 110.92,100.2 v2(110.79,100.33) ; UC1.AN42 v2(127.95,85.31) ; v2(62.12,67.62) 62.52,68.02 UV1.AB17 ; v2(141.05,95.03) 141.37,95.42 UC1.N19 ; v2(58.47,93.58) 58.07,93.98 UV9.B1 ; v2(58.47,97.58) 58.07,97.98 UV9.G1 ; v2(55.1,85.96) UV1.A26 54.65,85.4 v2(54.54,85.3) 54.54,84.84 UV1.B27 ; UC1.N13 144.4,95.28 v2(144.4,95.02) 144.48,95.02 144.82,94.68 UC1.R13 144.01,93.86 UC1.T15 ; UC1.K64 v2(116.33,96.95) UC1.K63 ; UC1.N68 v2(113.75,95.1) ; UC1.AT35 v2(131.63,84.03) 132.07,84.37 UC1.AR35 ; v2(146.46,87.75) 146.12,87.41 UC1.AK11 145.69,86.86 145.37,86.86 UC1.AM13 ; UV7.B9 45.72,80.04 v2(46.06,79.7) ; UC1.F28 135.91,99.42 136.46,99.42 UC1.F27 136.87,99.24 137.1,99.01 v2(137.1,98.97) 137.1,98.97 UC1.J25 ; UC1.AN35 v2(131.61,85.31) ; UV8.A9 72.55,93.18 v2(72.95,92.78) ; v2(125.22,100.12) 125.37,100.12 125.91,100.66 UC1.D45 ; v2(125.22,100.12) UC1.D48 UC1.B48 ; v2(125.22,100.12) 125.15,100.18 UC1.D47 ; v2(125.22,100.12) UC1.E46 ; UC1.BA49 v2(124.43,81.75) ; v2(124.43,81.75) 124.25,81.94 UC1.AW50 ; v2(124.43,81.75) UC1.AW49 ; v2(116.32,87.78) UC1.AK63 ; v2(116.32,87.78) UC1.AH63 ; v2(116.32,87.78) UC1.AH64 ; UC1.AR43 127.7,84.61 v2(128,84.75) UC1.AP42 ; UV7.M1 37.72,86.67 v2(38.31,87.27) ; v2(34.82,80.51) 34.82,80.5 34.52,80.19 UV7.T9 ; UV9.T9 v2(52.04,105.55) ; UC1.BA45 v2(126.84,81.75) ; v2(64.58,64.4) 64.99,64.8 UV1.AF14 ; v2(112.45,90.56) 112.45,90.39 UC1.AE69 UC1.AE68 UC1.AE67 UC1.AE66 UC1.AE65 UC1.AE64 ; UC1.H15 144.61,97.29 UC1.J13 ; UC1.H15 143.33,97.31 UC1.K16 ; UC1.H15 143.71,97.94 v2(143.46,98.19) ; UV5.B1 72.55,93.98 v2(72.95,93.58) ; UV5.E2 71.75,96.38 v2(72.15,95.98) ; UC1.AK69 112.76,87.47 112.94,87.65 113.25,87.65 UC1.AK68 ; v2(3.07,90.61) 2.96,90.5 JEDP.18 ; UC1.AN33 v2(132.53,85.31) ; v2(126.12,98.86) 126.31,98.86 UC1.G45 ; UC1.AL38 130.7,87.59 v2(130.87,87.77) ; UC1.AW41 v2(129.32,81.75) UC1.BA41 ; UC1.AP23 v2(138.01,84.67) ; UV14.D1 44.12,65.63 v2(43.72,66.03) UV6.E8 ; v2(72.95,97.58) 72.55,97.98 UV5.G1 ; v2(60.48,63.49) 60.04,63.94 UV1.AF20 ; UC1.B34 v2(131.91,101.14) UC1.D34 ; UC1.AP28 v2(135.27,84.67) ; v2(72.84,85.04) 72.45,84.65 UV1.B5 ; v2(74.51,81.77) 74.89,82.15 UV1.E2 ; v2(127.04,85.96) 127.24,85.96 UC1.AN43 ; UV6.J8 40.11,66.43 v2(39.72,66.81) ; 143.05,92.63 UC1.V16 ; 143.05,92.63 143.03,92.63 UC1.V17 142.46,93.2 142.24,93.2 UC1.V18 142.02,92.93 v2(141.75,92.58) 141.42,92.15 UC1.Y19 ; 143.05,92.63 UC1.Y17 ; UC1.B30 134.39,101.35 v2(134.13,101.1) 134.39,100.84 UC1.D30 ; UC1.AR15 143.95,84.4 v2(143.52,84.06) 143.43,84.06 143.09,84.4 UC1.AR16 ; v2(36.51,72.39) 36.45,72.39 36.12,72.06 UV6.P1 ; UC1.AW62 v2(117.07,81.75) UC1.BA62 ; UV9.M9 51.5,101.98 v2(50.91,101.38) ; UV5.J2 71.75,99.59 v2(71.36,99.97) ; UC1.AM55 v2(120.64,85.96) ; v2(134.48,87.71) 134.35,87.58 UC1.AL32 ; UC1.AP35 v2(131.61,84.67) ; v2(34.8,79.19) 35.21,79.19 UV7.P9 ; v2(39.72,86.01) 40.02,85.7 UV7.J2 ; v2(116.98,100.11) 117.04,100.17 UC1.D62 UC1.B62 ; v2(38.12,65.22) UV6.M9 ; UC1.AR20 141.22,84.4 141.49,84.67 v2(141.67,84.67) 142.1,85.03 UC1.AP18 ; UV5.T1 72.55,105.18 v2(72.15,105.58) ; UV14.A9 v2(46.92,72.43) ; UC1.L20 UC1.N21 139.38,96.19 v2(139.38,96.19) 139.25,96.32 139.25,97.53 UC1.K22 ; v2(119.72,83.4) UC1.AT56 ; v2(136.03,87.9) 136.03,87.69 136.18,87.54 UC1.AL28 ; UC1.L2 150.86,97.11 v2(150.66,96.91) 150.35,96.91 UC1.L4 ; UC1.AP58 v2(118.85,84.71) ; v2(46.12,65.22) 45.72,65.62 UV6.B9 ; UC1.AW34 133.07,82.51 v2(133.29,82.73) 133.78,83.1 UC1.AU32 ; UV4.B3 53.27,93.98 v2(52.87,94.38) ; UC1.G66 v2(113.93,98.84) ; v2(146.23,84.07) 146.12,84.07 UC1.AR11 ; v2(72,63.55) 72.51,64.06 72.51,64.74 UV1.AF5 ; UV9.T1 57.98,105.18 57.67,104.87 v2(57.67,104.87) ; UV15.A9 46.52,86.51 v2(46.12,86.91) UV7.B1 ; v2(129.43,101.11) 129.43,101.11 ; 129.43,101.11 UC1.B39 ; 129.43,101.11 UC1.D39 ; UC1.AA68 v2(113.75,91.44) ; UC1.AN32 v2(133.44,85.31) ; v2(38.12,79.7) UV7.M9 ; UC1.AW32 v2(134.27,81.75) UC1.BA32 ; v2(35.94,87) 35.94,86.68 UV7.P1 ; UV6.T1 34.41,72.03 34.09,71.7 v2(34.03,71.7) ; UC1.AW57 v2(119.55,81.75) UC1.BA57 ; UC1.BA10 v2(146.54,81.75) UC1.AW10 ; UV9.B9 v2(51.27,93.58) ; UC1.AB15 143.9,91.31 v2(143.59,91.73) 143.54,91.73 143.33,91.47 UC1.AB16 ; UC1.G60 v2(117.89,98.84) ; UV7.E8 v2(43.72,80.5) 44.12,80.11 UV15.D1 ; UV9.P1 59.06,104.57 v2(59.06,104.89) ; v2(3.42,96.69) 2.58,96.69 2.4,96.5 JEDP.6 ; UC1.G52 122.41,99.1 v2(122.41,99.51) 122.39,99.51 UC1.E53 122.01,99.91 122.05,99.95 122.01,99.99 122.01,100.37 122,100.38 UC1.D53 ; UC1.W9 147.42,92.53 v2(147.06,92.89) 147.06,93.02 146.77,93.31 UC1.U10 ; JEDP.12 1.77,93.51 v2(2.79,93.51) ; UC1.AR5 149.44,84.32 149.9,83.86 UC1.AT4 150.46,83.86 v2(150.64,83.68) 150.82,83.86 UC1.AT2 ; v2(123.38,100.12) 123.41,100.12 123.81,99.89 UC1.E50 ; UC1.E56 v2(119.72,100.11) 119.52,100.32 UC1.D58 UC1.B58 ; UC1.BA28 v2(136.78,81.75) UC1.AW28 ; v2(35.72,65.22) 36.12,65.62 UV6.P9 ; UV14.D8 v2(43.72,70.82) ; UC1.BA23 v2(139.25,81.75) UC1.AW23 ; v2(122.54,84.69) 122.54,84.69 122.64,84.69 UC1.AR52 ; UV1.B1 v2(75.7,85.28) 75.58,85.4 UV1.A2 ; UC1.B10 UC1.D10 146.74,100.66 UC1.D11 v2(145.33,100.11) UC1.E11 146.33,99.34 146.33,98.96 UC1.G10 ; v2(67.05,85) 67.44,84.6 UV1.B11 ; UC1.Y20 UC1.Y21 UC1.AB21 UC1.AD21 UC1.AD20 140.72,90.34 v2(141.03,90.03) 141.37,90.38 UC1.AD19 ; UV5.M9 65.6,101.98 v2(65.52,101.9) ; UC1.N10 146.38,96.09 v2(146.38,96.21) 146.12,96.56 UC1.L11 145.78,96.98 UC1.J11 ; UC1.AP68 v2(113.14,84.97) UC1.AP70 ; UC1.AG21 140.19,88.68 140.61,88.68 UC1.AG20 141.06,88.46 v2(141.06,88.35) 140.72,88.02 UC1.AJ20 ; v2(67.3,99.21) 66.95,99.56 UV5.J8 ; UV7.T1 v2(34.15,86.13) ; 112.94,97.25 UC1.K68 UC1.K67 114.05,97.27 v2(114.37,96.95) ; UC1.AH6 149.37,87.95 UC1.AJ4 ; UC1.AK21 140.07,87.28 v2(139.82,87.54) 139.57,87.29 UC1.AK22 ; RPV3.5 86.43,88.69 v2(86.67,88.45) 86.41,88.19 RPV3.6 ; UC1.T17 142.53,93.67 142.17,93.67 UC1.T18 141.94,93.94 142,93.94 v2(142.33,94.27) ; UC1.AP32 v2(133.44,84.67) ; v2(58.73,75.12) 57.97,75.12 57.54,74.7 UV1.P23 ; UC1.AN23 v2(138.01,85.31) ; UV4.F9 v2(57.67,96.78) ; UC1.AF10 146.65,89.3 146.17,89.78 v2(146.17,89.84) ; UC1.AW14 v2(144.12,81.6) UC1.BA14 ; UC1.AB8 148.07,91.02 v2(148.13,90.92) 148.13,90.42 UC1.AD8 ; UC1.N65 v2(115.7,95.1) ; v2(55.54,75.14) 55.1,74.71 UV1.P26 ; UV4.A9 v2(58.47,92.78) ; UV14.F9 42.52,72.03 42.52,72.03 v2(42.12,72.43) 41.72,72.03 UV6.G1 ; UC1.F42 128.46,99.24 v2(128.86,98.84) ; UV1.AE14 65,65.58 v2(64.61,65.18) ; UV9.G9 v2(51.27,97.58) ; v2(143.49,86.49) 143.49,86.95 UC1.AK16 ; UC1.AR8 147.36,84.66 v2(147.18,84.66) 147.09,84.66 UC1.AP10 ; v2(42.12,85.3) 41.72,85.7 UV15.G8 UV15.F9 v2(42.12,86.91) 41.72,86.51 UV7.G1 ; UC1.U67 v2(113.75,93.27) ; UV8.E1 v2(65.75,95.98) ; UC1.BA71 110.97,80.45 v2(110.7,80.18) 110.89,79.99 UC1.BB70 ; DI1.3 DI1.8 194.63,66.13 v2(194.51,66.01) ; UC1.AT63 UC1.AR63 116.52,84.41 116.29,84.64 v2(116.07,84.64) ; UV1.AF11 67.53,64.8 v2(67.94,65.21) 67.54,65.6 UV1.AE11 ; v2(120.64,83.96) 121.1,84.33 UC1.AR55 ; UC1.B18 UC1.D18 141.82,100.27 v2(141.67,100.11) UC1.E18 ; UC1.G5 v2(148.98,98.84) UC1.G6 ; UV4.E1 v2(51.27,95.98) UV4.D1 ; v2(64.61,66.8) 64.21,66.4 UV1.AD15 ; UV1.E11 v2(67.93,81.75) ; UV8.F9 72.55,97.18 v2(72.15,96.78) ; UC1.B44 v2(126.95,101.14) UC1.D44 ; UC1.G48 v2(124.3,98.84) ; UC1.AW18 v2(141.7,81.57) UC1.BA18 ; RPV3.7 86.41,87.69 v2(86.67,87.43) 86.43,87.19 RPV3.8 ; UC1.AA65 v2(115.7,91.44) ; UC1.AW6 148.92,81.61 v2(148.96,81.57) UC1.BA6 UC1.BB6 ; v2(132.22,87.77) 132.22,87.79 132.53,87.48 UC1.AL35 ; v2(129.9,82.62) 130.24,82.86 UC1.AU38 ; UV6.B1 v2(46.12,72.43) ; v2(140.42,93.4) 140.42,93.5 140.1,93.82 UC1.T21 UC1.P21 ; UC1.F32 133.78,99.24 v2(133.43,98.89) 133.08,99.24 UC1.F33 ; UC1.AN40 129.46,85.7 v2(129.78,85.38) ; UC1.AN58 v2(118.85,85.34) ; UC1.G55 v2(120.64,98.84) ; JEDP.31 2.67,84 v2(2.75,83.91) ; UC1.F35 131.68,98.85 v2(131.66,98.85) 131.54,98.85 UC1.F37 ; UV8.D8 71.75,95.58 v2(72.15,95.18) ; v2(62.96,66) UV1.AD16 ; UV6.E2 v2(43.72,71.63) ; v2(110.28,102.6) 110.46,102.78 111.77,102.78 UC1.A70 ; UC1.AM60 118.26,86.44 117.53,86.44 UC1.AM61 v2(116.98,85.96) 116.72,85.7 UC1.AN63 116.34,85.7 v2(116.07,85.97) ; UC1.AU10 v2(146.24,82.77) ; UV8.B3 v2(67.35,94.38) ; v2(2.85,92) JEDP.15 ; UC1.AM43 127.5,86.37 UC1.AL45 127.04,86.81 UC1.AM45 v2(126.12,85.96)
  BOTTOM w0.305: JNGFF.7 173.98,58.91 v2(174.24,59.17) ; JNGFF.55 187.98,56.59 v2(187.76,56.38) 186.89,56.38 186.48,56.79 JNGFF.49 ; v2(191.12,58.94) 190.98,58.8 JNGFF.67 ; v2(181.83,58.94) 181.98,58.79 JNGFF.31 ; JNGFF.18 176.73,64.32 v2(176.36,63.95) ; v2(172.97,59.11) 172.48,58.62 JNGFF.1 ; JNGFF.61 189.48,58.79 189.29,58.98 v2(188.84,58.98) ; UV1.L25 55.5,77.58 v2(55.5,77.6) ; v2(184.92,58.96) 184.98,58.9 JNGFF.43 ; v2(57.11,80.08) 57.11,80.05 UV1.H23 ; v2(57.96,82.56) 58.04,82.56 UV1.E22 ; v2(55.49,82.56) 55.49,82.56 UV1.E25 ; UV1.U23 v2(57.94,71.78) ; UV1.L23 v2(57.92,77.6) ; v2(55.5,80.08) 55.5,80.06 UV1.H25 ; v2(56.31,67.7) 56.31,67.71 UV1.AB24 ; UV1.E17 62.15,82.57 v2(62.11,82.57) ; DB1.2 127.8,18.07 127.5,17.77 v2(126.58,17.77) ; v2(180.63,58.94) 180.48,58.79 JNGFF.25 ; JDIMM2.195 v2(169.15,36.41) ; UV1.E14 65.4,81.8 v2(65.42,81.8) ; v2(62.74,85.53) 62.44,85.23 62.44,84.68 UV1.B17 ; v2(55.1,63.07) UV1.AG26 ; UV1.AC26 54.7,66.85 v2(54.69,66.85) ; v2(60.46,82.57) 60.09,82.2 UV1.E20 ; UV1.Y23 57.9,69.34 v2(57.9,69.3) ; JNGFF.37 v2(183.48,59.05) ; v2(120.58,9.77) 120.68,9.67 JDEG1.10
  BOTTOM w0.356: JDIMM1.20 101.85,41.66 v2(102.48,42.29) ; JDIMM2.179 164.35,35.87 ; JDIMM1.46 109.65,38.15 109.65,38.15 v2(109.66,38.14) ; 151.17,41.72 v2(151.22,41.72) 151.3,41.72 151.8,41.23 151.8,40.79 151.65,40.64 JDIMM1.178 151.65,38.39 v2(151.42,38.15) ; v2(153.45,38.13) JDIMM1.184 ; JDIMM2.19 113.95,35.97 114.17,36.19 v2(114.61,36.19) 114.61,36.18 115.57,36.18 115.75,36.01 JDIMM2.25 ; JDIMM1.144 141.45,40.94 140.67,41.72 v2(140.17,41.72) ; JDIMM2.44 121.45,25.27 v2(121.75,24.97) 122.05,25.27 JDIMM2.46 ; v2(138.72,45.15) 138.52,45.15 138.15,45.52 JDIMM1.133 138.15,49.19 ; CV164.2 62.41,94.54 v2(62.29,94.42) ; JDIMM2.49 122.95,35.9 122.77,36.08 122.35,36.08 122.33,36.11 v2(121.95,36.11) 121.36,36.11 121.15,35.9 JDIMM2.43 121.15,33.5 v2(122.29,32.36) ; v2(164.05,25.11) JDIMM2.178 164.05,28.03 v2(163.15,28.93) ; v2(100.32,45.33) 100.89,45.91 100.89,46.09 101.55,46.75 JDIMM1.19 ; JDIMM2.168 161.05,29.52 161.6,30.07 v2(161.65,30.07) ; JDIMM1.2 96.45,40.87 v2(96.36,40.96) ; 105.38,42.29 104.25,41.15 JDIMM1.28 ; 105.38,42.29 v2(105.41,42.29) ; 105.38,42.29 105.38,42.29 ; v2(166.15,25.06) 165.85,25.36 JDIMM2.184 ; JDIMM1.72 117.45,40.57 117.83,40.94 117.83,41.37 v2(117.14,41.97) ; v2(155.31,41.34) 155.25,41.29 JDIMM1.190 ; CV258.2 45.12,76.79 v2(45.46,76.45) ; JDIMM2.145 154.15,35.85 ; JDIMM1.32 105.45,38.23 v2(105.54,38.14) ; JDIMM2.54 124.45,25.45 124.04,25.04 v2(122.9,25.04) 122.65,25.3 JDIMM2.48 ; v2(115.55,38.09) 115.65,38.18 JDIMM1.66 ; v2(98.35,41.71) 98.25,41.61 JDIMM1.8 ; JDIMM1.138 139.65,37.75 v2(140.01,37.39) ; JDIMM2.190 167.65,27.97 v2(166.96,28.66) ; v2(47.8,96.89) CV247.2 CV246.2 ; JDIMM1.187 154.35,45.67 153.45,44.77 v2(153.15,44.77) ; JDIMM2.32 117.85,25.26 v2(118.16,24.95) 119.18,24.95 119.65,25.41 JDIMM2.38 ; JDIMM1.11 99.15,44.85 v2(100.32,43.81) ; JDIMM1.44 109.05,40.72 109.28,40.95 v2(109.66,40.95) ; CV199.2 v2(76.54,99.62) ; v2(116.85,36.16) 117.22,36.16 117.55,35.83 JDIMM2.31 ; v2(145.7,44.75) 144.75,45.7 JDIMM1.155 ; JDIMM1.54 112.05,38.34 111.84,38.13 v2(111.74,38.13) ; v2(116.65,28.22) JDIMM2.28 ; v2(113.45,45.02) 112.35,46.01 JDIMM1.55 ; JDIMM2.55 124.75,36.93 v2(124.8,36.98) ; JDIMM1.38 107.25,38.24 v2(107.04,38.04) ; JDIMM2.134 150.85,29.9 v2(150.68,30.07) ; v2(144.38,43.63) 144.15,43.92 JDIMM1.153 ; v2(129.62,31.98) 128.82,31.98 127.75,33.05 JDIMM2.65 ; JDIMM2.37 119.35,35.89 v2(119.13,36.11) ; v2(157.45,25.17) JDIMM2.156 ; JDIMM1.49 110.55,46.23 110.74,46.03 110.74,45.53 v2(111.32,45.02) ; v2(142.35,41.72) 143.25,40.82 JDIMM1.150 ; JDIMM2.66 128.05,25.29 v2(128.25,25.09) 129.61,25.09 129.85,25.33 JDIMM2.72 ; JDIMM1.185 153.75,46.59 153.45,46.3 v2(153.15,46.3) ; JDIMM2.71 129.55,36.01 v2(129.42,36.13) ; JDIMM1.71 117.15,46.75 117.78,46.12 117.78,45.65 v2(117.14,45.02) ; v2(145.7,43.22) 146.13,43.22 146.85,42.5 JDIMM1.162 ; v2(111.32,41.97) 111.1,41.97 110.25,41.13 JDIMM1.48 ; JDIMM2.3 109.15,35.82 109.53,36.2 v2(109.66,36.2) 110.61,36.2 110.95,35.85 JDIMM2.9 110.95,33.56 111.31,33.2 111.31,31.24 v2(111.05,30.98) ; v2(148.36,43.25) 147.83,43.25 146.55,44.53 JDIMM1.161 146.55,48.86 ; v2(114.98,41.59) 114.89,41.59 113.85,40.55 JDIMM1.60 ; v2(44.89,76) 45.21,75.68 CV286.2 CV283.2 ; JDIMM2.63 127.15,35.93 126.94,36.15 v2(126.48,36.15) 126.55,36.07 JDIMM2.61 ; JDIMM1.14 100.05,38.36 100.45,37.96 v2(100.89,37.96) ; CV240.2 v2(60.15,93.93) ; JDIMM1.134 138.45,42.6 v2(138.72,42.87) ; v2(96.99,45.33) 96.63,45.33 96.2,45.76 96.2,46.11 96.75,46.66 JDIMM1.3 ; JDIMM1.167 148.35,48.88 ; v2(125.94,25.14) 126.25,25.45 JDIMM2.60 ; CV257.2 43.78,76.88 43.5,76.88 v2(43.3,77.08) ; JDIMM1.170 149.25,41.92 v2(149.95,42.61) ; v2(111.05,28.03) 110.65,27.63 JDIMM2.8 110.65,25.41 110.96,25.1 v2(111.97,25.1) 112.45,25.58 JDIMM2.14 ; JDIMM1.26 103.65,38.28 103.29,37.93 102.2,37.93 v2(102.03,38.1) ; 166.15,35.77 JDIMM2.185 ; JDIMM2.26 116.05,25.5 115.63,25.07 v2(114.5,25.07) 114.25,25.32 JDIMM2.20 ; CV198.2 v2(62.29,93.78) ; JDIMM1.37 106.95,43.87 107.12,43.7 v2(107.85,43.7) ; CV253.2 v2(30.54,81.4) ; JDIMM2.11 111.55,35.8 v2(111.8,36.05) 112.15,35.71 JDIMM2.13 ; v2(98.29,44.19) 98.55,44.48 JDIMM1.9 ; JDIMM1.197 v2(157.35,49.08) ; JDIMM1.25 103.35,45.91 v2(103.53,45.71) ; JDIMM1.136 139.05,42.17 140.12,43.25 v2(140.17,43.25) ; 162.55,35.9 JDIMM2.173
  BOTTOM w0.381: PC1155.2 102.04,98.1 v2(102.04,97.78) ; v2(114.98,43.88) 115.02,43.92 115.02,46 114.75,46.27 JDIMM1.63 114.75,48.84 114.64,48.95 114.31,48.95 114.15,48.79 JDIMM1.61 ; v2(103.27,92.07) 103.27,92.41 PC1221.2 ; PC1024.2 99.15,94.52 v2(99.15,94.86) ; v2(109.64,45.4) 108.75,46.3 JDIMM1.43 ; v2(100.36,94.86) 100.36,94.52 PC1183.2 ; PQ3.4 20.09,15.71 v2(19.87,15.49) ; v2(102.77,94.86) 102.77,94.52 PC1019.2 ; RV48.2 81.24,83.9 v2(81.27,83.94) ; v2(102.06,92.07) 102.06,92.41 PC1179.2 ; v2(108.22,94.86) 107.98,95.1 RC226.2 ; v2(97.95,94.86) 97.95,94.52 PC1023.2 ; UC12.3 107.77,110.88 108.39,111.5 v2(108.39,111.69) ; PC1022.2 97.21,92.38 v2(97.21,92.07) ; v2(111.5,108.26) 110.97,108.79 CC83.2 ; CV248.2 47.55,97.65 v2(47.24,97.97) ; CA25.1 199.14,24.77 v2(198.81,24.44) ; PC631.2 86.28,119.94 v2(85.95,119.61) 85.96,119.6 PC628.2 ; v2(100.83,92.07) 100.83,92.38 PC1180.2 ; PC1018.2 96.01,92.38 v2(96.01,92.07) ; v2(156.92,43.25) 156.7,43.46 156.69,43.46 154.95,45.21 JDIMM1.189 ; PC1156.2 100.83,98.1 v2(100.83,97.78) ; CL36.1 177.73,107.37 v2(177.86,107.24) ; v2(148.36,46.3) 148.35,46.31 JDIMM1.167 ; JDIMM1.71 117.15,49.12 116.8,49.48 115.86,49.48 115.35,48.97 JDIMM1.65 ; JDIMM2.2 108.85,27.52 v2(108.42,27.96) ; v2(103.98,94.86) 103.98,94.52 PC1020.2 ; v2(155.71,28.54) 155.65,28.48 JDIMM2.150 ; v2(173.73,106.61) 173.73,106.93 174.17,107.37 CL37.1 ; CC16.2 154.92,86.68 v2(154.81,86.8) ; PC1154.2 99.62,98.1 v2(99.62,97.78) ; JDIMM1.31 105.15,48.94 105.42,49.21 106.63,49.21 106.95,48.89 JDIMM1.37 ; v2(99.62,92.07) 99.62,92.38 PC1021.2 ; v2(101.57,94.86) 101.57,94.52 PC1159.2
  BOTTOM w0.457: PC1075.2 126.17,113.85 v2(126.17,113.47) ; RC317.2 RC326.2 163.44,92.19 v2(163,92.64) 163.44,93.08 RC316.2 ; v2(188.33,96.41) 188.52,96.22 UL3.2 ; PC1076.2 125.28,116.51 v2(125.28,116.13) ; PC1081.2 124.39,113.85 v2(124.39,113.47) ; PC801.2 73.77,49.33 v2(74.48,49.33) ; v2(92.09,118.48) 91.88,118.7 PC644.2 ; PC1082.2 123.56,116.51 v2(123.56,116.13) ; UV13.3 v2(83.78,65.65)
  BOTTOM w0.508: v2(143.27,113.59) 143.27,114.01 PC1011.2 ; v2(52.7,57.27) 52.7,57.65 PC827.2 ; v2(81.15,24.25) 81.17,24.27 PR506.2 ; CS6.2 178.7,8.64 v2(179,8.94) ; PR302.2 v2(183.83,45.52) ; RV66.2 80.45,65.84 80.45,65.71 v2(81.72,64.44) ; PR310.2 PC405.2 v2(183.76,46.41) ; CV288.2 v2(47.57,73.84) ; v2(190.75,9.64) 190.16,9.64 JHDD.12 ; PR110.2 v2(60.57,20.06) ; v2(154.12,97.76) 154.12,97.92 154.69,98.49 RC211.2 ; CLRP3.2 v2(156.71,108.77) ; CV255.2 v2(30.41,82.22) ; JDEG1.12 119.55,11.82 v2(119.75,11.61) ; JWDB1.6 v2(92.81,11.32) ; PC8.2 v2(17.9,30.98) ; v2(23.87,58.22) 22.5,59.59 JIO.18 ; JIO.8 26.14,50.95 v2(26.66,51.46) 26.18,51.95 JIO.9 ; CA21.2 197.87,12.87 197.86,12.88 v2(197.86,13.45) ; DB1.11 131.56,15.59 v2(132.75,14.41) ; v2(80.59,71.2) 80.79,71.4 RV67.2 ; CI40.2 v2(194.3,55.9) ; v2(96.32,115.69) 96.05,115.41 PC603.2 ; PC803.1 v2(80.93,42.37) ; v2(55.56,57.27) 55.56,57.65 PC828.2 ; PR802.2 76.52,47.31 v2(76.89,47.68) ; v2(184.21,51.61) 183.75,51.61 PR311.2 183.31,51.8 182.66,51.15 PC313.2 ; JEDP.44 v2(12.99,93) ; v2(145.79,72) 145.54,72.25 CLRP1.1 ; v2(144.1,116.39) 144.1,116.81 PC1001.2 ; PC1141.2 160.27,114.74 v2(160.27,114.37) ; v2(45.46,106.35) 46.03,105.78 CV243.2 ; v2(24.31,58.79) 24.47,58.95 JIO.16 ; JDIMM2.206 v2(173,21.49) ; v2(135.12,107.62) CC12.2 ; PC769.1 PC768.1 v2(45,20.26) ; JNGFF.68 171.38,59.99 v2(171.82,60.44) ; RC316.2 RC315.2 163,94.35 162.74,94.61 v2(162.74,95.24) RC319.2 ; v2(78.52,90.82) RV206.2 RV205.2 ; v2(48.82,11.1) 49.65,10.28 PR732.2 ; CV169.2 v2(62.1,90.64) ; PC685.2 151.58,115.18 v2(152.14,115.18) ; v2(79.42,45.46) PR824.2 79.42,46.99 PC802.2 ; JRTC.2 28.62,10.1 v2(29.33,9.39) ; PD3.1 19,17.5 v2(19.42,17.07) ; PC1012.2 126.93,116.58 v2(126.93,116.13) ; CV269.2 v2(42.92,61.27) ; RC232.2 155.68,101.41 156.14,100.96 v2(156.65,100.96) ; v2(122.87,16.95) 121.65,15.73 DB1.12 ; JHDD.11 178.41,10.57 v2(178.35,10.52) ; JFAN.5 v2(2.84,67.12) ; PC213.2 v2(83.37,8.82) ; C5216.2 C5217.2 170.35,18.29 v2(170.36,18.28) ; v2(5.01,73.52) 4.55,73.07 JFAN.3 ; v2(13.01,96.89) 11.4,98.5 JEDP.43 ; v2(30.54,87.88) 31.62,87.88 CV256.2 ; RV50.2 80.99,87.65 v2(81.28,87.65) ; PC807.2 70.16,43.43 v2(69.65,43.93) ; CV238.2 45.52,104.51 v2(44.57,105.46) ; v2(130.64,107.42) 130.65,107.41 CC13.2 130.65,106.26 ; RC214.2 154.31,99.37 v2(154.09,99.15) ; PR810.1 v2(80.1,38.79) ; PC505.2 82.67,26.92 82.48,26.72 v2(82.29,26.72) 81.91,26.72 81.78,26.85 PR505.2 ; PC825.2 51.11,57.65 v2(51.11,57.27) ; PC1142.2 161.03,117.84 v2(161.03,117.48) ; RV49.2 v2(81.28,82.76) ; PC829.2 56.83,57.65 v2(56.83,57.27) ; v2(161.98,114.37) 161.98,114.74 PC1145.2 ; JHDD.6 184.73,12.11 v4(185.21,11.64) ; v2(9.74,57.05) 9.49,57.3 JCAM3D.12 ; RV20.2 v2(77.87,88.41) ; JEDP.46 v2(13.07,80) ; v2(182.05,13.39) 182.33,13.1 JHDD.3 ; v2(26.66,53.14) 26.47,52.95 JIO.10 ; YL2.2 174.6,107.82 174.48,107.7 CL37.1 ; RV62.2 80.87,86.12 81.27,85.72 v2(81.27,85.65) 81.27,85.4 80.98,85.11 RV52.2 ; PC1143.2 162.73,117.86 v2(162.73,117.49) ; PC661.2 99.55,113.97 v2(99.05,113.97) ; v2(183.57,24.5) 184.14,25.07 UC2.4 JC1.4 ; v2(28.95,7.17) 29.01,7.17 29.39,7.55 JRTC.3 ; v2(76.4,103.36) CV70.2 RV114.1 ; PC757.1 v2(41.78,19.93) ; v2(107.82,104.13) 107.63,103.94 107.63,103.58 106.72,102.68 RC102.1 RC193.2 ; PD2.1 v2(18.98,23.99) ; PR32.2 19.48,15.09 v2(19.87,15.49) ; v2(193.48,57.97) 193.68,57.77 CI2.2 ; PC604.2 96.26,116.66 v2(96.32,116.73) ; CV204.2 v2(76.96,97.91) ; v2(39.63,75.46) 39.22,75.05 RV99.1 ; JFAN.4 v2(9.9,64.96) ; v2(209.61,15.68) 209.48,15.8 DA14.1 ; PC209.2 v2(81.31,19.01) ; DA13.1 204.4,15.88 v2(204.48,15.8) ; YC1.2 134.68,109.78 v2(135.18,109.27) ; CL4.2 v2(170.94,114.86) ; RC37.2 v2(121.15,108.32) ; JNGFF.69 192.08,57.07 v2(191.83,56.82) ; PR727.2 v2(42.54,7.87) 42.34,7.66 PR753.1 PC752.1 39.88,7.66 v2(39.81,7.74) ; v2(156.77,87.88) 156.77,88.37 RC10.2 ; PC7.2 v2(22.66,30.79) ; RV64.2 v2(72.97,90.12) ; CLRP2.1 148.74,73.93 149.17,74.36 v2(149.17,75.1) ; RC51.2 157.11,81.09 v2(157.47,80.72) ; JIO.13 v2(26.6,55.95) ; v2(139.85,116.39) 139.85,116.81 PC1071.2 ; RA1113.1 198.81,12.88 v2(199.45,12.25) ; JWDB1.1 v2(94.11,11.39) ; v2(183.32,98.54) 184.66,97.2 RL27.1 ; CV28.2 v2(50.98,60.44) ; v2(84.13,112.83) 84.03,112.93 PC636.1 ; CS5.2 v2(176.66,8.64) ; CE20.2 171.95,119.75 v2(172.4,119.31) 172.52,119.43 DE2.1 ; RV107.2 v2(74.86,104.46) ; CV37.2 v2(78.43,92.02) ; v2(46.09,102.34) 47.1,101.34 RV116.1 CV252.2 CV251.2 CV249.2 CV248.2 ; PC1140.2 165.41,114.74 v2(165.41,114.37) ; CV162.2 v2(63.82,91.93) ; JRTC.4 29.78,13.9 29.24,14.43 v2(29.2,14.43) ; PC1144.2 163.7,114.74 v2(163.7,114.37) ; PC605.1 97.4,111 v2(97.4,110.42) ; JEDP.45 11.14,85.5 11.55,85.91 v2(11.55,87.43) ; PR755.1 40.5,11.4 PC753.1 39.81,12.31 v2(39.81,12.31) ; CL15.2 188.52,94.49 UL3.2 ; PC111.2 v2(65.27,17.26) ; v2(108.43,108.28) 108.13,108.58 107.69,108.58 107.37,108.26 RC43.2 ; PC751.1 v2(39.93,9.45) ; v2(107.75,21.45) 107.4,21.1 JDIMM2.205 ; PR647.1 83.06,111.31 PC629.1 v2(83.05,110.54) ; v2(194.87,44.19) 195.54,43.53 DI5.1 ; v2(117.4,4.63) 117.4,3.98 JDEG1.11 ; v2(164.39,117.48) 164.39,117.84 PC1139.2 ; PC677.2 v2(81.02,99.23) ; DI2.1 v2(194.49,63.41) ; v2(177.86,110.34) 177.7,110.19 176.81,110.19 YL2.4 ; CS7.2 v2(178.91,4.98) ; YV1.4 v2(78.12,96.77) ; CV302.1 v2(91.75,95.75) ; PR118.2 60.76,31.26 60.34,31.26 v2(60.06,30.98) ; PC826.2 54.29,57.65 v2(54.29,57.27) ; CV166.2 v2(76.96,97.02) ; JDIMM1.205 v2(92.85,55.6) ; CV260.2 v2(46.68,76.43) ; CV279.2 37.39,89.34 v2(37.71,89.65) 37.97,89.4 RV101.1 ; CV36.2 v2(75.05,92.7) ; JEDP.42 4.81,75.38 v2(4.39,75.8) ; CV254.2 v2(30.41,83.18) ; JSPK.6 v2(202,6.68) ; PC210.2 84.26,9.01 v2(84.07,8.82) ; v2(33.03,45.09) CI47.2 CI46.2 ; YC1.4 131.22,108.64 v2(130.61,108.64) ; PC805.2 v2(78.23,37.96) ; JEDP.41 6.02,103.13 v2(5.52,103.62) ; RC89.1 155.25,83.19 CC15.2 155.75,84.01 v2(155.89,83.87) ; RV112.1 v2(60.89,101.01) ; JSPK.5 v2(211.45,6.35) ; UI7.2 v2(29.46,45.77) ; PC1013.2 140.67,114.01 v2(140.67,113.59) ; CV261.2 v2(30.6,84.19) ; RC324.2 157.04,93.21 v2(157.73,93.21) ; JWDB1.5 v2(97.81,11.23) ; YV1.2 v2(74.57,94.07) ; v2(159.95,78.15) 159.26,78.15 RC46.2 ; CV268.2 v2(41.9,61.27) ; v2(142,116.39) 142,116.81 PC1174.2 ; PC312.2 v2(178.37,54.15) ; JIO.17 v2(24.08,41.12) ; PC204.1 v2(84.97,17.58) ; CV280.2 v2(38.41,63.55) ; JCAM3D.11 v2(6.83,48.7) ; CI43.2 v2(196.14,41.27) ; RC35.2 v2(117.47,108.32) ; CI45.2 v2(33.65,42.6) ; CV205.2 v2(76.96,98.8) ; JDIMM1.206 162.49,55.6 v2(162.71,55.39) ; PR204.2 v2(80.45,11.36) ; CV281.2 v2(39.43,63.55) ; CV236.2 v2(47.05,103.37)
  vias: v2(2.75,105.19) v2(3.42,100.26) v2(3.53,86.24) v2(3.57,81.56) v2(3.87,84.55) v2(4.15,83.09) v2(5.45,92) v2(5.84,100.26) v2(5.84,98.45) v2(5.84,96.68) v2(5.84,94.9) v2(6.01,73.56) v2(6.08,105.15) v2(7.74,99.94) v2(8.38,99.94) v2(8.83,105.2) v2(11.55,88.07) v2(12.88,10.91) v2(13.52,10.91) v2(13.77,72.83) v2(14.15,10.91) v2(14.79,10.91) v2(14.92,100.58) v2(15.49,71.56) v2(15.49,14.85) v2(15.49,14.22) v2(15.49,13.58) v2(15.49,12.95) v2(15.49,12.25) v2(15.49,10.91) v2(18.73,99.62) v2(19.95,8.74) v2(20.05,93.12) v2(20.05,90.91) v2(19.97,10.88) v2(20.19,19.36) v2(20.76,75.62) v2(20.95,102.67) v2(20.95,22.47) v2(20.95,21.84) v2(20.95,21.07) v2(20.95,20.44) v2(21.14,83.8) v2(21.14,83.1) v2(21.39,75.62) v2(21.77,83.43) v2(21.77,11.89) v2(21.77,7.57) v2(22.08,94.42) v2(22.1,89.74) v2(22.47,83.1) v2(23.04,19.23) v2(23.68,19.23) v2(23.65,10.9) v2(23.65,8.77) v2(24.19,93.12) v2(24.16,90.91) v2(24.57,19.23) v2(25.2,19.23) v2(25.99,119.89) v2(25.96,117.76) v2(26.54,107.81) v2(26.54,107.18) v2(26.54,106.54) v2(26.79,105.46) v2(26.79,83.56) v2(26.85,85.78) v2(27.17,107.81) v2(27.17,107.18) v2(27.17,106.54) v2(27.23,102.04) v2(27.62,99.56) v2(27.68,42.6) v2(27.68,19.23) v2(27.79,120.91) v2(27.79,116.59) v2(27.81,107.81) v2(27.81,107.18) v2(27.81,106.54) v2(28.31,19.23) v2(28.44,107.81) v2(28.44,107.18) v2(28.44,106.54) v2(29.01,105.46) v2(29.27,42.6) v2(29.39,103.24) v2(29.46,19.23) v2(29.7,119.87) v2(29.7,117.73) v2(29.84,101.78) v2(30.09,19.23) v2(31.24,19.23) v2(31.3,103.24) v2(31.25,97.29) v2(31.43,74.86) v2(31.87,19.23) v2(33.01,19.23) v2(33.27,74.86) v2(33.65,19.23) v2(33.7,77.51) v2(34.85,100.88) v2(34.79,19.23) v2(35.24,74.96) v2(35.43,19.23) v2(37.37,74.1) v2(38.44,104.48) v2(39.43,111.05) v2(40.9,69.46) v2(40.96,82.3) v2(41.7,74.97) v2(41.78,96.32) v2(42.03,108.07) v2(41.99,82.8) v2(41.98,68.32) v2(42.03,46.98) v2(42.09,51.49) v2(42.73,51.49) v2(42.67,46.98) v2(42.98,94.86) v2(43.24,92.57) v2(43.17,88.64) v2(43.3,46.98) v2(43.36,51.49) v2(43.55,114.04) v2(43.94,46.98) v2(44,51.49) v2(44,50.85) v2(44,50.22) v2(44.13,61.27) v2(44.29,56.05) v2(44.44,91.24) v2(44.57,109.91) v2(44.57,22.33) v2(44.76,61.27) v2(44.89,21.82) v2(45.21,22.33) v2(45.4,61.27) v2(45.42,58.01) v2(45.42,54.09) v2(45.4,14.28) v2(45.4,12.56) v2(45.52,21.82) v2(45.84,22.33) v2(46.21,13.39) v2(47.05,14.28) v2(47.05,12.56) v2(47.68,58.01) v2(47.68,54.09) v2(47.94,24.57) v2(47.94,23.93) v2(47.94,23.3) v2(47.94,22.66) v2(48.63,114.04) v2(48.57,24.57) v2(48.57,23.93) v2(48.57,23.3) v2(48.57,22.66) v2(48.81,56.05) v2(49.52,109.91) v2(50.86,26.22) v2(50.86,25.52) v2(51.27,95.18) v2(51.56,26.22) v2(51.56,25.52) v2(51.75,109.75) v2(53.71,114.04) v2(54.34,96.6) v2(55.94,109.75) v2(55.87,98.73) v2(56.27,64.41) v2(56.64,28.25) v2(56.64,26.92) v2(56.64,26.28) v2(56.89,43.62) v2(56.89,42.92) v2(56.85,27.55) v2(57.02,49.84) v2(57.02,49.14) v2(56.95,16.69) v2(56.95,16.06) v2(57.09,64.41) v2(57.23,28.25) v2(57.23,26.92) v2(57.49,27.55) v2(57.59,16.69) v2(57.59,16.06) v2(57.93,64.43) v2(57.87,28.25) v2(57.87,26.92) v2(58.1,27.55) v2(58.22,17.33) v2(58.22,16.69) v2(58.22,16.06) v2(58.48,28.25) v2(58.48,26.92) v2(58.7,85.99) v2(58.73,27.55) v2(58.79,114.04) v2(58.8,66.8) v2(58.77,65.97) v2(58.86,17.33) v2(58.86,16.69) v2(58.86,16.06) v2(59.05,60.95) v2(59.37,27.55) v2(59.44,16.69) v2(59.87,60.95) v2(60,27.55) v2(60.06,16.69) v2(60.45,103.78) v2(60.42,73.88) v2(60.5,105.96) v2(60.52,77.05) v2(60.48,65.98) v2(60.61,26.78) v2(60.64,8.18) v2(60.84,96.69) v2(61.14,7.8) v2(61.21,60.95) v2(61.25,45.91) v2(61.26,44.87) v2(61.54,75.16) v2(61.51,71.2) v2(61.52,45.39) v2(61.56,73.14) v2(61.59,57.97) v2(61.72,97.68) v2(61.84,45.9) v2(61.84,44.89) v2(62.02,15.26) v2(62.12,66.03) v2(62.14,65.19) v2(62.17,64.37) v2(62.16,45.39) v2(62.32,104.39) v2(62.53,102.25) v2(62.47,78.23) v2(62.48,45.9) v2(62.48,44.89) v2(62.79,46.41) v2(62.79,45.39) v2(62.9,60.95) v2(62.91,27) v2(63.11,45.9) v2(63.11,44.89) v2(63.24,107.7) v2(63.24,58.35) v2(63.43,46.41) v2(63.43,45.39) v2(63.54,71.16) v2(63.49,60.95) v2(63.56,55.87) v2(63.75,45.9) v2(63.75,44.89) v2(63.81,105.95) v2(63.87,114.04) v2(64.06,46.41) v2(64.06,45.39) v2(64.26,117.35) v2(64.38,45.9) v2(64.38,44.89) v2(64.57,116.84) v2(64.7,55.81) v2(64.7,46.41) v2(64.7,45.39) v2(64.89,117.35) v2(65.02,45.9) v2(65.21,116.84) v2(65.21,60.95) v2(65.33,46.41) v2(65.33,45.39) v2(65.43,77.31) v2(65.4,70.17) v2(65.53,117.35) v2(65.46,109.91) v2(65.53,71.17) v2(65.53,29.96) v2(65.56,79.33) v2(65.65,45.9) v2(65.84,116.84) v2(65.84,29.46) v2(65.91,56.25) v2(65.97,46.41) v2(65.97,45.39) v2(66.29,45.9) v2(66.35,42.6) v2(66.52,78.21) v2(66.54,60.95) v2(66.48,29.46) v2(66.6,46.41) v2(66.6,45.39) v2(66.67,48.38) v2(66.67,43.17) v2(66.9,45.9) v2(67.05,56.25) v2(66.99,42.6) v2(67.21,46.41) v2(67.2,45.39) v2(67.3,48.38) v2(67.44,71.26) v2(67.54,77.16) v2(67.51,45.9) v2(67.62,42.6) v2(67.56,17.64) v2(67.8,45.39) v2(67.94,48.38) v2(67.94,30.6) v2(67.94,29.96) v2(68.26,42.6) v2(68.38,62.16) v2(68.38,45.39) v2(68.57,78.17) v2(68.64,56.76) v2(68.71,98.8) v2(68.79,79.2) v2(68.95,114.04) v2(69.34,70.16) v2(69.59,60.51) v2(69.78,104.39) v2(69.8,76.08) v2(69.91,105.85) v2(69.86,97.72) v2(71.3,109.95) v2(71.56,16.88) v2(72.01,81.77) v2(72.19,16.88) v2(72.51,29.07) v2(72.84,66.82) v2(72.83,62.82) v2(72.91,75.93) v2(72.91,74.28) v2(73.15,29.07) v2(73.4,17.52) v2(73.7,80.89) v2(73.74,75.95) v2(73.68,66.84) v2(73.75,75.13) v2(74.03,114.04) v2(74.03,17.52) v2(74.29,28.38) v2(74.5,74.3) v2(74.49,71.81) v2(74.51,70.11) v2(74.49,66.76) v2(74.92,28.38) v2(74.86,9.68) v2(75.05,42.41) v2(75.11,17.52) v2(75.35,76.88) v2(75.47,79.67) v2(75.49,9.68) v2(75.75,17.52) v2(76,43.36) v2(76,42.41) v2(76,28.38) v2(76.14,100.64) v2(76.07,62.79) v2(76.64,28.38) v2(76.96,17.52) v2(77.27,61.97) v2(77.59,17.52) v2(77.72,28.38) v2(77.78,63.17) v2(78.35,28.38) v2(79.01,62.48) v2(79.69,30.09) v2(79.81,24.12) v2(80,30.6) v2(80.32,30.09) v2(80.64,30.6) v2(80.57,25.2) v2(80.79,57.8) v2(81.19,93.35) v2(81.8,59.54) v2(81.8,56.06) v2(82.32,95.31) v2(82.32,91.39) v2(83.8,59.54) v2(83.8,56.06) v2(84,104.51) v2(84,103.88) v2(84,103.24) v2(84.19,100.13) v2(84.32,102.35) v2(84.32,100.96) v2(84.58,95.31) v2(84.58,91.39) v2(84.58,8.44) v2(84.83,100.13) v2(84.83,98.54) v2(84.81,57.8) v2(84.77,19.74) v2(84.77,19.1) v2(84.89,101.65) v2(85.15,11.12) v2(85.15,10.53) v2(85.4,19.74) v2(85.4,19.1) v2(85.46,102.35) v2(85.46,100.89) v2(85.46,98.54) v2(85.65,104.51) v2(85.65,103.5) v2(85.71,93.35) v2(85.72,14.02) v2(85.72,13.07) v2(85.78,106.99) v2(85.85,20.5) v2(85.91,26.66) v2(85.97,104) v2(86.04,19.74) v2(86.04,19.1) v2(86.04,18.47) v2(86.04,17.83) v2(86.04,16.63) v2(86.04,15.99) v2(86.1,98.54) v2(86.16,9.64) v2(86.16,9.03) v2(86.16,8.44) v2(86.29,104.51) v2(86.29,103.5) v2(86.42,11.29) v2(86.54,26.66) v2(86.54,19.42) v2(86.54,18.79) v2(86.54,18.15) v2(86.54,17.52) v2(86.61,104) v2(86.92,104.51) v2(86.92,103.5) v2(87.05,11.29) v2(87.24,104) v2(87.56,104.51) v2(87.56,103.5) v2(87.81,21.58) v2(87.88,104) v2(88,58.73) v2(88.19,104.51) v2(88.19,103.5) v2(88.32,114.61) v2(88.32,112.64) v2(88.51,104) v2(88.51,28.12) v2(88.51,27.42) v2(88.83,103.5) v2(89.15,104) v2(89.46,113.59) v2(89.46,103.5) v2(89.78,104) v2(90.1,103.5) v2(90.42,104) v2(90.54,114.61) v2(90.54,112.64) v2(90.54,62.54) v2(90.54,61.08) v2(90.54,60.25) v2(90.58,63.55) v2(90.55,61.91) v2(90.73,103.5) v2(91.69,15.99) v2(92.07,106.93) v2(92.65,106.93) v2(93.21,20.95) v2(93.78,20.06) v2(93.78,19.3) v2(94.93,23.36) v2(94.93,22.66) v2(94.93,22.03) v2(94.93,21.39) v2(94.93,20.76) v2(94.93,20.12) v2(95.62,22.98) v2(95.62,22.34) v2(95.62,21.71) v2(95.62,21.07) v2(95.62,20.44) v2(95.62,19.8) v2(96.99,43.81) v2(96.99,42.29) v2(99.14,2.52) v2(99.17,4.65) v2(99.31,117.97) v2(99.31,117.34) v2(99.4,105.42) v2(99.39,81.1) v2(100.13,49.2) v2(100.32,49.83) v2(100.32,42.29) v2(100.6,107.51) v2(100.6,103.33) v2(100.59,83.19) v2(100.59,79.01) v2(100.97,5.67) v2(101.68,49.05) v2(102.48,45.33) v2(102.48,43.81) v2(102.93,4.55) v2(102.93,2.42) v2(103.02,107.51) v2(103.02,103.33) v2(103.01,83.19) v2(103.01,79.01) v2(103.06,89.32) v2(103.53,43.43) v2(103.94,118.48) v2(103.94,117.85) v2(103.94,112.77) v2(104.22,105.42) v2(104.21,81.1) v2(104.28,89.32) v2(104.39,114.23) v2(104.51,92.07) v2(104.64,115.24) v2(105.02,114.23) v2(105.15,51.24) v2(105.41,45.33) v2(105.41,43.81) v2(105.53,115.24) v2(105.59,118.42) v2(105.59,117.4) v2(105.66,112.77) v2(105.75,92.07) v2(105.76,88.4) v2(105.91,117.91) v2(105.97,85.84) v2(106.2,118.42) v2(106.23,117.4) v2(106.29,112.77) v2(106.42,94.86) v2(106.4,89.6) v2(106.55,117.91) v2(106.55,116.83) v2(106.86,117.4) v2(107.18,117.91) v2(107.18,116.83) v2(107.18,83.43) v2(107.5,117.4) v2(107.55,73.2) v2(107.82,117.91) v2(107.82,116.83) v2(107.92,85.78) v2(107.87,45.22) v2(107.88,42.17) v2(108.13,117.4) v2(108.2,92.07) v2(108.24,83.68) v2(108.35,81.79) v2(108.45,117.91) v2(108.45,116.83) v2(108.45,80.72) v2(108.7,49.58) v2(108.77,117.4) v2(108.8,89.39) v2(109.09,117.91) v2(109.09,116.83) v2(109.23,86.62) v2(109.22,32.23) v2(109.22,30.71) v2(109.22,29.18) v2(109.4,117.39) v2(109.49,94.86) v2(109.53,92.07) v2(109.64,43.12) v2(109.72,117.91) v2(110.04,117.4) v2(110.01,76.79) v2(109.99,75.08) v2(110.04,73.26) v2(110.36,117.91) v2(111.06,28.8) v2(111.32,43.5) v2(111.88,76.58) v2(111.88,74.63) v2(112.59,31.98) v2(112.59,30.45) v2(112.59,28.93) v2(113.45,43.5) v2(113.45,41.97) v2(114.01,75.99) v2(114,74.01) v2(115.01,31.98) v2(115.01,30.45) v2(115.01,28.93) v2(115.85,72.33) v2(115.94,74.23) v2(116.83,32.36) v2(116.83,30.15) v2(117.14,43.5) v2(117.66,8.37) v2(118.28,31.98) v2(118.28,30.45) v2(118.28,28.93) v2(118.5,74.3) v2(118.48,72.64) v2(119.56,95.18) v2(119.56,94.61) v2(119.56,92.76) v2(119.56,92.19) v2(119.78,43.85) v2(119.78,42.33) v2(120.55,73.4) v2(120.51,31.98) v2(120.51,30.45) v2(120.51,28.93) v2(120.63,75.1) v2(120.57,71.48) v2(121.73,43.85) v2(122.11,75.85) v2(122.1,73.84) v2(122.09,72.65) v2(122.29,30.07) v2(123.65,43.85) v2(123.75,31.98) v2(123.75,30.45) v2(123.75,28.93) v2(123.94,76.25) v2(124.01,72.81) v2(124.22,71.68) v2(125.85,31.98) v2(125.85,30.45) v2(125.85,28.93) v2(125.87,43.85) v2(126.5,75.52) v2(126.78,108.16) v2(127.92,77.9) v2(127.95,73.91) v2(127.91,72.71) v2(127.96,45.48) v2(127.96,43.95) v2(127.96,43.19) v2(128.14,30.84) v2(128.14,28.55) v2(128.1,27.92) v2(128.19,76.29) v2(128.23,75.17) v2(129.62,30.45) v2(129.62,28.93) v2(130.66,77.3) v2(130.66,76.09) v2(130.93,115.71) v2(130.93,115.13) v2(130.93,114.55) v2(131.26,43.95) v2(131.5,115.96) v2(131.5,115.37) v2(131.5,114.79) v2(131.76,95.24) v2(131.76,94.61) v2(131.76,93.97) v2(132,30.94) v2(132,29.42) v2(132.39,95.24) v2(132.39,94.61) v2(132.39,93.97) v2(132.44,76.74) v2(132.44,74.79) v2(132.44,72.84) v2(133.03,89.53) v2(133.41,90.03) v2(133.53,30.96) v2(133.53,29.44) v2(133.64,43.95) v2(133.79,17.33) v2(134.22,74.14) v2(134.22,72.19) v2(134.31,70.32) v2(134.74,17.33) v2(135.56,30.96) v2(135.56,29.44) v2(136.1,76.09) v2(136.12,72.27) v2(136.1,71.05) v2(136.42,44.78) v2(136.41,43.25) v2(136.41,41.72) v2(137.42,30.96) v2(137.42,29.44) v2(137.7,76.74) v2(137.7,74.79) v2(137.7,72.84) v2(138.23,94.35) v2(139.31,93.72) v2(139.66,76.04) v2(139.68,74.14) v2(139.7,30.96) v2(139.7,30.2) v2(139.95,109.47) v2(140.17,46.3) v2(140.17,44.77) v2(141.09,71.79) v2(141.66,70.73) v2(141.9,30.58) v2(142.02,61.55) v2(142.35,46.3) v2(142.35,44.77) v2(142.35,43.25) v2(142.43,29.41) v2(142.46,61.12) v2(142.88,60.7) v2(142.85,49.44) v2(143.29,60.27) v2(143.44,108.77) v2(144.26,30.96) v2(144.26,30.2) v2(144.38,41.34) v2(144.71,38.03) v2(145.22,108.76) v2(145.7,41.72) v2(145.66,24.63) v2(145.75,46.26) v2(146.23,117.4) v2(146.2,32.51) v2(146.2,30.98) v2(146.2,29.46) v2(146.87,117.4) v2(147.29,108.72) v2(147.5,24.76) v2(147.91,114.42) v2(148.36,44.77) v2(148.36,41.72) v2(148.81,38.13) v2(148.82,31.98) v2(148.82,30.45) v2(148.88,36.12) v2(149.09,108.77) v2(149.47,116.39) v2(149.47,112.89) v2(149.97,45.11) v2(150.11,116.39) v2(150.42,115.88) v2(150.74,116.39) v2(150.68,32.36) v2(151.06,116.89) v2(151.06,115.88) v2(151.19,49.06) v2(151.22,46.3) v2(151.22,44.77) v2(151.22,43.25) v2(151.38,116.39) v2(151.47,36.14) v2(151.69,116.89) v2(151.69,115.88) v2(151.76,25.19) v2(152.01,116.39) v2(152.2,31.98) v2(152.2,30.45) v2(152.2,28.93) v2(152.33,116.89) v2(152.33,115.88) v2(152.58,87.24) v2(153.03,115.37) v2(153.15,43.25) v2(153.15,41.72) v2(153.66,87.85) v2(153.72,25.2) v2(153.8,72.1) v2(154.23,31.97) v2(154.23,30.44) v2(154.23,28.92) v2(155.25,115.31) v2(155.31,43.63) v2(155.44,119.56) v2(155.38,71.92) v2(155.48,36.15) v2(155.71,30.85) v2(155.77,87.29) v2(156.14,38.12) v2(156.63,36.1) v2(156.92,44.77) v2(156.92,41.72) v2(157.53,31.97) v2(157.53,30.44) v2(157.53,28.92) v2(158.25,45.91) v2(159.44,25.2) v2(159.74,71.04) v2(159.9,31.98) v2(159.9,30.45) v2(159.9,28.93) v2(160.58,15.57) v2(160.97,46.28) v2(160.97,45.65) v2(160.97,45.01) v2(161.04,36.26) v2(161.5,25.02) v2(161.65,32.36) v2(161.89,17.97) v2(161.89,17.33) v2(161.98,16.76) v2(161.98,16.12) v2(162.59,105.4) v2(162.59,81.1) v2(163.15,31.98) v2(163.15,30.45) v2(163.79,107.49) v2(163.79,103.31) v2(163.79,83.19) v2(163.79,79.01) v2(163.93,68.81) v2(163.96,70.94) v2(164.97,95.94) v2(165.09,36.45) v2(165.44,32.09) v2(165.44,30.57) v2(165.44,29.04) v2(165.75,90.61) v2(165.81,71.96) v2(165.81,67.64) v2(165.9,55.79) v2(165.87,54.36) v2(166.21,107.49) v2(166.21,103.31) v2(166.21,83.19) v2(166.21,79.01) v2(167,36.19) v2(166.96,30.95) v2(167.41,105.4) v2(167.41,81.1) v2(167.71,70.86) v2(167.71,68.73) v2(168.89,32.09) v2(168.89,30.57) v2(168.89,29.04) v2(169.28,25.03) v2(169.92,14.15) v2(170.3,107.94) v2(170.31,32.63) v2(170.55,14.16) v2(170.74,107.5) v2(171.19,14.18) v2(174.24,49.39) v2(174.24,48.76) v2(174.43,88.51) v2(174.68,102.85) v2(174.94,103.43) v2(174.87,88.07) v2(174.94,50.16) v2(174.99,104.22) v2(175.06,48.51) v2(175.06,47.84) v2(175.32,13.77) v2(175.32,13.14) v2(175.42,102.85) v2(175.41,41.46) v2(175.41,40.82) v2(175.41,40.19) v2(175.57,104.22) v2(175.57,103.43) v2(175.57,50.16) v2(175.63,16.44) v2(175.7,48.51) v2(175.7,47.84) v2(176.1,102.85) v2(176.18,104.22) v2(176.21,103.43) v2(176.21,50.16) v2(176.33,48.51) v2(176.33,47.84) v2(176.71,48.95) v2(176.84,48.19) v2(177.03,16.44) v2(177.48,76.7) v2(177.54,11.36) v2(177.6,27.36) v2(178.16,76.7) v2(178.17,12.5) v2(178.3,25.84) v2(178.81,76.7) v2(179.06,24.63) v2(179.16,13.61) v2(179.38,26.22) v2(179.48,92.56) v2(179.56,90) v2(180.97,42.09) v2(180.97,41.46) v2(181.03,39.87) v2(181.13,33.18) v2(181.11,31.04) v2(181.73,93.84) v2(181.69,88.8) v2(181.67,42.09) v2(181.67,41.46) v2(181.67,39.87) v2(182.3,39.87) v2(183.01,34.19) v2(183.01,29.87) v2(183.38,20.88) v2(183.83,90.1) v2(183.89,92.57) v2(184.89,33.07) v2(184.89,30.94) v2(184.97,26.53) v2(185.86,46.34) v2(186.34,47) v2(187.89,53.14) v2(187.89,52.51) v2(187.89,51.87) v2(187.95,46.09) v2(187.95,45.46) v2(187.95,44.82) v2(187.95,44.19) v2(187.95,41.96) v2(187.95,41.08) v2(188.78,68.76) v2(188.78,68.13) v2(188.78,67.49) v2(190.33,35.63) v2(190.43,11.36) v2(190.81,13.16) v2(190.95,35.62) v2(191.57,35.62) v2(192.22,35.63) v2(193.15,5.11) v2(193.12,2.98) v2(193.63,95.41) v2(193.66,97.54) v2(194.9,36) v2(194.95,6.13) v2(194.95,1.81) v2(195.41,76.86) v2(195.45,35.61) v2(195.51,98.56) v2(195.51,94.24) v2(195.56,61.67) v2(196.02,78.99) v2(196.34,89.47) v2(196.46,91.24) v2(196.47,84.2) v2(196.6,119.87) v2(196.58,117.73) v2(196.57,87.83) v2(196.64,82.43) v2(196.64,80.75) v2(196.91,5.06) v2(196.91,2.93) v2(197.41,97.46) v2(197.41,95.33) v2(197.44,29.46) v2(198.11,26.72) v2(198.41,120.88) v2(198.41,116.56) v2(198.55,32.16) v2(199.45,10.79) v2(199.73,28.36) v2(200.15,30.88) v2(200.26,119.84) v2(200.26,117.71) v2(200.97,11.29) v3(15.61,116.64) v3(18.73,118.93) v3(19.49,116.26) v3(23.42,77.52) v3(24.05,82.77) v3(25.52,17.07) v3(30.73,18.47) v3(41.52,115.12) v3(42.35,50.54) v3(43.24,48.19) v3(46.48,23.74) v3(47.87,13.45) v3(50.16,23.93) v3(56,112.32) v3(56.64,115.24) v3(60,61.78) v3(60.83,15.1) v3(61.84,26.66) v3(65.14,41.77) v3(65.4,48.12) v3(68.57,111.81) v3(68.76,46.85) v3(71.62,78.67) v3(74.48,81.21) v3(77.34,115.56) v3(79.88,31.61) v3(86.54,105.27) v3(86.92,105.27) v3(91.12,113.15) v3(98.48,121.28) v3(104.7,112.13) v3(104.83,113.15) v3(116.01,113.02) v3(168.27,112.2) v3(169.35,117.02) v3(174.36,47.87) v3(190.24,36.25) v3(197.03,112.39) v3(198.81,36.12) v4(0.51,102.95) v4(0.51,95.46) v4(0.51,87.84) v4(0.51,80.06) v4(0.51,72.55) v4(0.51,65.08) v4(0.51,57.18) v4(0.51,49.61) v4(4.78,46.23) v4(9.52,107.28) v4(10.5,46) v4(10.93,121.77) v4(10.93,119.99) v4(10.93,118.22) v4(10.93,116.44) v4(10.92,114.66) v4(12.02,122.27) v4(12.83,41.33) v4(12.83,33.91) v4(13.8,122.27) v4(13.8,6.02) v4(15.57,122.27) v4(17.35,122.27) v4(19.13,122.27) v4(20.91,122.27) v4(22.69,122.27) v4(24.46,122.27) v4(32.26,122.28) v4(34.11,122.17) v4(36.24,120.29) v4(36.76,6.02) v4(38.36,120.29) v4(40.14,120.29) v4(41.92,120.29) v4(43.7,120.29) v4(44.38,6.02) v4(45.47,120.29) v4(47.25,120.29) v4(49.03,120.29) v4(50.81,120.29) v4(52.59,120.29) v4(54.36,120.29) v4(56.04,122.28) v4(57.82,122.28) v4(59.59,122.28) v4(61.37,122.28) v4(62.97,6.02) v4(63.15,122.28) v4(64.93,122.28) v4(66.71,122.28) v4(68.48,122.28) v4(70.26,122.28) v4(72.04,122.28) v4(73.82,122.28) v4(74.63,6.01) v4(75.6,122.28) v4(77.37,122.28) v4(79.15,122.28) v4(80.93,122.28) v4(82.25,6.01) v4(82.71,122.28) v4(84.49,122.28) v4(86.26,122.28) v4(88.04,122.28) v4(89.82,122.28) v4(89.87,6.01) v4(91.6,122.28) v4(93.38,122.28) v4(95.15,122.28) v4(96.75,5.69) v4(96.93,122.28) v4(98.71,122.28) v4(100.49,122.28) v4(102.27,122.28) v4(104.04,122.28) v4(105.14,0.51) v4(105.82,122.28) v4(107.46,121.73) v4(109.21,121.29) v4(110.99,121.29) v4(112.77,121.29) v4(112.76,0.51) v4(114.55,121.29) v4(116.33,121.29) v4(118.1,121.29) v4(119.88,121.29) v4(120.38,0.51) v4(122.23,121.26) v4(124.48,120.29) v4(126.26,120.29) v4(128.03,120.29) v4(128,0.51) v4(129.81,120.29) v4(131.59,120.29) v4(133.37,120.29) v4(135.15,120.29) v4(135.62,0.51) v4(136.92,120.29) v4(138.7,120.29) v4(140.48,120.29) v4(142.67,120.55) v4(143.24,0.51) v4(143.71,122.28) v4(145.48,122.28) v4(147.26,122.28) v4(149.04,122.28) v4(150.82,122.28) v4(150.86,0.51) v4(152.6,122.28) v4(154.37,122.28) v4(156.15,122.28) v4(157.93,122.28) v4(158.48,0.51) v4(159.71,122.28) v4(161.49,122.28) v4(163.26,122.28) v4(164.57,120.45) v4(166.1,0.51) v4(166.4,119.28) v4(168.23,120.46) v4(168.46,122.25) v4(170.24,122.25) v4(172.01,122.25) v4(173.64,0.54) v4(173.79,122.25) v4(175.57,122.25) v4(177.88,120.64) v4(177.88,118.86) v4(177.88,117.09) v4(177.88,115.31) v4(179.15,113.97) v4(180.93,113.97) v4(182.61,0.51) v4(182.71,113.97) v4(184.49,113.97) v4(184.59,11.21) v4(185.9,11.22) v4(186.26,113.97) v4(187.41,0.74) v4(188.04,113.97) v4(189.82,113.97) v4(190.89,0.54) v4(191.6,113.97) v4(193.38,113.97) v4(195.26,19.74) v4(195.26,19.1) v4(196.02,19.74) v4(196.02,19.1) v4(196.02,18.47) v4(197.03,19.87) v4(197.03,19.1) v4(197.03,18.47) v4(197.16,17.58) v4(200.6,41.13) v4(200.72,71.14) v4(202.24,112.65) v4(202.17,98.66) v4(204.03,79.53) v4(204.15,121.29) v4(204.17,0.51) v4(204.53,76.94) v4(205.52,95.89) v4(205.55,93.47) v4(205.64,57.97) v4(205.59,39.78) v4(206.06,54.31) v4(206.21,72.51) v4(206.62,120.45) v4(206.79,118.8) v4(207.36,117.2) v4(208.07,113.12) v4(208.72,93.46) v4(208.9,116.31) v4(209.04,76.93) v4(209.21,98.03) v4(209.45,113.11) v4(211.11,116.27) v4(211.26,54.54) v4(211.38,57.84) v4(211.38,39.55) v4(211.59,74.09) v4(211.75,98.01) v4(211.75,93.82) v4(211.83,0.57) v4(211.88,114.49) v4(211.88,113.12) v4(211.87,95.86) v4(213.67,76.76) v4(213.87,20.6) v4(213.87,15.9) v4(213.87,11.48) v4(213.87,8.23) v4(213.87,3.86)
