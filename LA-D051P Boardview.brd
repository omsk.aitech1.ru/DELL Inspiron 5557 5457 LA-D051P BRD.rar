# Allegro board LA-D051P Boardview.brd (continued)
## Footprints (pads in the part's own frame, mm; a bottom-side part is the same pattern mirrored in y, then rotated) (continued)
LTC015EUBFS8TL_UMT3F
  oval 0.787x0.889 smd: 1(0,0) 2(-0.65,-1.6) 3(0.65,-1.6)
MEC1404-NU-TR_VTQFP128_14X14
  oval 1.753x0.203 smd: 1(0,0) 2(0,-0.4) 3(0,-0.8) 4(0,-1.2) 5(0,-1.6) 6(0,-2) 7(0,-2.4) 8(0,-2.8) 9(0,-3.2) 10(0,-3.6) 11(0,-4) 12(0,-4.4) 13(0,-4.8) 14(0,-5.2) 15(0,-5.6) 16(0,-6) 17(0,-6.4) 18(0,-6.8) 19(0,-7.2) 20(0,-7.6) 21(0,-8) 22(0,-8.4) 23(0,-8.8) 24(0,-9.2) 25(0,-9.6) 26(0,-10) 27(0,-10.4) 28(0,-10.8) 29(0,-11.2) 30(0,-11.6) 31(0,-12) 32(0,-12.4) 65(15.654,-12.4) 66(15.654,-12) 67(15.654,-11.6) 68(15.654,-11.2) 69(15.654,-10.8) 70(15.654,-10.4) 71(15.654,-10) 72(15.654,-9.6) 73(15.654,-9.2) 74(15.654,-8.8) 75(15.654,-8.4) 76(15.654,-8) 77(15.654,-7.6) 78(15.654,-7.2) 79(15.654,-6.8) 80(15.654,-6.4) 81(15.654,-6) 82(15.654,-5.6) 83(15.654,-5.2) 84(15.654,-4.8) 85(15.654,-4.4) 86(15.654,-4) 87(15.654,-3.6) 88(15.654,-3.2) 89(15.654,-2.8) 90(15.654,-2.4) 91(15.654,-2) 92(15.654,-1.6) 93(15.654,-1.2) 94(15.654,-0.8) 95(15.654,-0.4) 96(15.654,0)
  oval 0.203x1.753 smd: 33(1.627,-14.027) 34(2.027,-14.027) 35(2.427,-14.027) 36(2.827,-14.027) 37(3.227,-14.027) 38(3.627,-14.027) 39(4.027,-14.027) 40(4.427,-14.027) 41(4.827,-14.027) 42(5.227,-14.027) 43(5.627,-14.027) 44(6.027,-14.027) 45(6.427,-14.027) 46(6.827,-14.027) 47(7.227,-14.027) 48(7.627,-14.027) 49(8.027,-14.027) 50(8.427,-14.027) 51(8.827,-14.027) 52(9.227,-14.027) 53(9.627,-14.027) 54(10.027,-14.027) 55(10.427,-14.027) 56(10.827,-14.027) 57(11.227,-14.027) 58(11.627,-14.027) 59(12.027,-14.027) 60(12.427,-14.027) 61(12.827,-14.027) 62(13.227,-14.027) 63(13.627,-14.027) 64(14.027,-14.027) 97(14.027,1.627) 98(13.627,1.627) 99(13.227,1.627) 100(12.827,1.627) 101(12.427,1.627) 102(12.027,1.627) 103(11.627,1.627) 104(11.227,1.627) 105(10.827,1.627) 106(10.427,1.627) 107(10.027,1.627) 108(9.627,1.627) 109(9.227,1.627) 110(8.827,1.627) 111(8.427,1.627) 112(8.027,1.627) 113(7.627,1.627) 114(7.227,1.627) 115(6.827,1.627) 116(6.427,1.627) 117(6.027,1.627) 118(5.627,1.627) 119(5.227,1.627) 120(4.827,1.627) 121(4.427,1.627) 122(4.027,1.627) 123(3.627,1.627) 124(3.227,1.627) 125(2.827,1.627) 126(2.427,1.627) 127(2.027,1.627) 128(1.627,1.627)
MMBT3904_NL_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
MMST3904-7-F_SOT323-3
  oval 0.711x0.889 smd: 1(0,0) 2(0.65,1.9) 3(-0.65,1.9)
MT41K256M16HA-125M-E_FBGA_96P
  round 0.343 smd: A1(0,0) A2(0.8,0) A3(1.6,0) A7(4.801,0) A8(5.601,0) A9(6.401,0) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B7(4.801,-0.8) B8(5.601,-0.8) B9(6.401,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C7(4.801,-1.6) C8(5.601,-1.6) C9(6.401,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D7(4.801,-2.4) D8(5.601,-2.4) D9(6.401,-2.4) E1(0,-3.2) E2(0.8,-3.2) E3(1.6,-3.2) E7(4.801,-3.2) E8(5.601,-3.2) E9(6.401,-3.2) F1(0,-4) F2(0.8,-4) F3(1.6,-4) F7(4.801,-4) F8(5.601,-4) F9(6.401,-4) G1(0,-4.801) G2(0.8,-4.801) G3(1.6,-4.801) G7(4.801,-4.801) G8(5.601,-4.801) G9(6.401,-4.801) H1(0,-5.601) H2(0.8,-5.601) H3(1.6,-5.601) H7(4.801,-5.601) H8(5.601,-5.601) H9(6.401,-5.601) J1(0,-6.401) J2(0.8,-6.401) J3(1.6,-6.401) J7(4.801,-6.401) J8(5.601,-6.401) J9(6.401,-6.401) K1(0,-7.201) K2(0.8,-7.201) K3(1.6,-7.201) K7(4.801,-7.201) K8(5.601,-7.201) K9(6.401,-7.201) L1(0,-8.001) L2(0.8,-8.001) L3(1.6,-8.001) L7(4.801,-8.001) L8(5.601,-8.001) L9(6.401,-8.001) M1(0,-8.801) M2(0.8,-8.801) M3(1.6,-8.801) M7(4.801,-8.801) M8(5.601,-8.801) M9(6.401,-8.801) N1(0,-9.601) N2(0.8,-9.601) N3(1.6,-9.601) N7(4.801,-9.601) N8(5.601,-9.601) N9(6.401,-9.601) P1(0,-10.401) P2(0.8,-10.401) P3(1.6,-10.401) P7(4.801,-10.401) P8(5.601,-10.401) P9(6.401,-10.401) R1(0,-11.201) R2(0.8,-11.201) R3(1.6,-11.201) R7(4.801,-11.201) R8(5.601,-11.201) R9(6.401,-11.201) T1(0,-12.002) T2(0.8,-12.002) T3(1.6,-12.002) T7(4.801,-12.002) T8(5.601,-12.002) T9(6.401,-12.002)
MURAT_BLM15AG102SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM15BD601SN1D_2P
  rect 0.508x0.762 smd: 1(0,0) 2(0.75,0)
MURAT_BLM15PX221SN1D_2P
  rect 0.457x0.508 smd: 1(0,0) 2(0.85,0)
MURAT_BLM18AG601SN1D_L0603_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM18PG331SN1D_2P
  rect 0.66x1.041 smd: 1(0,0) 2(1.2,0)
MURAT_BLM41PG600SN1L_2P
  rect 1.194x2.108 smd: 1(0,0) 2(3.8,0)
MURAT_DLW21SN670HQ2L_4P
  rect 0.889x0.406 smd: 1(0,0) 2(1.7,0) 3(1.7,0.8) 4(0,0.8)
MURAT_LQM2MPN2R2NG0L_2P
  rect 0.787x1.803 smd: 1(0,0) 2(1.6,0)
N16S-GT-S-A2_BGA_595P
  round 0.381 smd: A2(0.8,0) A3(1.6,0) A4(2.4,0) A6(4.1,0) A7(4.9,0) A9(6.58,0) A10(7.38,0) A12(9.06,0) A13(9.86,0) A15(11.54,0) A16(12.34,0) A18(14.02,0) A19(14.82,0) A21(16.5,0) A22(17.3,0) A24(19,0) A25(19.8,0) A26(20.6,0) AA1(0,-16.5) AA2(0.8,-16.5) AA3(1.6,-16.5) AA4(2.4,-16.5) AA5(3.2,-16.5) AA6(4.04,-16.5) AA7(4.9,-16.5) AA8(5.74,-16.5) AA9(6.58,-16.56) AA10(7.38,-16.56) AA12(9.06,-16.56) AA13(9.86,-16.56) AA14(10.7,-16.56) AA15(11.54,-16.56) AA16(12.34,-16.56) AA18(14.02,-16.56) AA19(14.82,-16.56) AA20(15.66,-16.5) AA21(16.5,-16.5) AA22(17.36,-16.5) AA23(18.2,-16.5) AA24(19,-16.5) AA25(19.8,-16.5) AA26(20.6,-16.5) AA27(21.4,-16.5) AB1(0,-17.3) AB2(0.8,-17.3) AB3(1.6,-17.3) AB4(2.4,-17.3) AB5(3.2,-17.3) AB6(4.1,-17.3) AB7(4.9,-17.36) AB8(5.74,-17.36) AB9(6.58,-17.36) AB10(7.38,-17.36) AB11(8.22,-17.36) AB12(9.06,-17.36) AB13(9.86,-17.36) AB14(10.7,-17.36) AB15(11.54,-17.36) AB16(12.34,-17.36) AB17(13.18,-17.36) AB18(14.02,-17.36) AB19(14.82,-17.36) AB20(15.66,-17.36) AB21(16.5,-17.36) AB22(17.3,-17.3) AB23(18.2,-17.3) AB24(19,-17.3) AB25(19.8,-17.3) AB26(20.6,-17.3) AB27(21.4,-17.3) AC2(0.8,-18.15) AC3(1.6,-18.15) AC4(2.4,-18.15) AC5(3.25,-18.15) AC6(4.1,-18.2) AC7(4.9,-18.2) AC8(5.74,-18.2) AC9(6.58,-18.2) AC10(7.38,-18.2) AC11(8.22,-18.2) AC12(9.06,-18.2) AC13(9.86,-18.2) AC14(10.7,-18.2) AC15(11.54,-18.2) AC16(12.34,-18.2) AC17(13.18,-18.2) AC18(14.02,-18.2) AC19(14.82,-18.2) AC20(15.66,-18.2) AC21(16.5,-18.2) AC22(17.3,-18.2) AC23(18.15,-18.15) AC24(19,-18.15) AC25(19.8,-18.15) AC26(20.6,-18.15) AD1(0,-19) AD2(0.8,-19) AD3(1.6,-19) AD4(2.4,-19) AD5(3.25,-19) AD6(4.1,-19) AD7(4.9,-19) AD8(5.74,-19) AD9(6.58,-19) AD10(7.38,-19) AD11(8.22,-19) AD12(9.06,-19) AD13(9.86,-19) AD14(10.7,-19) AD15(11.54,-19) AD16(12.34,-19) AD17(13.18,-19) AD18(14.02,-19) AD19(14.82,-19) AD20(15.66,-19) AD21(16.5,-19) AD22(17.3,-19) AD23(18.15,-19) AD24(19,-19) AD25(19.8,-19) AD26(20.6,-19) AD27(21.4,-19) AE1(0,-19.8) AE2(0.8,-19.8) AE3(1.6,-19.8) AE4(2.4,-19.8) AE5(3.25,-19.8) AE6(4.1,-19.8) AE7(4.9,-19.8) AE8(5.74,-19.8) AE9(6.58,-19.8) AE10(7.38,-19.8) AE11(8.22,-19.8) AE12(9.06,-19.8) AE13(9.86,-19.8) AE14(10.7,-19.8) AE15(11.54,-19.8) AE16(12.34,-19.8) AE17(13.18,-19.8) AE18(14.02,-19.8) AE19(14.82,-19.8) AE20(15.66,-19.8) AE21(16.5,-19.8) AE22(17.3,-19.8) AE23(18.15,-19.8) AE24(19,-19.8) AE25(19.8,-19.8) AE26(20.6,-19.8) AE27(21.4,-19.8) AF1(0,-20.6) AF2(0.8,-20.6) AF3(1.6,-20.6) AF4(2.4,-20.6) AF5(3.25,-20.6) AF6(4.1,-20.6) AF7(4.9,-20.6) AF8(5.74,-20.6) AF9(6.58,-20.6) AF10(7.38,-20.6) AF11(8.22,-20.6) AF12(9.06,-20.6) AF13(9.86,-20.6) AF14(10.7,-20.6) AF15(11.54,-20.6) AF16(12.34,-20.6) AF17(13.18,-20.6) AF18(14.02,-20.6) AF19(14.82,-20.6) AF20(15.66,-20.6) AF21(16.5,-20.6) AF22(17.3,-20.6) AF23(18.15,-20.6) AF24(19,-20.6) AF25(19.8,-20.6) AF26(20.6,-20.6) AF27(21.4,-20.6) AG2(0.8,-21.4) AG3(1.6,-21.4) AG4(2.4,-21.4) AG6(4.1,-21.4) AG7(4.9,-21.4) AG9(6.58,-21.4) AG10(7.38,-21.4) AG12(9.06,-21.4) AG13(9.86,-21.4) AG15(11.54,-21.4) AG16(12.34,-21.4) AG18(14.02,-21.4) AG19(14.82,-21.4) AG21(16.5,-21.4) AG22(17.3,-21.4) AG24(19,-21.4) AG25(19.8,-21.4) AG26(20.6,-21.4) B1(0,-0.8) B2(0.8,-0.8) B3(1.6,-0.8) B4(2.4,-0.8) B5(3.25,-0.8) B6(4.1,-0.8) B7(4.9,-0.8) B8(5.74,-0.8) B9(6.58,-0.8) B10(7.38,-0.8) B11(8.22,-0.8) B12(9.06,-0.8) B13(9.86,-0.8) B14(10.7,-0.8) B15(11.54,-0.8) B16(12.34,-0.8) B17(13.18,-0.8) B18(14.02,-0.8) B19(14.82,-0.8) B20(15.66,-0.8) B21(16.5,-0.8) B22(17.3,-0.8) B23(18.15,-0.8) B24(19,-0.8) B25(19.8,-0.8) B26(20.6,-0.8) B27(21.4,-0.8) C1(0,-1.6) C2(0.8,-1.6) C3(1.6,-1.6) C4(2.4,-1.6) C5(3.25,-1.6) C6(4.1,-1.6) C7(4.9,-1.6) C8(5.74,-1.6) C9(6.58,-1.6) C10(7.38,-1.6) C11(8.22,-1.6) C12(9.06,-1.6) C13(9.86,-1.6) C14(10.7,-1.6) C15(11.54,-1.6) C16(12.34,-1.6) C17(13.18,-1.6) C18(14.02,-1.6) C19(14.82,-1.6) C20(15.66,-1.6) C21(16.5,-1.6) C22(17.3,-1.6) C23(18.15,-1.6) C24(19,-1.6) C25(19.8,-1.6) C26(20.6,-1.6) C27(21.4,-1.6) D1(0,-2.4) D2(0.8,-2.4) D3(1.6,-2.4) D4(2.4,-2.4) D5(3.25,-2.4) D6(4.1,-2.4) D7(4.9,-2.4) D8(5.74,-2.4) D9(6.58,-2.4) D10(7.38,-2.4) D11(8.22,-2.4) D12(9.06,-2.4) D13(9.86,-2.4) D14(10.7,-2.4) D15(11.54,-2.4) D16(12.34,-2.4) D17(13.18,-2.4) D18(14.02,-2.4) D19(14.82,-2.4) D20(15.66,-2.4) D21(16.5,-2.4) D22(17.3,-2.4) D23(18.15,-2.4) D24(19,-2.4) D25(19.8,-2.4) D26(20.6,-2.4) D27(21.4,-2.4) E2(0.8,-3.25) E3(1.6,-3.25) E4(2.4,-3.25) E5(3.25,-3.25) E6(4.1,-3.2) E7(4.9,-3.2) E8(5.74,-3.2) E9(6.58,-3.2) E10(7.38,-3.2) E11(8.22,-3.2) E12(9.06,-3.2) E13(9.86,-3.2) E14(10.7,-3.2) E15(11.54,-3.2) E16(12.34,-3.2) E17(13.18,-3.2) E18(14.02,-3.2) E19(14.82,-3.2) E20(15.66,-3.2) E21(16.5,-3.2) E22(17.3,-3.2) E23(18.15,-3.25) E24(19,-3.25) E25(19.8,-3.25) E26(20.6,-3.25) F1(0,-4.1) F2(0.8,-4.1) F3(1.6,-4.1) F4(2.4,-4.1) F5(3.2,-4.1) F6(4.1,-4.1) F7(4.9,-4.04) F8(5.74,-4.04) F9(6.58,-4.04) F10(7.38,-4.04) F11(8.22,-4.04) F12(9.06,-4.04) F13(9.86,-4.04) F14(10.7,-4.04) F15(11.54,-4.04) F16(12.34,-4.04) F17(13.18,-4.04) F18(14.02,-4.04) F19(14.82,-4.04) F20(15.66,-4.04) F21(16.5,-4.04) F22(17.3,-4.1) F23(18.2,-4.1) F24(19,-4.1) F25(19.8,-4.1) F26(20.6,-4.1) F27(21.4,-4.1) G1(0,-4.9) G2(0.8,-4.9) G3(1.6,-4.9) G4(2.4,-4.9) G5(3.2,-4.9) G6(4.04,-4.9) G7(4.9,-4.9) G8(5.74,-4.9) G9(6.58,-4.84) G10(7.38,-4.84) G12(9.06,-4.84) G13(9.86,-4.84) G14(10.7,-4.84) G15(11.54,-4.84) G16(12.34,-4.84) G18(14.02,-4.84) G19(14.82,-4.84) G20(15.66,-4.9) G21(16.5,-4.9) G22(17.36,-4.9) G23(18.2,-4.9) G24(19,-4.9) G25(19.8,-4.9) G26(20.6,-4.9) G27(21.4,-4.9) H2(0.8,-5.74) H3(1.6,-5.74) H4(2.4,-5.74) H5(3.2,-5.74) H6(4.04,-5.74) H22(17.36,-5.74) H23(18.2,-5.74) H24(19,-5.74) H25(19.8,-5.74) H26(20.6,-5.74) J1(0,-6.58) J2(0.8,-6.58) J3(1.6,-6.58) J4(2.4,-6.58) J5(3.2,-6.58) J6(4.04,-6.58) J7(4.84,-6.58) J21(16.56,-6.58) J22(17.36,-6.58) J23(18.2,-6.58) J24(19,-6.58) J25(19.8,-6.58) J26(20.6,-6.58) J27(21.4,-6.58) K1(0,-7.38) K2(0.8,-7.38) K3(1.6,-7.38) K4(2.4,-7.38) K5(3.2,-7.38) K6(4.04,-7.38) K7(4.84,-7.38) K21(16.56,-7.38) K22(17.36,-7.38) K23(18.2,-7.38) K24(19,-7.38) K25(19.8,-7.38) K26(20.6,-7.38) K27(21.4,-7.38) L2(0.8,-8.22) L3(1.6,-8.22) L4(2.4,-8.22) L5(3.2,-8.22) L6(4.04,-8.22) L22(17.36,-8.22) L23(18.2,-8.22) L24(19,-8.22) L25(19.8,-8.22) L26(20.6,-8.22) M1(0,-9.06) M2(0.8,-9.06) M3(1.6,-9.06) M4(2.4,-9.06) M5(3.2,-9.06) M6(4.04,-9.06) M7(4.84,-9.06) M21(16.56,-9.06) M22(17.36,-9.06) M23(18.2,-9.06) M24(19,-9.06) M25(19.8,-9.06) M26(20.6,-9.06) M27(21.4,-9.06) N1(0,-9.86) N2(0.8,-9.86) N3(1.6,-9.86) N4(2.4,-9.86) N5(3.2,-9.86) N6(4.04,-9.86) N7(4.84,-9.86) N21(16.56,-9.86) N22(17.36,-9.86) N23(18.2,-9.86) N24(19,-9.86) N25(19.8,-9.86) N26(20.6,-9.86) N27(21.4,-9.86) P2(0.8,-10.7) P3(1.6,-10.7) P4(2.4,-10.7) P5(3.2,-10.7) P6(4.04,-10.7) P22(17.36,-10.7) P23(18.2,-10.7) P24(19,-10.7) P25(19.8,-10.7) P26(20.6,-10.7) R1(0,-11.54) R2(0.8,-11.54) R3(1.6,-11.54) R4(2.4,-11.54) R5(3.2,-11.54) R6(4.04,-11.54) R7(4.84,-11.54) R21(16.56,-11.54) R22(17.36,-11.54) R23(18.2,-11.54) R24(19,-11.54) R25(19.8,-11.54) R26(20.6,-11.54) R27(21.4,-11.54) T1(0,-12.34) T2(0.8,-12.34) T3(1.6,-12.34) T4(2.4,-12.34) T5(3.2,-12.34) T6(4.04,-12.34) T7(4.84,-12.34) T21(16.56,-12.34) T22(17.36,-12.34) T23(18.2,-12.34) T24(19,-12.34) T25(19.8,-12.34) T26(20.6,-12.34) T27(21.4,-12.34) U2(0.8,-13.18) U3(1.6,-13.18) U4(2.4,-13.18) U5(3.2,-13.18) U6(4.04,-13.18) U22(17.36,-13.18) U23(18.2,-13.18) U24(19,-13.18) U25(19.8,-13.18) U26(20.6,-13.18) V1(0,-14.02) V2(0.8,-14.02) V3(1.6,-14.02) V4(2.4,-14.02) V5(3.2,-14.02) V6(4.04,-14.02) V7(4.84,-14.02) V21(16.56,-14.02) V22(17.36,-14.02) V23(18.2,-14.02) V24(19,-14.02) V25(19.8,-14.02) V26(20.6,-14.02) V27(21.4,-14.02) W1(0,-14.82) W2(0.8,-14.82) W3(1.6,-14.82) W4(2.4,-14.82) W5(3.2,-14.82) W6(4.04,-14.82) W7(4.84,-14.82) W21(16.56,-14.82) W22(17.36,-14.82) W23(18.2,-14.82) W24(19,-14.82) W25(19.8,-14.82) W26(20.6,-14.82) W27(21.4,-14.82) Y2(0.8,-15.66) Y3(1.6,-15.66) Y4(2.4,-15.66) Y5(3.2,-15.66) Y6(4.04,-15.66) Y22(17.36,-15.66) Y23(18.2,-15.66) Y24(19,-15.66) Y25(19.8,-15.66) Y26(20.6,-15.66)
  round 0.406 smd: K10(6.7,-6.7) K11(7.7,-6.7) K12(8.7,-6.7) K13(9.7,-6.7) K14(10.7,-6.7) K15(11.7,-6.7) K16(12.7,-6.7) K17(13.7,-6.7) K18(14.7,-6.7) L10(6.7,-7.7) L11(7.7,-7.7) L12(8.7,-7.7) L13(9.7,-7.7) L14(10.7,-7.7) L15(11.7,-7.7) L16(12.7,-7.7) L17(13.7,-7.7) L18(14.7,-7.7) M10(6.7,-8.7) M11(7.7,-8.7) M12(8.7,-8.7) M13(9.7,-8.7) M14(10.7,-8.7) M15(11.7,-8.7) M16(12.7,-8.7) M17(13.7,-8.7) M18(14.7,-8.7) N10(6.7,-9.7) N11(7.7,-9.7) N12(8.7,-9.7) N13(9.7,-9.7) N14(10.7,-9.7) N15(11.7,-9.7) N16(12.7,-9.7) N17(13.7,-9.7) N18(14.7,-9.7) P10(6.7,-10.7) P11(7.7,-10.7) P12(8.7,-10.7) P13(9.7,-10.7) P14(10.7,-10.7) P15(11.7,-10.7) P16(12.7,-10.7) P17(13.7,-10.7) P18(14.7,-10.7) R10(6.7,-11.7) R11(7.7,-11.7) R12(8.7,-11.7) R13(9.7,-11.7) R14(10.7,-11.7) R15(11.7,-11.7) R16(12.7,-11.7) R17(13.7,-11.7) R18(14.7,-11.7) T10(6.7,-12.7) T11(7.7,-12.7) T12(8.7,-12.7) T13(9.7,-12.7) T14(10.7,-12.7) T15(11.7,-12.7) T16(12.7,-12.7) T17(13.7,-12.7) T18(14.7,-12.7) U10(6.7,-13.7) U11(7.7,-13.7) U12(8.7,-13.7) U13(9.7,-13.7) U14(10.7,-13.7) U15(11.7,-13.7) U16(12.7,-13.7) U17(13.7,-13.7) U18(14.7,-13.7) V10(6.7,-14.7) V11(7.7,-14.7) V12(8.7,-14.7) V13(9.7,-14.7) V14(10.7,-14.7) V15(11.7,-14.7) V16(12.7,-14.7) V17(13.7,-14.7) V18(14.7,-14.7)
NC7ST32P5X_SC70-5
  oval 0.406x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
NTK3139PT1G_SOT723-3
  oval 0.406x0.457 smd: 1(0,0) 2(-0.4,-1) 3(0.4,-1)
PESD5V0U2BT_SOT23-3
  oval 1.016x1.524 smd: 1(0,0) 2(0.965,2.083) 3(-0.965,2.083)
PS8520BTQFN20GTR2_TQFN20_4X4
  oval 0.254x1.194 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 11(2,3.8) 12(1.5,3.8) 13(1,3.8) 14(0.5,3.8) 15(0,3.8)
  oval 1.194x0.254 smd: 6(2.9,0.9) 7(2.9,1.4) 8(2.9,1.9) 9(2.9,2.4) 10(2.9,2.9) 16(-0.9,2.9) 17(-0.9,2.4) 18(-0.9,1.9) 19(-0.9,1.4) 20(-0.9,0.9)
  rect 2.108x2.108 smd: 21(1,1.9)
R0402_0OHM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R0603_0OHM
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R0805_0OHM
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_0402
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0402-NPM
  rect 0.508x0.559 smd: 1(0,0) 2(0.914,0)
R_0603
  rect 0.635x0.889 smd: 1(0,0) 2(1.397,0)
R_0805
  rect 0.813x1.397 smd: 1(0,0) 2(1.702,0)
R_1206
  rect 1.016x1.651 smd: 1(0,0) 2(2.667,0)
R_1206_4P
  custom 0.476x0.476 smd: 1(0,0) 4(5.08,0)
  rect 1.397x0.381 smd: 2(1.206,0) 3(3.873,0)
RB551V-30_SOD323-2
  rect 0.559x0.813 smd: 1(0,0) 2(2.3,0)
RB751S40T1G_SOD523-2
  rect 0.406x0.406 smd: 1(0,0) 2(1.4,0)
RHU002N06_SOT323-3
  oval 0.813x0.914 smd: 1(0,0) 2(0.65,1.6) 3(-0.65,1.6)
RP_0804_8P4R
  oval 0.66x0.254 smd: 1(0,0) 2(0,-0.5) 3(0,-1) 4(0,-1.5) 5(1.15,-1.5) 6(1.15,-1) 7(1.15,-0.5) 8(1.15,0)
RT8207MZQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RT8207PGQW_WQFN20_3X3
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 11(1.6,3.1) 12(1.2,3.1) 13(0.8,3.1) 14(0.4,3.1) 15(0,3.1)
  oval 0.889x0.203 smd: 6(2.35,0.75) 7(2.35,1.15) 8(2.35,1.55) 9(2.35,1.95) 10(2.35,2.35) 16(-0.75,2.35) 17(-0.75,1.95) 18(-0.75,1.55) 19(-0.75,1.15) 20(-0.75,0.75)
  rect 1.702x1.702 smd: 21(0.8,1.55)
RTL8106EUS-CG_QFN32_4X4
  oval 0.203x0.889 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 17(2.8,4.1) 18(2.4,4.1) 19(2,4.1) 20(1.6,4.1) 21(1.2,4.1) 22(0.8,4.1) 23(0.4,4.1) 24(0,4.1)
  oval 0.889x0.203 smd: 9(3.45,0.65) 10(3.45,1.05) 11(3.45,1.45) 12(3.45,1.85) 13(3.45,2.25) 14(3.45,2.65) 15(3.45,3.05) 16(3.45,3.45) 25(-0.65,3.45) 26(-0.65,3.05) 27(-0.65,2.65) 28(-0.65,2.25) 29(-0.65,1.85) 30(-0.65,1.45) 31(-0.65,1.05) 32(-0.65,0.65)
  rect 2.692x2.692 smd: 33(1.4,2.05)
SDAN_601028-008041_8P-T
  round 1.245 hole 0.94: 1(0,0) 2(1.02,-1) 3(2.04,0) 4(3.06,-1) 5(4.08,0) 6(5.1,-1) 7(6.12,0) 8(7.14,-1)
  oval 1.092x2.692 hole 0.61x2.21: 9(-4.43,-5) 10(11.57,-5)
SDMK0340L-7-F_SOD323-2
  rect 1.346x0.66 smd: 1(0,0) 2(2.4,0)
SHORTPADS
  custom 0.19x0.19 smd: 1(-0.483,0) 2(0.483,0)
SI3456BDV-T1-E3_TSOP6
  oval 0.508x1.448 smd: 1(0,0) 2(1,0) 3(2,0) 4(2,2.425) 5(1,2.425) 6(0,2.425)
SINGA_2SJ3080-001111F_6P
  oval 0.991x1.905 hole 0.61x1.499: 1(0,0) 2(-9.55,5.5) 3(0,7.8) 4(-9.55,8.4) 5(-9.55,0) 6(-9.55,2.75) 7(0,4.1)
SIR472DP-T1-GE3_POWERPAK8-5
  oval 0.61x1.27 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0)
  custom 1.105x1.105 smd: 5(1.905,3.36)
SIS412DN-T1-GE3_POWERPAK8-5
  oval 0.406x0.991 smd: 1(0,0) 2(0.66,0) 3(1.32,0) 4(1.98,0)
  custom 0.559x0.559 smd: 5(0.99,2.247)
SKL-U_BGA_1356P-T
  round 0.356 smd: A3(-0.965,0) A70(-40.166,0) B2(-0.483,0.483) B71(-40.629,0.462) BA1(0,22.166) BA71(-40.629,22.166) BB2(-0.462,22.628) BB70(-40.166,22.628) C1(0,0.965)
  round 0.33 smd: A4(-1.615,0) A69(-39.516,0) AY1(0,21.516) AY71(-40.629,21.516) B3(-1.118,0.635) B70(-39.999,0.63) BA2(-0.629,21.999) BA70(-39.999,21.999) BB3(-1.113,22.628) BB69(-39.516,22.628) C2(-0.635,1.118) C71(-40.629,1.113) D1(0,1.615)
  round 0.305 smd: A5(-2.266,0) A68(-38.866,0) AA2(-0.975,10.804) AA4(-1.951,10.804) AA63(-35.427,10.719) AA64(-36.077,10.719) AA65(-36.727,10.719) AA66(-37.377,10.719) AA67(-38.028,10.719) AA68(-38.678,10.719) AA69(-39.328,10.719) AA70(-39.978,10.719) AA71(-40.629,10.719) AB4(-1.951,11.467) AB6(-2.729,11.181) AB7(-3.379,11.181) AB8(-4.029,11.181) AB9(-4.679,11.181) AB10(-5.33,11.181) AB11(-5.98,11.181) AB12(-6.63,11.181) AB13(-7.28,11.181) AB15(-8.126,11.305) AB16(-8.776,11.305) AB17(-9.426,11.305) AB18(-10.077,11.305) AB19(-10.727,11.305) AB20(-11.377,11.305) AB21(-12.027,11.305) AB62(-34.958,11.176) AC3(-1.626,12.13) AC63(-35.427,11.633) AC64(-36.077,11.633) AC65(-36.727,11.633) AC66(-37.377,11.633) AC67(-38.028,11.633) AC68(-38.678,11.633) AC69(-39.328,11.633) AC70(-39.978,11.633) AC71(-40.629,11.633) AD4(-1.951,12.792) AD6(-2.729,12.248) AD7(-3.379,12.248) AD8(-4.029,12.248) AD9(-4.679,12.248) AD10(-5.33,12.248) AD11(-5.98,12.248) AD12(-6.63,12.248) AD13(-7.28,12.248) AD15(-8.126,12.143) AD16(-8.776,12.143) AD17(-9.426,12.143) AD18(-10.077,12.143) AD19(-10.727,12.143) AD20(-11.377,12.143) AD21(-12.027,12.143) AD62(-34.958,12.09) AE62(-34.958,13.005) AE63(-35.427,12.547) AE64(-36.077,12.547) AE65(-36.727,12.547) AE66(-37.377,12.547) AE67(-38.028,12.547) AE68(-38.678,12.547) AE69(-39.328,12.547) AF2(-0.975,13.455) AF4(-1.951,13.455) AF6(-2.729,13.315) AF7(-3.379,13.315) AF8(-4.029,13.315) AF9(-4.679,13.315) AF10(-5.33,13.315) AF11(-5.98,13.315) AF12(-6.63,13.315) AF13(-7.28,13.315) AF15(-8.126,12.982) AF16(-8.776,12.982) AF17(-9.426,12.982) AF18(-10.077,12.982) AF19(-10.727,12.982) AF20(-11.377,12.982) AF21(-12.027,12.982) AF63(-35.427,13.462) AF64(-36.077,13.462) AF65(-36.727,13.462) AF66(-37.377,13.462) AF67(-38.028,13.462) AF68(-38.678,13.253) AF69(-39.328,13.253) AG4(-1.951,14.118) AG15(-8.126,13.82) AG16(-8.776,13.82) AG17(-9.426,13.82) AG18(-10.077,13.82) AG19(-10.727,13.82) AG20(-11.377,13.82) AG21(-12.027,13.82) AG62(-34.958,13.919) AG69(-39.003,13.916) AH3(-1.626,14.781) AH6(-2.729,14.381) AH7(-3.379,14.381) AH8(-4.029,14.381) AH9(-4.679,14.381) AH10(-5.33,14.381) AH11(-5.98,14.381) AH12(-6.63,14.381) AH13(-7.28,14.381) AH63(-35.427,14.376) AH64(-36.077,14.376) AH65(-36.727,14.376) AH66(-37.377,14.376) AH67(-38.028,14.376) AJ4(-1.951,15.444) AJ15(-8.126,14.658) AJ16(-8.776,14.658) AJ17(-9.426,14.658) AJ18(-10.077,14.658) AJ19(-10.727,14.658) AJ20(-11.377,14.658) AJ21(-12.027,14.658) AJ62(-34.958,14.833) AK6(-2.729,15.321) AK7(-3.379,15.321) AK8(-4.029,15.321) AK9(-4.679,15.321) AK10(-5.33,15.321) AK11(-5.98,15.321) AK12(-6.63,15.321) AK13(-7.28,15.321) AK15(-8.126,15.496) AK16(-8.776,15.496) AK17(-9.426,15.496) AK18(-10.077,15.496) AK19(-10.727,15.496) AK20(-11.377,15.496) AK21(-12.027,15.496) AK22(-12.719,15.323) AK23(-13.633,15.323) AK25(-14.547,15.323) AK27(-15.462,15.323) AK28(-16.376,15.323) AK30(-17.291,15.323) AK32(-18.205,15.323) AK33(-19.119,15.323) AK35(-20.034,15.323) AK37(-20.948,15.323) AK38(-21.863,15.323) AK40(-22.777,15.323) AK42(-23.691,15.323) AK43(-24.606,15.323) AK45(-25.52,15.323) AK46(-26.435,15.323) AK48(-27.349,15.323) AK50(-28.263,15.323) AK52(-29.178,15.323) AK53(-30.092,15.323) AK55(-31.007,15.323) AK56(-31.921,15.323) AK58(-32.835,15.323) AK60(-33.75,15.323) AK62(-34.774,15.458) AK63(-35.427,15.291) AK64(-36.077,15.291) AK65(-36.727,15.291) AK66(-37.377,15.291) AK67(-38.028,15.291) AK68(-38.678,15.143) AK69(-39.653,15.143) AL2(-0.975,16.107) AL4(-1.951,16.107) AL23(-13.176,15.788) AL25(-14.09,15.788) AL27(-15.005,15.788) AL28(-15.919,15.788) AL30(-16.833,15.788) AL32(-17.748,15.788) AL33(-18.662,15.788) AL35(-19.577,15.788) AL37(-20.491,15.788) AL38(-21.405,15.788) AL40(-22.32,15.788) AL42(-23.234,15.788) AL43(-24.149,15.788) AL45(-25.063,15.788) AL46(-25.977,15.788) AL48(-26.892,15.788) AL50(-27.806,15.788) AL52(-28.721,15.788) AL53(-29.635,15.788) AL55(-30.549,15.788) AL56(-31.464,15.788) AL58(-32.378,15.788) AL60(-33.293,15.788) AL61(-34.207,15.788) AL63(-35.427,16.159) AL64(-36.077,16.159) AL65(-36.727,16.159) AL66(-37.377,16.159) AM4(-1.951,16.77) AM5(-2.66,16.261) AM7(-3.575,16.261) AM8(-4.489,16.261) AM10(-5.403,16.261) AM11(-6.318,16.261) AM13(-7.232,16.261) AM15(-8.147,16.261) AM16(-9.061,16.261) AM18(-9.975,16.261) AM20(-10.89,16.261) AM21(-11.804,16.261) AM22(-12.719,16.261) AM23(-13.633,16.261) AM25(-14.547,16.261) AM27(-15.462,16.261) AM28(-16.376,16.261) AM30(-17.291,16.261) AM32(-18.205,16.261) AM33(-19.119,16.261) AM35(-20.034,16.261) AM37(-20.948,16.261) AM38(-21.863,16.261) AM40(-22.777,16.261) AM42(-23.691,16.261) AM43(-24.606,16.261) AM45(-25.52,16.261) AM46(-26.435,16.261) AM48(-27.349,16.261) AM50(-28.263,16.261) AM52(-29.178,16.261) AM53(-30.092,16.261) AM55(-31.007,16.261) AM56(-31.921,16.261) AM58(-32.835,16.261) AM60(-33.75,16.261) AM61(-34.664,16.261) AM68(-38.353,16.37) AM69(-39.003,16.37) AN3(-1.626,17.433) AN5(-2.66,16.911) AN7(-3.575,16.911) AN8(-4.489,16.911) AN10(-5.403,16.911) AN11(-6.318,16.911) AN13(-7.232,16.911) AN15(-8.147,16.911) AN16(-9.061,16.911) AN18(-9.975,16.911) AN20(-10.89,16.911) AN21(-11.804,16.911) AN22(-12.719,16.911) AN23(-13.633,16.911) AN25(-14.547,16.911) AN27(-15.462,16.911) AN28(-16.376,16.911) AN30(-17.291,16.911) AN32(-18.205,16.911) AN33(-19.119,16.911) AN35(-20.034,16.911) AN37(-20.948,16.911) AN38(-21.863,16.911) AN40(-22.777,16.911) AN42(-23.691,16.911) AN43(-24.606,16.911) AN45(-25.52,16.911) AN46(-26.435,16.911) AN48(-27.349,16.911) AN50(-28.263,16.911) AN52(-29.178,16.911) AN53(-30.092,16.911) AN55(-31.007,16.911) AN56(-31.921,16.911) AN58(-32.835,16.911) AN60(-33.75,16.911) AN61(-34.664,16.911) AN63(-35.579,16.911) AN65(-36.493,16.911) AN66(-37.407,16.911) AN68(-38.678,17.033) AN69(-39.328,17.033) AP4(-1.951,18.096) AP5(-2.66,17.561) AP7(-3.575,17.561) AP8(-4.489,17.561) AP10(-5.403,17.561) AP11(-6.318,17.561) AP13(-7.232,17.561) AP15(-8.147,17.561) AP16(-9.061,17.561) AP18(-9.975,17.561) AP20(-10.89,17.561) AP21(-11.804,17.561) AP22(-12.719,17.561) AP23(-13.633,17.561) AP25(-14.547,17.561) AP27(-15.462,17.561) AP28(-16.376,17.561) AP30(-17.291,17.561) AP32(-18.205,17.561) AP33(-19.119,17.561) AP35(-20.034,17.561) AP37(-20.948,17.561) AP38(-21.863,17.561) AP40(-22.777,17.561) AP42(-23.691,17.561) AP43(-24.606,17.561) AP45(-25.52,17.561) AP46(-26.435,17.561) AP48(-27.349,17.561) AP50(-28.263,17.561) AP52(-29.178,17.561) AP53(-30.092,17.561) AP55(-31.007,17.561) AP56(-31.921,17.561) AP58(-32.835,17.561) AP60(-33.75,17.561) AP61(-34.664,17.561) AP63(-35.579,17.561) AP65(-36.493,17.561) AP66(-37.407,17.561) AP68(-38.353,17.646) AP70(-39.572,17.646) AR5(-2.66,18.211) AR7(-3.575,18.211) AR8(-4.489,18.211) AR10(-5.403,18.211) AR11(-6.318,18.211) AR13(-7.232,18.211) AR15(-8.147,18.211) AR16(-9.061,18.211) AR18(-9.975,18.211) AR20(-10.89,18.211) AR21(-11.804,18.211) AR22(-12.719,18.211) AR23(-13.633,18.211) AR25(-14.547,18.211) AR27(-15.462,18.211) AR28(-16.376,18.211) AR30(-17.291,18.211) AR32(-18.205,18.211) AR33(-19.119,18.211) AR35(-20.034,18.211) AR37(-20.948,18.211) AR38(-21.863,18.211) AR40(-22.777,18.211) AR42(-23.691,18.211) AR43(-24.606,18.211) AR45(-25.52,18.211) AR46(-26.435,18.211) AR48(-27.349,18.211) AR50(-28.263,18.211) AR52(-29.178,18.211) AR53(-30.092,18.211) AR55(-31.007,18.211) AR56(-31.921,18.211) AR58(-32.835,18.211) AR60(-33.75,18.211) AR61(-34.664,18.211) AR63(-35.579,18.211) AR65(-36.493,18.211) AR66(-37.407,18.211) AR68(-38.678,18.26) AR69(-39.328,18.26) AT2(-0.975,18.759) AT4(-1.951,18.759) AT5(-2.66,18.862) AT7(-3.575,18.862) AT8(-4.489,18.862) AT10(-5.403,18.862) AT11(-6.318,18.862) AT13(-7.232,18.862) AT15(-8.147,18.862) AT16(-9.061,18.862) AT18(-9.975,18.862) AT20(-10.89,18.862) AT21(-11.804,18.862) AT22(-12.719,18.862) AT23(-13.633,18.862) AT25(-14.547,18.862) AT27(-15.462,18.862) AT28(-16.376,18.862) AT30(-17.291,18.862) AT32(-18.205,18.862) AT33(-19.119,18.862) AT35(-20.034,18.862) AT37(-20.948,18.862) AT38(-21.863,18.862) AT40(-22.777,18.862) AT42(-23.691,18.862) AT43(-24.606,18.862) AT45(-25.52,18.862) AT46(-26.435,18.862) AT48(-27.349,18.862) AT50(-28.263,18.862) AT52(-29.178,18.862) AT53(-30.092,18.862) AT55(-31.007,18.862) AT56(-31.921,18.862) AT58(-32.835,18.862) AT60(-33.75,18.862) AT61(-34.664,18.862) AT63(-35.579,18.862) AT65(-36.493,18.862) AT66(-37.407,18.862) AT68(-38.353,18.823) AT69(-39.003,18.823) AU4(-1.951,19.422) AU5(-2.66,19.512) AU7(-3.575,19.512) AU8(-4.489,19.512) AU10(-5.403,19.512) AU11(-6.318,19.512) AU13(-7.232,19.512) AU15(-8.147,19.512) AU16(-9.061,19.512) AU18(-9.975,19.512) AU20(-10.89,19.512) AU21(-11.804,19.512) AU22(-12.719,19.512) AU23(-13.633,19.512) AU25(-14.547,19.512) AU27(-15.462,19.512) AU28(-16.376,19.512) AU30(-17.291,19.512) AU32(-18.205,19.512) AU33(-19.119,19.512) AU35(-20.034,19.512) AU37(-20.948,19.512) AU38(-21.863,19.512) AU40(-22.777,19.512) AU42(-23.691,19.512) AU43(-24.606,19.512) AU45(-25.52,19.512) AU46(-26.435,19.512) AU48(-27.349,19.512) AU50(-28.263,19.512) AU52(-29.178,19.512) AU53(-30.092,19.512) AU55(-31.007,19.512) AU56(-31.921,19.512) AU58(-32.835,19.512) AU60(-33.75,19.512) AU61(-34.664,19.512) AU63(-35.579,19.512) AU65(-36.493,19.512) AU66(-37.407,19.512) AV3(-1.626,20.113) AV68(-38.343,20.026) AV69(-39.328,20.215) AV70(-39.978,20.215) AW1(0,20.866) AW5(-2.534,20.226) AW6(-3.184,20.353) AW7(-3.75,20.678) AW8(-4.328,20.353) AW9(-4.898,20.678) AW10(-5.561,20.353) AW11(-6.171,20.678) AW12(-6.749,20.353) AW13(-7.319,20.678) AW14(-7.982,20.353) AW15(-8.592,20.678) AW16(-9.17,20.353) AW17(-9.74,20.678) AW18(-10.403,20.353) AW20(-11.012,20.678) AW21(-11.59,20.353) AW22(-12.16,20.678) AW23(-12.849,20.353) AW25(-13.486,20.678) AW26(-14.05,20.353) AW27(-14.713,20.678) AW28(-15.326,20.353) AW29(-15.94,20.678) AW30(-16.603,20.353) AW31(-17.167,20.678) AW32(-17.83,20.353) AW33(-18.467,20.678) AW34(-19.031,20.353) AW35(-19.694,20.678) AW36(-20.307,20.353) AW37(-20.921,20.678) AW38(-21.584,20.353) AW39(-22.148,20.678) AW41(-22.785,20.353) AW42(-23.423,20.678) AW43(-23.986,20.353) AW44(-24.649,20.678) AW45(-25.263,20.353) AW46(-25.876,20.678) AW47(-26.477,20.353) AW48(-27.041,20.678) AW49(-27.669,20.353) AW50(-28.298,20.678) AW51(-28.862,20.353) AW52(-29.463,20.678) AW53(-30.076,20.353) AW54(-30.69,20.678) AW55(-31.352,20.353) AW56(-31.916,20.678) AW57(-32.554,20.353) AW59(-33.191,20.678) AW60(-33.755,20.353) AW61(-34.418,20.678) AW62(-35.032,20.353) AW63(-35.645,20.678) AW64(-36.308,20.353) AW65(-36.872,20.678) AW66(-37.407,20.215) AW67(-38.332,20.685) AW68(-38.936,20.936) AW69(-39.581,20.85) AW70(-39.999,21.349) AW71(-40.629,20.866) AY2(-0.629,21.348) AY3(-1.286,21.342) AY4(-2.04,21.357) AY5(-2.649,21.003) AY8(-4.328,21.003) AY12(-6.749,21.003) AY16(-9.17,21.003) AY21(-11.59,21.003) AY26(-14.05,21.003) AY27(-14.713,21.328) AY29(-15.94,21.328) AY30(-16.603,21.003) AY34(-19.031,21.003) AY35(-19.694,21.328) AY37(-20.921,21.328) AY38(-21.584,21.003) AY43(-23.986,21.003) AY44(-24.649,21.328) AY46(-25.876,21.328) AY47(-26.477,21.003) AY51(-28.862,21.003) AY52(-29.463,21.328) AY54(-30.69,21.328) AY55(-31.352,21.003) AY60(-33.755,21.003) AY61(-34.418,21.328) AY63(-35.645,21.328) AY64(-36.308,21.003) AY66(-37.535,21.003) AY68(-38.85,21.581) B5(-2.266,0.65) B6(-2.847,0.975) B10(-5.325,0.975) B14(-7.803,0.975) B18(-10.281,0.975) B22(-12.759,0.975) B26(-15.237,0.975) B30(-17.715,0.975) B34(-20.194,0.975) B39(-22.672,0.975) B44(-25.15,0.975) B48(-27.628,0.975) B53(-30.106,0.975) B58(-32.584,0.975) B62(-35.062,0.975) B66(-37.54,0.975) B69(-39.349,0.63) BA3(-1.279,21.999) BA5(-2.599,21.94) BA8(-4.328,21.653) BA12(-6.749,21.653) BA16(-9.17,21.653) BA21(-11.59,21.653) BA23(-12.849,21.572) BA28(-15.326,21.572) BA32(-17.83,21.572) BA36(-20.307,21.572) BA41(-22.785,21.572) BA45(-25.263,21.572) BA49(-27.669,21.653) BA53(-30.076,21.572) BA57(-32.554,21.572) BA62(-35.032,21.572) BA68(-39.349,21.999) BB4(-1.763,22.628) BB68(-38.866,22.628) C4(-1.699,0.978) C5(-2.266,1.3) C7(-3.523,1.3) C8(-4.086,0.975) C9(-4.65,1.3) C11(-6.001,1.3) C12(-6.564,0.975) C13(-7.128,1.3) C15(-8.479,1.3) C16(-9.042,0.975) C17(-9.606,1.3) C19(-10.957,1.3) C20(-11.52,0.975) C21(-12.084,1.3) C23(-13.435,1.3) C24(-13.998,0.975) C25(-14.562,1.3) C27(-15.913,1.3) C28(-16.476,0.975) C29(-17.04,1.3) C31(-18.391,1.3) C32(-18.954,0.975) C33(-19.518,1.3) C36(-20.869,1.3) C37(-21.433,0.975) C38(-21.996,1.3) C40(-23.347,1.3) C41(-23.911,0.975) C42(-24.474,1.3) C45(-25.825,1.3) C46(-26.389,0.975) C47(-26.952,1.3) C50(-28.303,1.3) C51(-28.867,0.975) C52(-29.43,1.3) C54(-30.781,1.3) C55(-31.345,0.975) C56(-31.908,1.3) C59(-33.259,1.3) C60(-33.823,0.975) C61(-34.386,1.3) C63(-35.737,1.3) C64(-36.301,0.975) C65(-36.864,1.3) C67(-38.799,1.015) C68(-38.936,1.693) C70(-39.999,1.28) D3(-0.975,1.706) D4(-1.624,1.646) D5(-2.224,1.951) D6(-2.873,1.991) D7(-3.523,1.951) D8(-4.086,1.626) D9(-4.65,1.951) D10(-5.325,1.991) D11(-6.001,1.951) D12(-6.564,1.626) D13(-7.128,1.951) D14(-7.803,1.991) D15(-8.479,1.951) D16(-9.042,1.626) D17(-9.606,1.951) D18(-10.281,1.991) D19(-10.957,1.951) D20(-11.52,1.626) D21(-12.084,1.951) D22(-12.759,1.991) D23(-13.435,1.951) D24(-13.998,1.626) D25(-14.562,1.951) D26(-15.237,1.991) D27(-15.913,1.951) D28(-16.476,1.626) D29(-17.04,1.951) D30(-17.715,1.991) D31(-18.391,1.951) D32(-18.954,1.626) D33(-19.518,1.951) D34(-20.194,1.991) D36(-20.869,1.951) D37(-21.433,1.626) D38(-21.996,1.951) D39(-22.672,1.991) D40(-23.347,1.951) D41(-23.911,1.626) D42(-24.474,1.951) D44(-25.15,1.991) D45(-25.825,1.951) D46(-26.389,1.626) D47(-26.952,1.951) D48(-27.628,1.991) D50(-28.303,1.951) D51(-28.867,1.626) D52(-29.43,1.951) D53(-30.106,1.991) D54(-30.781,1.951) D55(-31.345,1.626) D56(-31.908,1.951) D58(-32.584,1.991) D59(-33.259,1.951) D60(-33.823,1.626) D61(-34.386,1.951) D62(-35.062,1.991) D63(-35.737,1.951) D64(-36.301,1.626) D65(-36.864,1.951) D66(-37.54,1.991) D67(-38.213,1.3) D68(-39.582,1.779) D69(-38.876,2.343) D71(-40.629,1.763) E1(0,2.274) E2(-0.65,2.274) E3(-1.3,2.274) E5(-2.66,2.723) E6(-3.575,2.723) E8(-4.489,2.723) E10(-5.403,2.723) E11(-6.318,2.723) E13(-7.232,2.723) E15(-8.147,2.723) E16(-9.061,2.723) E18(-9.975,2.723) E20(-10.89,2.723) E21(-11.804,2.723) E22(-12.719,2.723) E23(-13.633,2.723) E25(-14.547,2.723) E27(-15.462,2.723) E28(-16.376,2.723) E30(-17.291,2.723) E32(-18.205,2.723) E33(-19.119,2.723) E35(-20.034,2.723) E37(-20.948,2.723) E38(-21.863,2.723) E40(-22.777,2.723) E42(-23.691,2.723) E43(-24.606,2.723) E45(-25.52,2.723) E46(-26.435,2.723) E48(-27.349,2.723) E50(-28.263,2.723) E52(-29.178,2.723) E53(-30.092,2.723) E55(-31.007,2.723) E56(-31.921,2.723) E58(-32.835,2.723) E60(-33.75,2.723) E61(-34.664,2.723) E63(-35.629,2.659) E65(-36.645,2.659) E66(-37.661,2.659) E68(-38.213,1.951) F2(-0.975,2.848) F4(-1.951,2.848) F5(-2.66,3.373) F6(-3.575,3.373) F8(-4.489,3.373) F10(-5.403,3.373) F11(-6.318,3.373) F13(-7.232,3.373) F15(-8.147,3.373) F16(-9.061,3.373) F18(-9.975,3.373) F20(-10.89,3.373) F21(-11.804,3.373) F22(-12.719,3.373) F23(-13.633,3.373) F25(-14.547,3.373) F27(-15.462,3.373) F28(-16.376,3.373) F30(-17.291,3.373) F32(-18.205,3.373) F33(-19.119,3.373) F35(-20.034,3.373) F37(-20.948,3.373) F38(-21.863,3.373) F40(-22.777,3.373) F42(-23.691,3.373) F43(-24.606,3.373) F45(-25.52,3.373) F46(-26.435,3.373) F48(-27.349,3.373) F50(-28.263,3.373) F52(-29.178,3.373) F53(-30.092,3.373) F55(-31.007,3.373) F56(-31.921,3.373) F58(-32.835,3.373) F60(-33.75,3.373) F61(-34.664,3.373) F63(-35.629,3.31) F65(-36.645,3.31) F66(-37.661,3.31) F68(-38.876,2.994) G4(-1.951,3.511) G5(-2.66,4.023) G6(-3.575,4.023) G8(-4.489,4.023) G10(-5.403,4.023) G11(-6.318,4.023) G13(-7.232,4.023) G15(-8.147,4.023) G16(-9.061,4.023) G18(-9.975,4.023) G20(-10.89,4.023) G21(-11.804,4.023) G22(-12.719,4.023) G23(-13.633,4.023) G25(-14.547,4.023) G27(-15.462,4.023) G28(-16.376,4.023) G30(-17.291,4.023) G32(-18.205,4.023) G33(-19.119,4.023) G35(-20.034,4.023) G37(-20.948,4.023) G38(-21.863,4.023) G40(-22.777,4.023) G42(-23.691,4.023) G43(-24.606,4.023) G45(-25.52,4.023) G46(-26.435,4.023) G48(-27.349,4.023) G50(-28.263,4.023) G52(-29.178,4.023) G53(-30.092,4.023) G55(-31.007,4.023) G56(-31.921,4.023) G58(-32.835,4.023) G60(-33.75,4.023) G61(-34.664,4.023) G63(-35.629,3.96) G65(-36.645,3.96) G66(-37.661,3.96) G68(-38.678,3.655) G69(-39.328,3.655) H3(-1.626,4.174) H5(-2.66,4.674) H6(-3.575,4.674) H8(-4.489,4.674) H10(-5.403,4.674) H11(-6.318,4.674) H13(-7.232,4.674) H15(-8.147,4.674) H16(-9.061,4.674) H18(-9.975,4.674) H20(-10.89,4.674) H21(-11.804,4.674) H63(-35.629,4.61) H65(-36.645,4.61) H66(-37.661,4.61) H69(-39.003,4.218) J4(-1.951,4.837) J5(-2.66,5.324) J6(-3.575,5.324) J8(-4.489,5.324) J10(-5.403,5.324) J11(-6.318,5.324) J13(-7.232,5.324) J22(-13.176,4.488) J23(-14.09,4.488) J25(-15.005,4.488) J27(-15.919,4.488) J28(-16.833,4.488) J30(-17.748,4.488) J32(-18.662,4.488) J33(-19.577,4.488) J35(-20.491,4.488) J37(-21.405,4.488) J38(-22.32,4.488) J40(-23.234,4.488) J42(-24.149,4.488) J43(-25.063,4.488) J45(-25.977,4.488) J46(-26.892,4.488) J48(-27.806,4.488) J50(-28.721,4.488) J52(-29.635,4.488) J53(-30.549,4.488) J55(-31.464,4.488) J56(-32.378,4.488) J58(-33.293,4.488) J60(-34.207,4.488) J68(-38.676,4.794) K15(-8.126,5.438) K16(-8.776,5.438) K17(-9.426,5.438) K18(-10.077,5.438) K19(-10.727,5.438) K20(-11.377,5.438) K21(-12.027,5.438) K22(-12.719,4.952) K23(-13.633,4.952) K25(-14.547,4.952) K27(-15.462,4.952) K28(-16.376,4.952) K30(-17.291,4.952) K32(-18.205,4.952) K33(-19.119,4.952) K35(-20.034,4.952) K37(-20.948,4.952) K38(-21.863,4.952) K40(-22.777,4.952) K42(-23.691,4.952) K43(-24.606,4.952) K45(-25.52,4.952) K46(-26.435,4.952) K48(-27.349,4.952) K50(-28.263,4.952) K52(-29.178,4.952) K53(-30.092,4.952) K55(-31.007,4.952) K56(-31.921,4.952) K58(-32.835,4.952) K60(-33.75,4.952) K61(-34.664,4.952) K63(-35.447,5.26) K64(-36.097,5.26) K65(-36.747,5.26) K66(-37.398,5.26) K67(-38.048,5.26) K68(-38.666,5.468) K70(-39.653,5.57) L2(-0.975,5.5) L4(-1.951,5.5) L6(-2.729,5.974) L7(-3.379,5.974) L8(-4.029,5.974) L9(-4.679,5.974) L10(-5.33,5.974) L11(-5.98,5.974) L12(-6.63,5.974) L13(-7.28,5.974) L15(-8.126,6.276) L16(-8.776,6.276) L17(-9.426,6.276) L18(-10.077,6.276) L19(-10.727,6.276) L20(-11.377,6.276) L21(-12.027,6.276) L62(-34.958,5.689) L63(-35.427,6.147) L64(-36.077,6.147) L65(-36.727,6.147) L66(-37.377,6.147) L67(-38.028,6.147) L68(-38.678,6.147) L69(-39.328,6.147) L70(-39.978,6.147) L71(-40.629,6.147) M4(-1.951,6.163) M62(-34.958,6.604) N3(-1.626,6.826) N6(-2.729,6.914) N7(-3.379,6.914) N8(-4.029,6.914) N9(-4.679,6.914) N10(-5.33,6.914) N11(-5.98,6.914) N12(-6.63,6.914) N13(-7.28,6.914) N15(-8.126,7.114) N16(-8.776,7.114) N17(-9.426,7.114) N18(-10.077,7.114) N19(-10.727,7.114) N20(-11.377,7.114) N21(-12.027,7.114) N63(-35.427,7.061) N64(-36.077,7.061) N65(-36.727,7.061) N66(-37.377,7.061) N67(-38.028,7.061) N68(-38.678,7.061) N69(-39.328,7.061) N70(-39.978,7.061) N71(-40.629,7.061) P4(-1.951,7.489) P15(-8.126,7.952) P16(-8.776,7.952) P17(-9.426,7.952) P18(-10.077,7.952) P19(-10.727,7.952) P20(-11.377,7.952) P21(-12.027,7.952) P62(-34.958,7.518) R6(-2.729,7.981) R7(-3.379,7.981) R8(-4.029,7.981) R9(-4.679,7.981) R10(-5.33,7.981) R11(-5.98,7.981) R12(-6.63,7.981) R13(-7.28,7.981) R63(-35.427,7.975) R64(-36.077,7.975) R65(-36.727,7.975) R66(-37.377,7.975) R67(-38.028,7.975) R68(-38.678,7.975) R69(-39.328,7.975) R70(-39.978,7.975) R71(-40.629,7.975) T2(-0.975,8.152) T4(-1.951,8.152) T15(-8.126,8.791) T16(-8.776,8.791) T17(-9.426,8.791) T18(-10.077,8.791) T19(-10.727,8.791) T20(-11.377,8.791) T21(-12.027,8.791) T62(-34.958,8.433) U4(-1.951,8.815) U6(-2.729,9.047) U7(-3.379,9.047) U8(-4.029,9.047) U9(-4.679,9.047) U10(-5.33,9.047) U11(-5.98,9.047) U12(-6.63,9.047) U13(-7.28,9.047) U63(-35.427,8.89) U64(-36.077,8.89) U65(-36.727,8.89) U66(-37.377,8.89) U67(-38.028,8.89) U68(-38.678,8.89) U69(-39.328,8.89) U70(-39.978,8.89) U71(-40.629,8.89) V3(-1.626,9.478) V15(-8.126,9.629) V16(-8.776,9.629) V17(-9.426,9.629) V18(-10.077,9.629) V19(-10.727,9.629) V20(-11.377,9.629) V21(-12.027,9.629) V62(-34.958,9.347) W4(-1.951,10.141) W6(-2.729,10.114) W7(-3.379,10.114) W8(-4.029,10.114) W9(-4.679,10.114) W10(-5.33,10.114) W11(-5.98,10.114) W12(-6.63,10.114) W13(-7.28,10.114) W63(-35.427,9.804) W64(-36.077,9.804) W65(-36.727,9.804) W66(-37.377,9.804) W67(-38.028,9.804) W68(-38.678,9.804) W69(-39.328,9.804) W70(-39.978,9.804) W71(-40.629,9.804) Y15(-8.126,10.467) Y16(-8.776,10.467) Y17(-9.426,10.467) Y18(-10.077,10.467) Y19(-10.727,10.467) Y20(-11.377,10.467) Y21(-12.027,10.467) Y62(-34.958,10.261)
  oval 0.254x0.343 smd: A6(-2.847,0.325) A7(-3.523,0) A9(-4.65,0) A10(-5.325,0.325) A11(-6.001,0) A13(-7.128,0) A14(-7.803,0.325) A15(-8.479,0) A17(-9.606,0) A18(-10.281,0.325) A19(-10.957,0) A21(-12.084,0) A22(-12.759,0.325) A23(-13.435,0) A25(-14.562,0) A26(-15.237,0.325) A27(-15.913,0) A29(-17.04,0) A30(-17.715,0.325) A31(-18.391,0) A33(-19.518,0) A34(-20.194,0.325) A36(-20.869,0) A38(-21.996,0) A39(-22.672,0.325) A40(-23.347,0) A42(-24.474,0) A44(-25.15,0.325) A45(-25.825,0) A47(-26.952,0) A48(-27.628,0.325) A50(-28.303,0) A52(-29.43,0) A53(-30.106,0.325) A54(-30.781,0) A56(-31.908,0) A58(-32.584,0.325) A59(-33.259,0) A61(-34.386,0) A62(-35.062,0.325) A63(-35.737,0) A65(-36.864,0) A66(-37.54,0.325) A67(-38.215,0) AY7(-3.763,21.328) AY9(-4.898,21.328) AY11(-6.184,21.328) AY13(-7.319,21.328) AY15(-8.604,21.328) AY17(-9.74,21.328) AY20(-11.025,21.328) AY22(-12.16,21.328) AY25(-13.486,21.328) AY31(-17.167,21.328) AY33(-18.467,21.328) AY39(-22.148,21.328) AY42(-23.423,21.328) AY48(-27.103,21.328) AY50(-28.236,21.328) AY56(-31.916,21.328) AY59(-33.191,21.328) AY65(-36.872,21.328) AY67(-38.216,21.328) B7(-3.523,0.65) B9(-4.65,0.65) B11(-6.001,0.65) B13(-7.128,0.65) B15(-8.479,0.65) B17(-9.606,0.65) B19(-10.957,0.65) B21(-12.084,0.65) B23(-13.435,0.65) B25(-14.562,0.65) B27(-15.913,0.65) B29(-17.04,0.65) B31(-18.391,0.65) B33(-19.518,0.65) B36(-20.869,0.65) B38(-21.996,0.65) B40(-23.347,0.65) B42(-24.474,0.65) B45(-25.825,0.65) B47(-26.952,0.65) B50(-28.303,0.65) B52(-29.43,0.65) B54(-30.781,0.65) B56(-31.908,0.65) B59(-33.259,0.65) B61(-34.386,0.65) B63(-35.737,0.65) B65(-36.864,0.65) B67(-38.215,0.65) BA4(-1.948,22.004) BA6(-3.141,21.572) BA7(-3.705,21.978) BA9(-4.898,21.978) BA10(-5.561,21.572) BA11(-6.125,21.978) BA13(-7.319,21.978) BA14(-7.982,21.572) BA15(-8.546,21.978) BA17(-9.74,21.978) BA18(-10.403,21.572) BA20(-10.966,21.978) BA22(-12.16,21.978) BA25(-13.486,21.978) BA26(-14.149,21.653) BA27(-14.812,21.978) BA29(-15.841,21.978) BA30(-16.504,21.653) BA31(-17.167,21.978) BA33(-18.467,21.978) BA34(-19.13,21.653) BA35(-19.793,21.978) BA37(-20.822,21.978) BA38(-21.485,21.653) BA39(-22.148,21.978) BA42(-23.423,21.978) BA43(-24.086,21.653) BA44(-24.748,21.978) BA46(-25.777,21.978) BA47(-26.44,21.653) BA48(-27.103,21.978) BA50(-28.236,21.978) BA51(-28.899,21.653) BA52(-29.562,21.978) BA54(-30.59,21.978) BA55(-31.253,21.653) BA56(-31.916,21.978) BA59(-33.191,21.978) BA60(-33.854,21.653) BA61(-34.517,21.978) BA63(-35.546,21.978) BA64(-36.209,21.653) BA65(-36.872,21.978) BA66(-37.535,21.653) BA67(-38.216,21.978) BB5(-2.529,22.628) BB6(-3.141,22.303) BB7(-3.705,22.628) BB9(-4.898,22.628) BB10(-5.561,22.303) BB11(-6.125,22.628) BB13(-7.319,22.628) BB14(-7.982,22.303) BB15(-8.546,22.628) BB17(-9.74,22.628) BB18(-10.403,22.303) BB20(-10.966,22.628) BB22(-12.16,22.628) BB23(-12.849,22.222) BB25(-13.486,22.628) BB26(-14.149,22.303) BB27(-14.812,22.628) BB29(-15.841,22.628) BB30(-16.504,22.303) BB31(-17.167,22.628) BB32(-17.83,22.222) BB33(-18.467,22.628) BB34(-19.13,22.303) BB35(-19.793,22.628) BB37(-20.822,22.628) BB38(-21.485,22.303) BB39(-22.148,22.628) BB41(-22.785,22.222) BB42(-23.423,22.628) BB43(-24.086,22.303) BB44(-24.748,22.628) BB46(-25.777,22.628) BB47(-26.44,22.303) BB48(-27.103,22.628) BB50(-28.236,22.628) BB51(-28.899,22.303) BB52(-29.562,22.628) BB54(-30.59,22.628) BB55(-31.253,22.303) BB56(-31.916,22.628) BB57(-32.554,22.222) BB59(-33.191,22.628) BB60(-33.854,22.303) BB61(-34.517,22.628) BB63(-35.546,22.628) BB64(-36.209,22.303) BB65(-36.872,22.628) BB66(-37.535,22.303) BB67(-38.216,22.628)
  oval 0.343x0.254 smd: AA1(-0.325,10.804) AB1(0,11.467) AB2(-0.65,11.467) AB3(-1.3,11.467) AC1(-0.325,12.13) AC2(-0.975,12.13) AD1(0,12.792) AD2(-0.65,12.792) AD3(-1.3,12.792) AF1(-0.325,13.455) AF70(-39.978,13.154) AF71(-40.629,13.154) AG1(0,14.118) AG2(-0.65,14.118) AG3(-1.3,14.118) AG70(-39.653,13.817) AG71(-40.303,13.817) AH1(-0.325,14.781) AH2(-0.975,14.781) AH68(-38.678,14.48) AH69(-39.328,14.48) AH70(-39.978,14.48) AH71(-40.629,14.48) AJ1(0,15.444) AJ2(-0.65,15.444) AJ3(-1.3,15.444) AK70(-40.303,15.143) AL1(-0.325,16.107) AL68(-38.678,15.806) AL69(-39.328,15.806) AL70(-39.978,15.806) AL71(-40.629,15.806) AM1(0,16.77) AM2(-0.65,16.77) AM3(-1.3,16.77) AM70(-39.653,16.469) AM71(-40.303,16.469) AN1(-0.325,17.433) AN2(-0.975,17.433) AN70(-39.978,17.132) AN71(-40.629,17.132) AP1(0,18.096) AP2(-0.65,18.096) AP3(-1.3,18.096) AR70(-39.978,18.16) AR71(-40.629,18.16) AT1(-0.325,18.759) AT70(-39.653,18.823) AT71(-40.303,18.823) AU1(0,19.422) AU2(-0.65,19.422) AU3(-1.3,19.422) AU68(-38.678,19.461) AU69(-39.328,19.486) AU70(-39.978,19.486) AU71(-40.629,19.486) AV1(0,20.142) AV2(-0.95,20.113) AV71(-40.629,20.215) AW2(-0.625,20.677) AW3(-1.275,20.677) E70(-39.978,2.305) E71(-40.629,2.413) F1(-0.325,2.848) F70(-39.526,2.994) F71(-40.176,2.931) G1(0,3.511) G2(-0.65,3.511) G3(-1.3,3.511) G70(-39.978,3.555) G71(-40.629,3.555) H1(-0.325,4.174) H2(-0.975,4.174) H70(-39.653,4.218) H71(-40.303,4.218) J1(0,4.837) J2(-0.65,4.837) J3(-1.3,4.837) J69(-39.328,4.881) J70(-39.978,4.881) J71(-40.629,4.881) K71(-40.303,5.57) L1(-0.325,5.5) M1(0,6.163) M2(-0.65,6.163) M3(-1.3,6.163) N1(-0.325,6.826) N2(-0.975,6.826) P1(0,7.489) P2(-0.65,7.489) P3(-1.3,7.489) T1(-0.325,8.152) U1(0,8.815) U2(-0.65,8.815) U3(-1.3,8.815) V1(-0.325,9.478) V2(-0.975,9.478) W1(0,10.141) W2(-0.65,10.141) W3(-1.3,10.141)
SN65LVPE502CPRGER_VQFN24_4X4
  oval 0.254x1.041 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 13(2.5,3.95) 14(2,3.95) 15(1.5,3.95) 16(1,3.95) 17(0.5,3.95) 18(0,3.95)
  oval 1.041x0.254 smd: 7(3.225,0.725) 8(3.225,1.225) 9(3.225,1.725) 10(3.225,2.225) 11(3.225,2.725) 12(3.225,3.225) 19(-0.725,3.225) 20(-0.725,2.725) 21(-0.725,2.225) 22(-0.725,1.725) 23(-0.725,1.225) 24(-0.725,0.725)
  rect 2.108x2.108 smd: 25(1.25,1.975)
SN74LVC1G06DCKR_SC70-5
  oval 0.381x0.864 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.74) 5(0,1.74)
STARC_107K40-000001-G2_40P
  round 1.092 hole 1.092 unplated: (-2.3,-1.95) (21.8,-1.95)
  oval 0.254x1.295 smd: 1(0,0) 2(0.5,0) 3(1,0) 4(1.5,0) 5(2,0) 6(2.5,0) 7(3,0) 8(3.5,0) 9(4,0) 10(4.5,0) 11(5,0) 12(5.5,0) 13(6,0) 14(6.5,0) 15(7,0) 16(7.5,0) 17(8,0) 18(8.5,0) 19(9,0) 20(9.5,0) 21(10,0) 22(10.5,0) 23(11,0) 24(11.5,0) 25(12,0) 26(12.5,0) 27(13,0) 28(13.5,0) 29(14,0) 30(14.5,0) 31(15,0) 32(15.5,0) 33(16,0) 34(16.5,0) 35(17,0) 36(17.5,0) 37(18,0) 38(18.5,0) 39(19,0) 40(19.5,0)
  rect 1.549x3.404 smd: 41(-4.125,-5.85) 42(23.625,-5.85)
  rect 2.007x6.198 smd: 43(0.5,-7.65) 44(6,-7.65) 45(13.5,-7.65) 46(19,-7.65)
STARC_111D10-000000-G4-R_10P
  oval 0.203x1.194 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.8,0) 9(3.2,0) 10(3.6,0)
  rect 1.397x2.007 smd: 11(-2.5,-1.37) 12(6.1,-1.37)
SW_SMT1-05-A_4P
  rect 0.61x0.991 smd: 1(0,0) 2(0,-4.4) 3(3.7,0) 4(3.7,-4.4)
  rect 0.457x0.991 smd: 5(-0.675,-2.2) 6(4.375,-2.2)
SY6288C20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY6288D20AAC_SOT23-5
  oval 0.559x0.787 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0,2.4)
SY8032ABC_SOT23-6
  oval 0.61x0.991 smd: 1(0,0) 2(0.95,0) 3(1.9,0) 4(1.9,2.4) 5(0.95,2.4) 6(0,2.4)
SY8286BRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SY8286CRAC_QFN20_3X3
  oval 0.889x0.254 smd: 1(0,0) 2(0,-0.45) 3(0,-0.9) 4(0,-1.35) 5(0,-1.8) 11(3.1,-1.8) 12(3.1,-1.35) 13(3.1,-0.9) 14(3.1,-0.45) 15(3.1,0)
  oval 0.254x0.889 smd: 6(0.65,-2.45) 7(1.1,-2.45) 8(1.55,-2.45) 9(2,-2.45) 10(2.45,-2.45) 16(2.45,0.65) 17(2,0.65) 18(1.55,0.65) 19(1.1,0.65) 20(0.65,0.65)
  rect 0.991x0.991 smd: 21(1.55,-0.9)
SYX196DQNC_QFN10_3X3
  oval 0.254x0.61 smd: 1(0,0) 2(0.45,0) 3(0.9,0) 4(1.35,0) 5(1.8,0) 6(2.25,0)
  rect 1.118x0.229 smd: 7(2.215,-0.662)
  rect 0.864x2.007 smd: 8(2.09,-2)
  custom 0.47x0.47 smd: 9(1.077,-1.775)
  rect 0.787x1.143 smd: 10(0.113,-1.6)
TAI-T_HCB2012KF-121T50_2P-NPM
  rect 0.991x0.991 smd: 1(0,0) 2(2,0)
TAITW_PUBAU6-09FLBS1NN4H0_9P
  round 1.295 hole 0.711: 1(0,0) 2(-2.5,0) 3(-4.5,0) 4(-7,0) 5(-7.5,-1.5) 6(-5.5,-1.5) 7(-3.5,-1.5) 8(-1.5,-1.5) 9(0.5,-1.5)
  oval 1.397x3.2 hole 0.787x2.591: 10(4.35,-2.38) 12(-11.35,-2.38)
  oval 1.397x2.388 hole 0.787x1.803: 11(4.35,-9.48) 13(-11.35,-9.48)
TAIYO_FBMJ4516HS720NT_2P-NPM
  rect 1.549x1.854 smd: 1(0,0) 2(3.95,0)
TC7SH08FU_SSOP5
  oval 0.406x0.787 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.9) 5(0,1.9)
TC7SH08FUF_SSOP5
  oval 0.457x0.711 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.3,1.875) 5(0,1.875)
TDK_MPZ1608S300AT_2P
  rect 0.61x0.787 smd: 1(0,0) 2(1.4,0)
TPC12
  round 0.305 smd: 1(0,0)
TPS22961DNYR_WSON8
  oval 0.305x0.508 smd: 1(0,0) 2(0.65,0) 3(1.3,0) 4(1.95,0) 5(1.95,2.7)
  oval 1.6x0.508 smd: 6(0.65,2.7)
  rect 2.388x1.6 smd: 7(0.975,1.35)
TPS22966DPUR_SON14_2X3
  oval 0.203x0.762 smd: 1(0,0) 2(0.4,0) 3(0.8,0) 4(1.2,0) 5(1.6,0) 6(2,0) 7(2.4,0) 8(2.4,2.05) 9(2,2.05) 10(1.6,2.05) 11(1.2,2.05) 12(0.8,2.05) 13(0.4,2.05) 14(0,2.05)
  rect 2.489x0.889 smd: 15(1.2,1.025)
TVNST52302AB0_SOT523-3
  oval 0.508x0.559 smd: 1(0,0) 2(-0.5,-1.4) 3(0.5,-1.4)
W25R128FVSIQ_SO8
  oval 0.635x1.676 smd: 1(0,0) 2(1.27,0) 3(2.54,0) 4(3.81,0) 5(3.81,7.25) 6(2.54,7.25) 7(1.27,7.25) 8(0,7.25)
Y_7V24000020_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_7V27000050_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.7) 4(0,1.7)
Y_9H03200031_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)
Y_FSX3M-25PM20FDO_4P
  rect 1.397x1.194 smd: 1(0,0) 2(2.2,0) 3(2.2,1.6) 4(0,1.6)
Y_Q13FC135000040_2P
  rect 0.991x1.803 smd: 1(0,0) 2(2.5,0)

## Nets
0.675V_DDR_VTT_ON: PR202.1 RC123.2 RC129.2 UC7.4
1.35V_PWR_EN: QV5.2 RV201.2 UV23.4
1.35V_VTT_PWRGD: PR209.2 PU200.10 RC392.1
1VS_VCCIO_PWRGD: RC389.1
3V_FB: PC113.1 PR109.2 PR110.1 PU100.13
3V_PRIM_OC: RC166.1 UC8.3
3V_SN: PC112.1 PR106.2
3V_VIN: PC100.1 PC103.1 PC104.1 PC105.1 PJP105.2 PL102.2 PU100.2 PU100.3 PU100.4 PU100.5
3VS: J511.2 U2301.8 U2301.9
3VS_GATE: C2322.1 R2318.2 U2301.5
5V_FB: PC127.1 PR115.2 PR118.1 PU102.13
5V_SN: PC125.1 PR112.2
5V_VIN: PC115.1 PC116.1 PC117.1 PC118.1 PJP106.2 PL103.2 PU102.2 PU102.3 PU102.4 PU102.5
5VS: J510.2 U2301.13 U2301.14
5VS_GATE: C2309.1 R2313.2 U2301.3
+0.675V_A_VREFDQ: CD21.1 RD10.2 UC1.AY68
+0.675V_B_VREFDQ: CD31.1 RD14.2 UC1.BA67
+0.675V_DDR_VREFCA: RD8.2 RD17.2 RD18.2 RD19.1 RD20.1
+0.675V_DDRA_VREFCA: CD17.1 CD18.1 JDIMM1.126 RD8.1
+0.675V_DDRA_VREFDQ: CD1.1 CD2.1 JDIMM1.1 RD9.2 RD10.1 RD11.1
+0.675V_DDRB_VREFCA: CD47.1 CD48.1 JDIMM2.126 RD17.1
+0.675V_DDRB_VREFDQ: CD28.1 CD29.1 JDIMM2.1 RD13.2 RD14.1 RD15.1
+0.675V_VREFCA: CD49.1 RD19.2 UC1.AY67
+0.675VS_VREF_CA0: CV70.1 RV107.1 RV108.2 UV4.M8 UV5.M8 UV8.M8 UV9.M8
+0.675VS_VREF_CA1: CV105.1 RV94.1 RV100.2 UV6.M8 UV7.M8 UV14.M8 UV15.M8
+0.675VS_VREF_DQ0: CV71.1 RV113.1 RV115.2 UV4.H1 UV5.H1 UV8.H1 UV9.H1
+0.675VS_VREF_DQ1: CV106.1 RV95.2 RV96.1 UV6.H1 UV7.H1 UV14.H1 UV15.H1
+0.675VS_VTT: CD22.1 CD23.1 CD24.1 CD25.1 CD50.1 CD51.1 CD52.1 CD53.1 JDIMM1.203 JDIMM1.204 JDIMM2.203 JDIMM2.204 PJP203.1
+0.675VSP: PC205.1 PC211.1 PJP203.2 PU200.2 PU200.20
+1.0V_APLL: CC64.1 CC123.1 CC124.1 RC148.2 UC1.L21 UC1.V15
+1.0V_CLK4_F100OC: CC127.1 CC128.1 RC190.2 UC1.N20
+1.0V_CLK5: CC129.1 CC130.1 RC96.2 RC152.2 UC1.L19
+1.0V_CLK6_24TBT: CC75.1 CC86.1 CC125.1 CC126.1 RC169.2 UC1.A10 UC1.A14 UC1.K19
+1.0V_DTS: RC162.2 UC1.T1
+1.0V_MPHYJP: JP19.1 UC4.6
+1.0V_MPHYPLL: CC58.1 CC61.1 CC68.1 CC80.1 CC81.1 CC82.1 CC118.1 CC119.1 CC122.1 JP17.2 JP19.2 UC1.AF20 UC1.AF21 UC1.K15 UC1.L15 UC1.N15 UC1.N16 UC1.N17 UC1.N18 UC1.P15 UC1.P16 UC1.T19 UC1.T20
+1.0V_PRIM: CC59.1 CC76.1 CC87.1 CC91.1 CC97.1 CC111.1 CC112.1 CE75.1 JP14.2 JP17.1 PJP302.2 RC12.1 RC148.1 RC152.1 RC162.1 RC169.1 RC190.1 RV209.1 UC1.AB17 UC1.AB19 UC1.AB20 UC1.AF18 UC1.AF19 UC1.AK20 UC1.K17 UC1.L1 UC1.P18 UC1.V20 UC1.V21 UC1.Y18 UC4.1 UC4.2 UC4.7 UC5.1 UC5.2 UE5.95
+1.0V_PRIM_D: RV209.2 UV10.6 UV10.7
+1.0V_PRIM_JP: CC117.1 JP14.1 UC6.1 UC6.2 UC6.7
+1.0V_VCCSFR: CC55.1 RC143.2 UC1.K20 UC1.K21
