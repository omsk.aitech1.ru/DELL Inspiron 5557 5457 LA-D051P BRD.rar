# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
GNDA: length 53.3
  TOP w0.102: v2(204.53,24.18) v3(203.97,24.18)
  TOP w0.508: v2(201.4,22.93) 201.43,22.95 RA31.1 ; RA29.1 196.44,35.03 v2(197.36,34.1) ; v2(188.21,25.01) 187.9,25.32 RA30.1 ; v2(188.59,23.04) RA32.1
  GND1 w0.254: 205.84,36.24 JHP.7 ; JHP.7 206.98,37.58 ; JHP.7 206.98,36.24 ; JHP.7 204.71,37.58 ; JHP.7 206.98,36.91 ; JHP.7 204.71,36.24 ; JHP.7 204.71,36.91 ; JHP.7 205.84,37.58 ; 204.49,26.69 JHP.6 ; JHP.6 203.36,26.69 ; JHP.6 205.63,26.69 ; JHP.6 205.63,27.36 ; JHP.6 203.36,27.36
  VCC w0.254: JHP.7 205.84,37.58 ; JHP.7 206.98,37.58 ; JHP.7 204.71,37.58 ; 204.49,26.69 JHP.6 ; JHP.6 203.36,26.69 ; JHP.6 205.63,26.69
  GND2 w0.254: 204.49,26.69 JHP.6 ; JHP.6 205.63,27.36 ; JHP.6 203.36,26.69 ; JHP.6 203.36,27.36 ; JHP.6 205.63,26.69 ; 204.71,36.91 JHP.7 ; JHP.7 205.84,36.24 ; JHP.7 206.98,37.58 ; JHP.7 205.84,37.58 ; JHP.7 204.71,36.24 ; JHP.7 206.98,36.91 ; JHP.7 204.71,37.58 ; JHP.7 206.98,36.24
  BOTTOM w0.203: UA1.38 200.01,21.29 200.01,21.28 200.02,21.29 200.1,21.29 201.4,22.58 v2(201.4,22.93)
  BOTTOM w0.381: v2(191.57,33.96) 191.62,33.91 CA38.2
  BOTTOM w0.508: v2(192.78,30.6) 192.46,30.28 RA83.2 ; CA23.1 v2(196.08,25.65) ; CA63.1 v2(204.53,24.18) ; CA39.2 v2(194.19,29.85) ; v2(189.29,19.79) 189.73,19.79 CA74.2 ; CA40.2 v2(194.19,30.84) ; CA61.2 v2(204.65,22.79) ; RA84.2 v2(193.35,26.22) 193.48,26.34 CA33.2 ; CA62.1 192.27,24.44 v2(192.08,24.63)
  vias: v2(188.78,23.93) v2(189.73,29.26) v2(190,27.3) v3(192.21,26.6) v3(195.19,26.53) v4(193.6,22.91) v4(193.6,22.28)
PVCC_VGA:
  vias: v1(72.83,42.85)
VCC_GT_SENSE: length 46.5
  TOP w0.254: PC620.1 PC618.2 89.99,106.93 v2(90.19,106.93) 90.16,106.9 90.16,106.1 90.96,105.3 94.28,105.3 99.53,110.54 104.55,110.54 106.94,108.15 106.94,103.5 106.23,102.78 106.23,100.91 104.35,99.03 104.35,97.52 104.25,97.41 v2(104.25,96.89)
  BOTTOM w0.076: 110.36,97.32 110.66,97.32 110.81,97.47 111.58,97.47 111.83,97.58 111.83,97.59 111.83,97.59 111.97,97.73 UC1.J70
  BOTTOM w0.254: v2(104.25,96.89) 104.25,97.07 104.58,97.4 105.12,97.4 105.94,96.57 107.19,96.57 RC219.1 108.25,96.88 108.69,97.32 110.36,97.32 ; v2(90.19,106.93) 90.02,106.93 PC617.1 89.33,108.54 PR622.1
VCCEOPIO_SENSE: length 1.3
  TOP w0.076: v2(116.39,86.92) 116.71,86.92 T137.1
  BOTTOM w0.076: UC1.AL63 116.67,86.64 v2(116.39,86.92)
VCCGTX_SENSE: length 2
  TOP w0.076: T155.1 117.63,87.59 v2(117.62,87.59)
  BOTTOM w0.076: UC1.AK62 117.33,87.3 v2(117.62,87.59)
VCCIO_SENSE: length 1.2
  TOP w0.254: T124.1 137.88,85.96 v2(138.01,85.96)
  BOTTOM w0.254: UC1.AM23 138.41,86.35 v2(138.01,85.96)
VCCOPC_SENSE: length 1.4
  TOP w0.076: v2(117.53,91.05) 117.66,90.92 T132.1
  BOTTOM w0.076: UC1.AC63 117.46,90.98 v2(117.53,91.05)
VCCSA_B+:
  vias: v1(148.71,120.9) v2(145.85,119.12) v2(146.49,119.12)
VCCSENSE: length 83.1
  TOP w0.254: v2(133.46,100.12) 133.46,100.11 134.31,100.11 135.02,100.82 135.1,100.82 RC203.1 137.47,103.19 137.47,104.58 139.18,106.28 139.18,113.84 139.44,114.1 139.44,114.77 v2(139.54,114.87) ; PC651.2 84.06,114.5 v2(84.06,116.2)
  IN3 w0.254: v2(84.06,116.2) 84.19,116.07 92,116.07 96.2,120.26 106.29,120.26 107.17,119.37 121.24,119.37 122.32,118.29 138.2,118.29 138.68,117.81 138.68,116.23 139.44,115.47 139.44,114.98 v2(139.54,114.87)
  BOTTOM w0.254: UC1.E32 133.68,99.89 v2(133.46,100.12) ; PC653.1 84.06,116.76 v2(84.06,116.2) PC639.1 84.05,115.53 PR648.1
VCCST_PWRGD: length 8.1
  BOTTOM w0.076: UC1.B65 115.49,102.22 115.49,103.39 114.9,103.99 114.38,103.99 114.11,104.26 113.14,104.26 112.83,104.56 112.83,105.34
  BOTTOM w0.102: 112.83,105.34 112.83,105.68 112.73,105.78 v1(112.45,105.78) 112.19,105.78 112.07,105.9 112.07,106.07 112.19,106.19 112.73,106.19 112.83,106.29 RC116.2
VCCSTG_EN: length 5.3
  TOP w0.102: UC15.4 171.01,48.58 171.39,48.96 RC67.2 RZ75.2 172.26,50.36 DC7.1 v1(171.89,52.04)
VCCSTG_EN_R: length 7.1
  TOP w0.254: UC6.4 168.29,45.54 168.65,45.9 168.65,47.04 168.52,47.17 168.52,48.01 CC101.1 169.16,49.38 v1(169.42,49.65) RC67.1 170.48,50.72 DC7.2
VDD_1.35V: length 1.7
  TOP w0.102: v1(83.05,15.55) 83.05,15.29 83.29,15.05 v2(83.75,15.05)
  TOP w0.254: PR205.1 v2(83.75,15.05)
VDD_CHG: length 21.3
  TOP w0.254: v2(47.43,7.87) 47.43,7.67 47.11,7.36 41.2,7.36 40.68,7.88 PR750.2 PR749.2 40.68,15.41 42.16,16.88 v2(45,16.88)
  BOTTOM w0.102: v2(47.43,7.87) v1(47.43,7.17)
  BOTTOM w0.254: v2(47.43,7.87) 47.43,8.06 47.87,8.5 PR741.1
VDDP_CHG:
  vias: v1(45.59,16.82)
VIN_1.8VALW:
  vias: v1(86.73,24.18)
VSS_GT_SENSE: length 48.3
  TOP w0.254: PC619.2 88.98,110.81 v2(88.98,110.1) 88.98,109.71 PC620.2 89.91,108.78 89.91,108.2 90.67,107.43 90.67,106.24 91.23,105.68 94.13,105.68 99.37,110.93 104.7,110.93 107.33,108.31 107.33,103.34 106.61,102.63 106.61,100.75 104.73,98.87 104.73,97.52 104.83,97.41 v2(104.83,96.89)
  BOTTOM w0.076: 110.17,96.94 110.63,96.94 111,97.3 111.61,97.3 111.85,97.4 112.02,97.47 112.3,97.47 112.57,97.73 UC1.J69
  BOTTOM w0.203: PU602.6 89.16,110.28 v2(88.98,110.1)
  BOTTOM w0.254: v2(104.83,96.89) 105.09,96.89 105.78,96.19 107.19,96.19 107.37,96.02 RC226.1 108.02,96.02 108.94,96.94 110.17,96.94
VSSEOPIO_SENSE: length 1.7
  TOP w0.076: v2(117.6,88.19) 117.6,88.51 T139.1
  BOTTOM w0.076: UC1.AJ62 117.18,87.78 v2(117.6,88.19)
VSSGTX_SENSE: length 2.2
  TOP w0.076: v2(118.81,86.07) 118.81,86.72 T219.1
  BOTTOM w0.076: v2(118.81,86.07) 118.81,86.35 118.33,86.83 UC1.AL61
VSSIO_SENSE: length 2.5
  TOP w0.254: T125.1 138.46,84.35 138.46,85.49 138.9,85.93 v2(138.93,85.93)
  BOTTOM w0.254: v2(138.93,85.93) 139.34,86.35 UC1.AM22
VSSOPC_SENSE: length 1.8
  TOP w0.076: v2(115.75,89.59) 115.69,89.65 T133.1
  BOTTOM w0.076: v2(115.75,89.59) 116.26,89.59 116.67,90 UC1.AE63
VSSSENSE: length 82.2
  TOP w0.254: v2(85.59,114.99) 86.48,114.1 PC654.2 ; v2(133.06,100.5) 133.13,100.58 134.24,100.58 134.57,100.91 134.57,101.26 RC205.1 135.42,101.69 137.09,103.37 137.09,104.73 138.79,106.44 138.79,114 139.06,114.26 139.06,114.77 v2(138.96,114.87)
  IN3 w0.254: v2(85.59,114.99) 86.29,115.69 92.16,115.69 96.35,119.88 106.13,119.88 107.02,118.99 121.08,118.99 122.16,117.91 138.04,117.91 138.3,117.66 138.3,116.07 139.06,115.31 139.06,114.98 v2(138.96,114.87)
  BOTTOM w0.203: PU602.18 85.75,114.84 v2(85.59,114.99)
  BOTTOM w0.254: v2(85.59,114.99) 85.59,116.15 PC653.2 ; v2(133.06,100.5) 132.98,100.43 UC1.E33
3D_CAM_EN: length 218.5
  TOP w0.102: DX7.2 153.73,23.3 v1(154.07,23.64) v2(154.07,24.38) ; RI88.2 20.36,62.17 v2(20.92,61.61) ; DC4.2 150.62,63.54 v2(150.62,63.87)
  TOP w0.254: U2409.3 18.91,62.92 18.73,62.73 RI90.1 ; RI90.1 RI88.2 ; RI90.1 RI54.2
  IN1 w0.102: v2(150.62,63.87) 150.62,63.53 155.09,59.05 155.09,53.49 158.87,49.71 158.87,47.03 159.51,46.39 159.51,45.43 159.19,45.11 159.19,39.04 158.4,38.25 158.4,27.53 157.59,26.72 156.42,26.72 v2(154.07,24.38) 153.84,24.15 150.83,24.15 149.21,25.77 138.81,25.77 137.64,26.95 107.95,26.95 105.4,29.5 105.4,32.5 99.66,38.24 89.63,38.24 89.27,38.6 81.27,38.6 79.66,36.99 55.2,36.99 45.71,46.47 41.86,46.47 32.19,56.15 32.19,63.05 27.23,68 23.41,68 20.5,65.09 20.5,62.03 v2(20.92,61.61)
3D_CAM_EN_EC: length 13.7
  TOP w0.102: DX7.1 148.86,21.68 148.86,21.15 v1(148.59,20.87) 146.69,18.98 146.11,18.98 145.47,18.34 145.47,17.97 144.39,16.89 144.39,15.16 145.41,14.15 UE5.23
3D_CAM_EN_R: length 29.8
  TOP w0.102: DC4.1 151.24,64.32 v2(150.17,64.32)
  IN1 w0.076: v2(148.06,85.23) 147.71,85.23 147.33,85.6 146.15,85.6 145.88,85.34 145.88,81.19 149.93,77.14
  IN1 w0.102: 149.93,77.14 152.14,74.93 152.14,71.66 152.71,71.09 152.71,67.81 150.17,65.27 v2(150.17,64.32)
  BOTTOM w0.076: UC1.AN7 v2(148.06,85.23)
  BOTTOM w0.102: v2(150.17,64.32) v1(149.66,64.32)
+A_VCC: length 5.3
  BOTTOM w0.203: UA1.20 v1(192.4,20.09)
  BOTTOM w0.508: v1(192.4,20.09) 192.37,20.09 191.78,20.68 191.52,20.63 ; 191.52,20.63 189.87,20.63 RA10.2 ; 191.52,20.63 RA11.2
+CODEC_AVDD2: length 7
  BOTTOM w0.203: UA1.40 200.23,20.49 200.37,20.62 200.76,20.62 201.78,21.64 RA8.2 202.67,21.59 203.19,21.07 v1(204.59,21.07)
  BOTTOM w0.508: RA8.2 202.67,22.55 CA61.1
+FAN_POWER:
  vias: v2(7.8,71.81) v2(7.8,71.17) v3(7.3,71.56)
+GPU_CORE: length 40.3
  TOP w0.508: PC840.1 60.76,56.73 v2(60.76,57.27) ; PC849.1 58.98,56.73 v2(58.98,57.27)
  IN3 w0.508: v2(77.34,37.96) 75.18,35.81 56.06,35.81 50.98,40.89 50.98,43.93 v2(50.92,44)
  BOTTOM w0.203: v2(69.6,77.87) 69,78.47 UV1.K10
  BOTTOM w0.508: PC825.1 51.75,56.89 v2(51.75,57.27) ; v2(54.92,57.27) 54.92,56.89 PC826.1 ; PC829.1 57.46,56.89 v2(57.46,57.27) ; PC828.1 56.19,56.89 v2(56.19,57.27) ; v2(53.33,57.27) 53.33,56.89 PC827.1 ; PR813.1 v2(77.34,37.96)
  vias: v2(47.3,50.79) v2(47.3,49.97) v2(47.3,49.14) v2(47.3,48.25) v2(47.3,47.43) v2(47.3,46.6) v2(48,47.43) v2(48,46.6) v2(48.25,51.49) v2(48.7,47.43) v2(48.7,46.6) v2(49.14,52.25) v2(49.14,51.49) v2(49.4,47.43) v2(49.4,46.6) v2(50.03,53.52) v2(50.03,52.25) v2(50.03,50.98) v2(50.03,49.71) v2(50.03,48.38) v2(50.03,47.17) v2(50.03,45.9) v2(50.03,44.63) v2(50.03,43.3) v2(50.79,52.87) v2(50.79,51.6) v2(50.79,50.33) v2(50.79,49.06) v2(50.92,47.81) v2(50.92,46.54) v2(50.92,45.27) v2(51.5,53.46) v2(51.5,52.19) v2(51.5,50.92) v2(51.5,49.65) v2(51.53,44.58) v2(51.58,43.26) v2(51.81,48.38) v2(51.81,47.17) v2(51.81,45.84) v2(61.47,78.23) v2(61.53,74.17) v2(61.53,72.18) v2(61.59,76.11) v2(62.46,71.22) v2(63.52,78.18) v2(63.55,76.15) v2(63.51,74.19) v2(63.55,72.15) v2(64.48,71.22) v2(65.42,76.28) v2(65.5,78.2) v2(65.51,74.19) v2(65.51,72.19) v2(66.55,71.15) v2(67.44,72.27) v2(67.55,78.15) v2(67.49,76.21) v2(67.48,74.22) v2(68.46,77.4) v2(68.51,71.19) v3(55.56,51.49)
+INV_PWR_SRC: length 3.4
  TOP w0.102: v3(7.8,73.52) 7.3,73.52 6.95,73.87 RX4.2 ; v2(2.79,79.11) 2.53,79.11 v3(1.83,79.81)
  vias: v2(3.42,79.11) v2(3.42,78.41) v3(4.12,78.73)
+LAN_REGOUT: length 0.6
  TOP w0.102: v2(172.97,108.64) v3(172.97,109.2)
+LAN_VDD10: length 8.5
  TOP w0.508: CL7.1 175.7,106.13 v2(176.21,106.63) ; CL8.1 CL9.1 172.87,103.94 v2(172.65,104.16) ; v2(178.49,102.04) 178.57,102.11 CL5.1 178.52,102.67 CL6.1
  BOTTOM w0.203: v2(178.49,102.04) 178.37,102.16 UL1.8 ; UL1.30 176.17,106.6 v2(176.21,106.63) ; v2(178.76,104.4) 178.52,104.16 UL1.3 ; v2(172.65,104.16) UL1.22
  vias: v2(170.11,112.83) v2(170.11,112.2) v2(170.11,111.56)
+LAN_VDD33: length 17
  TOP w0.508: CL12.1 v2(177.6,105.97)
  IN1 w1.016: 177.5,100.49 184.04,100.49 187.14,97.39 187.14,92.8
  BOTTOM w0.203: UL1.11 v2(176.17,100.68)
  vias: v1(187.06,92.83) v2(170.06,103.52) v2(170.06,102.94) v2(176.6,100.26) v2(186.81,91.69) v2(187.25,91.24)
+LAN_VDDREG:
  vias: v1(172.21,104.7)
+LCDVDD: length 11.5
  IN3 w1.524: 19.32,75.07 19.05,75.07 17.2,76.92 17.2,78.67 12.31,83.56
  vias: v2(10.53,83.87) v2(10.98,83.43) v2(11.17,84.07) v2(20.03,74.22) v2(20.61,74.6) v2(20.61,73.84) v3(19.93,73.59)
+LCDVDD_CONN:
  vias: v2(4.63,88.45) v2(4.63,87.68) v2(5.39,88.45) v2(5.39,87.68) v3(3.99,88) v3(7.61,86.03) v3(9.52,84.07)
+MIC2-VREFO: length 23.6
  TOP w0.254: v2(189.67,34.14) 190.19,34.66 v1(193.22,34.66) 194.43,34.66 195,34.09 195,29.21 197.58,26.64 197.58,23.76 197.17,23.35 196.02,23.35 v2(195.84,23.53)
  BOTTOM w0.254: v2(195.84,23.53) 195.92,23.44 195.92,22.54 UA1.29 ; v2(189.67,34.14) 189.02,33.49 RA53.2 RA1109.2
+RTCBATT: length 6.8
  TOP w0.102: v2(32.7,10.79) v3(32.7,11.37)
  TOP w0.508: RC192.1 32.06,10.15 v2(32.7,10.79)
  BOTTOM w0.508: v2(32.7,10.79) 32.14,11.35 JRTC.1
+V_TS:
  vias: v1(14.53,99.05)
+VDISPLAY_VCC:
  vias: v1(200.65,79.87)
A_MIC_CLK: length 258
  TOP w0.102: CA22.1 4.44,82.1 v2(4.05,82.48)
  IN1 w0.102: v2(200.07,10.79) 200.27,10.99 200.27,11.23 200.13,11.38 197.64,11.38 197.13,11.89 194.08,11.89 191.2,9.01 188.21,9.01 186.37,7.17 178.68,7.17 177.6,6.09 161.54,6.09 158.97,8.65 148.55,8.65 148.09,9.11 147.03,9.11 146.07,8.14 142.65,8.14 141.85,8.94 136.85,8.94 135.71,10.09 133.41,10.09 132.04,11.46 127.86,11.46 125.45,13.87 121.3,13.87 118.23,16.95 110.52,16.95 107.1,20.37 106.86,20.37 94.86,32.38 52.89,32.38 51.71,33.55 51.71,34.56 43.87,42.41 38.6,42.41 28.89,52.12 7.35,52.12 5.1,54.38 5.1,66.83 2.05,69.87 2.05,80.95 3.35,82.25 3.82,82.25 v2(4.05,82.48)
  BOTTOM w0.102: LA1.2 200.27,13.36 200.27,10.99 v2(200.07,10.79) ; JEDP.30 2.54,84.5 2.66,84.38 3.1,84.38 3.47,84.02 3.47,83.39 3.74,83.12 3.74,82.53 3.79,82.48 v2(4.05,82.48)
A_MIC_DATA: length 260.3
  IN1 w0.102: v2(200.65,10.79) 200.5,10.94 200.5,11.33 200.22,11.61 197.74,11.61 197.22,12.12 193.99,12.12 191.1,9.24 188.11,9.24 186.27,7.4 178.59,7.4 177.51,6.32 161.63,6.32 159.07,8.88 148.65,8.88 148.19,9.34 146.94,9.34 145.97,8.37 142.75,8.37 141.95,9.17 136.95,9.17 135.8,10.32 133.51,10.32 132.13,11.69 127.96,11.69 125.54,14.1 121.4,14.1 118.33,17.17 110.62,17.17 107.19,20.6 106.96,20.6 94.96,32.6 52.98,32.6 51.94,33.65 51.94,34.66 43.96,42.64 38.7,42.64 28.98,52.35 7.45,52.35 5.33,54.47 5.33,66.92 2.28,69.97 2.28,80.86 3.44,82.02 3.93,82.02 v2(4.05,81.9)
  BOTTOM w0.102: v2(4.05,81.9) 4.05,81.9 4.05,81.9 3.51,82.44 3.51,83.02 3.03,83.5 JEDP.32 ; UA1.2 198.33,15.91 198.62,15.61 199,15.61 199.57,15.04 200.27,15.04 200.53,14.79 200.53,10.91 v2(200.65,10.79)
AC_DIS: length 130.6
  TOP w0.102: v2(132.86,16.44) 132.57,16.15 UE5.69
  TOP w0.254: v2(25.58,35.04) v1(25.08,35.55) PQ707.2 PQ707.5
  IN3 w0.102: v2(132.86,16.44) 132.61,16.18 130.91,16.18 129.59,17.5 129.43,17.5 129.24,17.32 124.06,17.32 123.15,16.41 121.5,16.41 120.65,17.26 110.67,17.26 110.07,17.86 104.05,17.86 89.31,32.6 86.94,32.6 85.04,34.51 79.44,34.51 77.54,32.6 57.76,32.6 49.28,41.08 30.28,41.08 29.33,40.12 27.74,40.12 25.14,37.52 25.14,35.49 v2(25.58,35.04)
AC_PRESENT: length 23
  TOP w0.102: RC106.2 152.83,69.88 v2(153.79,69.88) 153.35,70.32 DC2.2
  BOTTOM w0.076: 143.95,77.14 143.95,77.76 143.12,78.58 143.12,80.44 143.23,80.55 143.23,80.83 143.4,81.11 UC1.AY15
  BOTTOM w0.102: v2(153.79,69.88) 153.55,70.12 151.23,70.12 150.34,71.01 149.61,71.01 149.4,70.79 v1(148.9,70.79) 145.47,70.79 144.68,71.59 144.68,75.08 143.95,75.81 143.95,77.14
ACAV_IN: length 210.9
  TOP w0.102: CE89.2 148.42,4.84 146,4.84 v2(145.79,4.63) 145.58,4.84 145.15,4.84 145,4.69 UE5.128 ; DC2.1 153.39,69.08 v2(153.85,68.61)
  TOP w0.254: PR731.1 46.92,10.28 v1(47.11,10.09) v2(47.62,10.09)
  IN2 w0.102: v2(145.79,4.63) 146.49,5.33 v2(146.49,21.2)
  IN3 w0.102: v2(146.49,21.2) 148.2,21.2 150.08,23.08 169.63,23.08 171.6,25.04 171.6,33.86 170.64,34.81 170.64,36.65 168.66,38.64 168.66,40.32 169.04,40.7 169.04,43.3 168.52,43.82 168.52,49.57 163.53,54.56 163.53,56.12 161.85,57.79 161.85,58.69 160.39,60.15 160.39,61.72 159.64,62.47 159.64,63.69 158.84,64.48 157.37,64.48 155.95,65.9 155.5,65.9 153.85,67.56 v2(153.85,68.61)
  IN3 w0.254: v2(47.62,10.09) 48.06,9.64 49.16,9.64 52.52,13.01 57.84,13.01 63.3,7.55 106.75,7.55 111.93,2.37 121.89,2.37 122.51,1.74 129.62,1.74 131.62,3.74 144.9,3.74 v2(145.79,4.63)
  BOTTOM w0.203: PR741.2 47.62,9.72 v2(47.62,10.09) 47.55,10.09 47.08,10.56 PU703.2
ACIN_CHG: length 70.8
  TOP w0.254: v2(32.89,39.55) v1(32.89,38.85) 32.89,36.31 32.09,35.52 PD706.2 ; v2(48.57,10.41) 48.49,10.41 PC711.2 ; PQ707.3 25.73,36.49 26.16,36.06 v2(26.16,35.42)
  IN3 w0.254: v2(48.57,10.41) 48.95,10.41 53.33,14.79 53.33,36.19 48.82,40.69 34.03,40.69 v2(32.89,39.55) 28.76,35.42 v2(26.16,35.42)
  BOTTOM w0.203: PU703.1 47.48,10.92 47.62,10.79 48,10.79 48.38,10.41 v2(48.57,10.41)
  BOTTOM w0.254: PR732.1 PR729.2 48.57,9.66 v2(48.57,10.41)
ACLIM: length 4.5
  TOP w0.254: v2(43.17,15.04) 43.81,14.41 PR751.2 43.54,14.09 v1(42.67,14.09) 41.92,14.09 PR749.1
  BOTTOM w0.203: PU703.16 43.49,14.72 v2(43.17,15.04)
ALL_SYS_PWRGD: length 161.5
  TOP w0.076: 111.18,105.34 111.18,104.51 109.35,102.68 RC388.1 RC389.2 RC345.1 RC392.2 108.78,98.16 108.64,98.16
  TOP w0.102: UC13.4 127.15,23.64 127.56,24.06 128.63,24.06 129.41,24.83 131.36,24.83 DC6.2 132.01,24.44 136.01,24.44 v2(136.65,25.07) v1(137.53,24.18) 138.23,23.49 RE381.2 ; 111.18,105.34 111.18,106.8 v2(109.78,108.2) ; 108.64,98.16 107.56,98.16 106.93,98.8 v2(106.17,98.8)
  IN1 w0.089: v2(136.65,25.07) 135.25,26.47 107.73,26.47 104.93,29.27 104.93,32.28 99.5,37.71 88.63,37.71 v2(88.51,37.82)
  IN3 w0.102: v2(88.51,37.82) 91.46,40.77 91.46,58.44 92.11,59.08 92.11,64.95 91.92,65.14 91.92,71.91 92.64,72.64 92.64,91.37 100.07,98.8 v2(106.17,98.8)
  BOTTOM w0.102: v2(109.78,108.2) 109.53,108.45 109.09,108.45 108.51,109.02 106.61,109.02 106.42,109.21 106.42,110.13 106.52,110.23 UC12.2
ALWON: length 95.2
  TOP w0.102: UE5.121 142.2,5.3 v2(142.42,5.52) ; v2(64.19,29.58) v1(64.19,29.07)
  TOP w0.254: PR114.1 64.19,29.7 v2(64.19,29.58)
  IN1 w0.102: v2(142.42,5.52) 141.85,6.09 137.41,6.09 136.38,7.12 130.9,7.12 129.81,8.21 127.65,8.21 127.29,7.84 122.89,7.84 122.04,8.69 119.06,8.69 118.73,9.01 116.08,9.01 113.35,11.74 108.83,11.74 106.42,14.15 106.42,17.58 99.21,24.79 95.47,24.79 89.16,31.09 65.32,31.09 64.19,29.96 v2(64.19,29.58)
ASGATE: length 60.5
  TOP w0.102: v2(27.04,40.52) v1(26.3,40.52)
  TOP w0.254: PR762.2 v2(27.04,40.52)
  IN1 w0.254: v2(27.04,40.52) 25.53,40.52 24.38,39.36 24.38,34.28 23.74,33.65 23.74,24.5 22.03,22.79 22.03,18.28 26.47,13.83 27.3,13.83 32.28,8.86 40.1,8.86 41.84,10.6 47.62,10.6 49.02,11.99 v2(49.02,12.63)
  BOTTOM w0.203: v2(49.02,12.63) 48.92,12.72 PU703.30
AUD_HP_OUT_L_CN: length 15.4
  TOP w1.016: v2(196.58,30.27) 196.84,30.53 198.23,30.53 v1(199.42,31.73) 199.42,36.19 200.14,36.91 JHP.1
  BOTTOM w0.508: v2(196.58,30.27) 195.78,29.47 DA10.3 194.98,29.47 194.44,28.93 CA39.1 192.4,28.93 LA8.1
AUD_HP_OUT_R_CN: length 16.4
  TOP w1.016: 198.94,27.23 v1(200.08,26.09) 205.15,26.09 205.73,25.51 206.99,25.51 207.56,26.08 207.56,27.04 JHP.2
  BOTTOM w0.508: v2(197.48,27.54) DA10.2 195.08,27.82 CA33.1 192.65,27.82 LA9.1
AUD_PC_BEEP: length 2.9
  TOP w0.102: v1(195.13,12.75) 195,12.88 CA65.1
  TOP w0.254: CA65.1 194.18,12.89 RA1115.2 RA1114.1
AUD_PC_BEEP_R: length 2.8
  TOP w0.254: RA1115.1 194.19,15.35 v2(193.86,15.68)
  BOTTOM w0.102: v2(193.86,15.68) 193.6,15.42 v1(193.22,15.42)
  BOTTOM w0.254: v2(193.86,15.68) 194.33,16.14 UA1.12
BA: length 6.5
  TOP w0.508: PR780.1 38.65,11.94 PQ710.1 39.11,14.61 v1(39.11,15.23) 39.11,15.74 38.73,16.12 v2(38.03,16.12)
  BOTTOM w0.508: v2(38.03,16.12) 37.22,16.12 PD705.2
BAT1_LED#: length 172.1
  TOP w0.102: 15.55,35.55 15.55,36 15.74,36.19 v1(17.39,36.19) 17.84,36.63 17.84,41.39 18.53,42.09 18.53,46.84 22.47,50.79 30.99,50.79 31.92,51.72 v2(31.92,52.25) ; v2(140.9,13.01) 140.9,8.69 144.24,5.35 UE5.1 149.74,5.35 RE358.1
  IN1 w0.102: v2(31.92,52.25) 31.92,52 39.91,44.01 44.68,44.01 53.27,35.42 53.27,34.5 53.88,33.88 80.23,33.88 81.06,34.71 83.07,34.71 83.9,33.88 95.36,33.88 106.24,23.01 108.1,23.01 109.8,21.31 109.8,19.8 111.09,18.51 122.89,18.51 123.22,18.18 126.93,18.18 128.3,16.81 128.79,16.81 129.29,16.3 130.28,16.3 132.64,13.94 133.95,13.94 134.88,13.01 v2(140.9,13.01)
BAT2_LED#: length 159.2
  TOP w0.102: v2(136.52,6.32) 136.07,5.87 136.07,4.82 136.2,4.69 UE5.106 ; v2(17.71,49.27) 17,48.56 v1(17,47.74) 17,44.17 16.63,43.81 15.74,43.81 15.55,43.62 RI1.2 ; v2(128.57,7.8) 128.09,8.29 RE360.1
  IN1 w0.102: v2(128.57,7.8) 128.8,7.57 129.95,7.57 130.64,6.89 135.95,6.89 v2(136.52,6.32) ; v2(135.47,9.56) 135.23,9.8 131.67,9.8 130.24,11.23 127.77,11.23 125.35,13.64 111.26,13.64 108.85,16.06 108.85,17.75 94.7,31.89 52.67,31.89 51.11,33.46 51.11,34.34 44,41.46 38.22,41.46 30.41,49.27 v2(17.71,49.27)
  BOTTOM w0.102: v2(136.52,6.32) 136.52,8.21 135.47,9.25 v2(135.47,9.56)
BEEP: length 65.6
  TOP w0.102: UE5.45 140.2,18.41 139.17,17.38 139.17,15.29 139.34,15.13 139.34,10.68 v2(138.87,10.21) ; DA8.2 188.18,18.55 v1(186.81,18.55) 185.54,18.55 v2(185.46,18.47)
  IN1 w0.102: v2(138.87,10.21) 139.31,9.77 142.05,9.77 142.56,10.28 148.15,10.28 148.72,10.85 149.73,10.85 151.06,9.52 164.14,9.52 168.4,13.77 168.4,14.94 169.95,16.5 174.6,16.5 176.95,18.85 185.08,18.85 v2(185.46,18.47)
BLON_OUT_C: length 7.5
  TOP w0.102: RX31.2 6.01,80.57 4.35,80.57 4.17,80.4 RX9.1 3.23,80.06 2.82,80.47 v2(2.82,80.61) 2.82,80.85 2.03,81.65 v1(1.71,81.65)
  BOTTOM w0.102: JEDP.37 2.43,81 v2(2.82,80.61)
BLUETOOTH_EN: length 55.5
  IN1 w0.102: v2(157.73,91.5) 158.04,91.5 160.18,89.36 165.59,89.36 170.07,84.88 170.07,77.06 170.96,76.17 v2(170.96,74.8)
  BOTTOM w0.076: 154.87,91.43 v1(154.33,90.89) 152.03,90.89 151.72,90.96 UC1.AB2
  BOTTOM w0.102: 154.87,91.43 155.7,92.26 RC322.1 156.57,91.75 157.48,91.75 v2(157.73,91.5) ; v2(170.96,74.8) 170.96,70.51 173.41,68.06 181.19,68.06 181.45,68.32 185.15,68.32 185.73,67.75 JNGFF.46
BOARD_ID: length 28.5
  TOP w0.102: UE5.111 138.2,2.43 v2(138.07,2.29) ; v1(115.12,4.5) 115.37,4.25 v2(115.75,4.25) 115.68,4.17 RE343.2 115.68,2.62 RE344.2 CE71.1
  IN1 w0.102: v2(138.07,2.29) 137.42,1.64 122.48,1.64 121.37,2.76 117.24,2.76 v2(115.75,4.25)
BOARD_ID2: length 9.2
  BOTTOM w0.076: 154.87,91.95 154.03,91.11 152.58,91.11 152.27,91.43 151.09,91.43 UC1.AB3
  BOTTOM w0.102: 154.87,91.95 v1(155.15,92.23) RC324.1 156.56,93.64 157.98,93.64 RC325.2
BOARD_ID3: length 49.9
  BOTTOM w0.076: 151.63,77.41 151.02,77.41 148.81,79.62 148.36,79.62 148.1,79.88 148.1,80.12 148.4,80.42 UC1.BA7
  BOTTOM w0.102: RC326.1 RC323.2 166.49,91.74 v1(168.46,91.74) 168.8,91.74 173.86,86.68 173.86,79 171.58,76.72 168.01,76.72 167.09,75.8 163.65,75.8 163.03,75.18 161.6,75.18 161.03,74.62 159.75,74.62 159.44,74.92 155.21,74.92 154.4,75.73 153.38,75.73 151.7,77.41 151.63,77.41
BS_+1VALWP: length 3.1
  BOTTOM w0.102: v1(181.16,55.11) 181.65,54.61 181.65,53.12 181.16,52.62 PR304.1
BST1_VGA:
  vias: v1(73.34,47.3)
BST1_VGA_R:
  vias: v1(70.73,47.11)
BST2_VGA:
  vias: v1(73.21,38.6)
BST2_VGA_R:
  vias: v1(71.94,38.47)
BST_1.35V: length 1.8
  BOTTOM w0.102: v1(89.27,11.87) 89.27,12.2 88.39,13.09 PR200.2
BST_1.35V_R:
  vias: v1(90.61,12.06)
BST_3V:
  vias: v1(62.92,12.12)
BST_5V:
  vias: v1(63.86,24.35)
CAM_DETECT: length 288.6
  TOP w0.076: 154.87,94.99 154.11,94.99 v3(154.04,95.05) 153.86,95.05 v2(153.43,95.48)
  TOP w0.102: RC330.1 154.87,94.99
  IN1 w0.076: v2(153.43,95.48) 153.75,95.48 154.5,94.72 154.87,94.72
  IN1 w0.102: v2(14.85,53.08) 14.85,55.05 18.52,58.72 20.53,58.72 24.11,62.29 24.11,64.87 24.26,65.02 27.04,65.02 27.3,64.76 29.11,62.94 29.11,56.46 40.72,44.85 44.86,44.85 54.89,34.81 79.87,34.81 80.68,35.63 83.46,35.63 84.27,34.81 95.72,34.81 106.62,23.92 108.48,23.92 112.83,19.57 114.38,19.57 115.15,20.34 122.36,20.34 123.5,19.19 128.33,19.19 129.67,17.85 130.04,17.85 132.35,15.54 133.97,15.54 135.28,14.22 140.24,14.22 140.4,14.38 146.39,14.38 148.06,16.05 153.52,16.05 155.38,17.91 159.97,17.91 161.35,19.29 163.33,19.29 167.9,23.86 167.9,40.44 168.52,41.06 168.52,42.97 167.73,43.76 167.73,45.92 167.02,46.63 167.02,52.96 166.78,53.2 166.78,60.2 167.73,61.15 167.73,64.46 171.37,68.09 171.37,76.09 170.3,77.16 170.3,86 167.25,89.04 166.23,89.04 165.69,89.59 160.27,89.59 159.25,90.61 159.25,92.83 158.18,93.9 156.9,93.9 156.08,94.72 154.87,94.72
  BOTTOM w0.076: UC1.P2 151.72,94.86 153.11,94.86 153.43,95.18 v2(153.43,95.48)
  BOTTOM w0.102: JCAM3D.4 10.52,52.4 10.52,52.4 14.17,52.4 v2(14.85,53.08)
CAP_LED: length 10.7
  TOP w0.102: JKB.4 94.88,45.35 95.24,45.71 95.24,47.4 93.27,49.37 v3(93.27,50.35) 93.27,51.79 RE401.2
CAP_LED#: length 77.3
  TOP w0.102: UE5.93 129.9,6.55 129.55,6.9 129.09,6.9 v2(129.1,6.91) ; v2(113.4,7.93) v1(113.4,8.94) 113.4,9.45 111.73,11.13 111.73,13.45 111.04,14.14 111.04,20.03 104.5,26.57 103.61,26.57 97.15,33.04 97.15,40.79 96.02,41.92 96.02,46.95 94.16,48.81 94.16,52.38 95.24,53.46 95.24,55.57 QE11.3 94.25,56.56 RE330.2
  IN3 w0.102: v2(129.1,6.91) 128.66,7.36 128.26,7.36 127.78,7.84 124.14,7.84 123.07,6.77 121.27,6.77 120.84,7.2 118.43,7.2 117.71,7.93 v2(113.4,7.93)
CAP_LED_Q: length 3.5
  TOP w0.102: RE401.1 v1(91.18,51.87) 90.73,52.32 QE10.1
CAP_LED_R#: length 5.6
  TOP w0.102: QE10.2 91.7,53.64 v1(92.45,52.89) 93.66,52.89 QE11.1
CCLIM: length 5.1
  TOP w0.254: PR750.1 42.23,12.63 v2(42.54,12.63) 42.92,12.25 v1(43.55,12.25) 43.86,12.55 PR752.2
  BOTTOM w0.203: PU703.11 42.63,12.72 v2(42.54,12.63)
CFG0: length 9.7
  BOTTOM w0.076: 108.77,105.34 110.03,104.08 112.59,104.08 112.91,103.76 113.9,103.76 114.17,103.49 114.17,103.16 114.32,103.01 114.32,102.84 114.32,102.84 114.32,102.48 114.32,102.47 114.29,102.38 114.29,102.24 114.3,102.15 114.32,102.07 114.32,102.01 114.32,101.9 114.32,101.89 114.32,101.85 114.3,101.79 114.27,101.7 114.22,101.52 114.18,101.26 114.11,100.99 UC1.E68
  BOTTOM w0.102: 108.77,105.34 108.64,105.46 T4932.1
CFG1: length 7.8
  BOTTOM w0.076: UC1.B67 113.89,102.14 113.53,102.5 113.53,102.75 113.35,102.93 113.24,102.93 112.45,103.72 108.87,103.72 108.64,103.94
  BOTTOM w0.102: T4933.1 107.75,104.83 108.64,103.94
CFG2: length 11.8
  BOTTOM w0.076: 109.15,105.34 110.23,104.25 112.65,104.25 112.98,103.93 113.97,103.93 114.24,103.66 114.76,103.66 114.98,103.44 114.98,103.01 114.81,102.84 114.81,102.48 114.84,102.38 114.84,102.19 114.81,102.1 114.81,101.85 114.82,101.8 114.86,101.65 114.95,101.37 114.95,101.26 115.02,100.99 UC1.D65
  BOTTOM w0.102: T4935.1 108.98,107.15 108.98,105.5 109.15,105.34
CFG3: length 11
  BOTTOM w0.076: UC1.D67 114.07,101.62 114.15,101.88 114.15,102.05 114.09,102.24 114.09,102.39 114.15,102.51 114.15,102.94 114,103.09 114,103.43 113.83,103.6 112.84,103.6 112.54,103.9 109.57,103.9 108.64,104.83
  BOTTOM w0.102: 108.64,104.83 T4934.1 RC43.1
CFG4: length 5.3
  BOTTOM w0.076: 110.04,100.7 111.13,100.7 111.31,100.51 111.65,100.51 111.85,100.31 UC1.E70
  BOTTOM w0.102: 110.04,100.7 109.59,100.7 109.34,100.45 T4943.1 108.26,100.45 107.64,101.07 RC193.1
CFG5: length 1.2
  TOP w0.076: v2(112.79,101.36) 113.15,101 T4944.1
  BOTTOM w0.076: UC1.C68 113.17,100.98 v2(112.79,101.36)
CFG6: length 4.4
  BOTTOM w0.076: UC1.D68 111.97,100.83 111.66,101.14 110.48,101.14 109.78,101.85 108.64,101.85
  BOTTOM w0.102: 108.64,101.85 T4945.1
CFG7: length 6.1
  BOTTOM w0.076: 108.64,103.18 110.1,103.18 110.29,103.37 112.31,103.37 112.94,102.74 112.94,102.5 113.3,102.14 UC1.C67
  BOTTOM w0.102: 108.64,103.18 T4946.1
CFG8: length 7.1
  BOTTOM w0.076: UC1.F71 111.86,99.75 109.95,99.75 109.85,99.85
  BOTTOM w0.102: 109.85,99.85 107.45,99.85 107.24,100.05 105.8,100.05 T4938.1
CFG9: length 5.7
  BOTTOM w0.076: 108.64,98.77 110.24,98.77 110.53,99.07 111.04,99.07 111.32,98.79 111.58,98.79 111.7,98.85 111.84,98.85 112.07,98.78 112.2,98.78 112.71,98.96 UC1.G69
  BOTTOM w0.102: 108.64,98.77 107.46,98.77 T4939.1
CFG10: length 5.7
  BOTTOM w0.076: UC1.F70 112.25,99.95 111.64,99.95 111.63,99.93 110.36,99.93 110.22,100.08
  BOTTOM w0.102: T4940.1 107.19,100.44 107.54,100.08 110.22,100.08
CFG11: length 9.1
  BOTTOM w0.076: UC1.G68 112.88,99.23 112.82,99.25 112.35,99.25 112.28,99.33 112.02,99.33 111.46,99.57 109.52,99.57
  BOTTOM w0.102: T4941.1 105.35,99.83 107.15,99.83 107.35,99.62 109.47,99.62 109.52,99.57
CFG12: length 3.7
  BOTTOM w0.076: T4947.1 110.78,97.91 111.03,98.16 111.61,98.16 111.74,98.11 111.85,98.11 111.98,98.16 112.22,98.16 UC1.H70
CFG13: length 5.7
  BOTTOM w0.076: UC1.G71 111.29,99.24 110.4,99.24 110.1,98.94 108.71,98.94 108.64,99
  BOTTOM w0.102: 108.64,99 108.53,99.11 107.58,99.11 107.3,99.4 106.32,99.4 T4948.1
CFG14: length 8.6
  BOTTOM w0.076: UC1.H69 112.83,98.66 112.36,98.66 112.21,98.61 112.06,98.61 111.84,98.67 111.73,98.67 111.61,98.63 111.2,98.63 110.96,98.88 110.66,98.88 110.33,98.54
  BOTTOM w0.102: T4949.1 105.4,98.23 107.47,98.23 107.78,98.54 110.33,98.54
CFG15: length 3.3
  BOTTOM w0.076: T4942.1 109.35,99.1 109.98,99.1 110.28,99.4 111.42,99.4 111.83,99.21 111.83,99.2 111.83,99.2 111.97,99.06 UC1.G70
CFG16: length 1.5
  TOP w0.076: T4937.1 115.96,101 v2(115.96,100.11)
  BOTTOM w0.076: UC1.E63 v2(115.96,100.11)
CFG17: length 1.2
  TOP w0.076: v2(115.96,99.48) 116.14,99.31 T4936.1
  BOTTOM w0.076: UC1.F63 v2(115.96,99.48)
CFG18: length 1.4
  TOP w0.076: v2(113.93,100.11) 114.02,100.11 T4951.1
  BOTTOM w0.076: UC1.E66 v2(113.93,100.11)
CFG19: length 1.1
  TOP w0.076: T4950.1 114.11,99.31 v2(113.93,99.48)
  BOTTOM w0.076: UC1.F66 v2(113.93,99.48)
CFG_RCOMP: length 2.2
  TOP w0.076: RC185.1 v1(117.97,101.78)
  TOP w0.254: RC185.1 117.89,100.72 v2(117.89,100.11)
  BOTTOM w0.254: UC1.E60 117.97,100.08 v2(117.89,100.11)
CLK_CPU_ITP: length 1
  TOP w0.076: T90.1 128.01,99.75 v2(127.9,99.64)
  BOTTOM w0.076: UC1.E43 127.65,99.89 v2(127.9,99.64)
CLK_CPU_ITP#: length 1.2
  TOP w0.076: T89.1 128.22,99 v2(127.9,99)
  BOTTOM w0.076: v2(127.9,99) 127.66,99.24 UC1.F43
CLK_PCI_LPC_MEC: length 80.9
  TOP w0.102: R2454.2 135.11,21.2 135.33,21.2 v2(135.73,20.8) 135.73,20.57 135.4,20.25 UE5.57 ; v2(161.4,65.33) 161.4,65.52 160.89,66.03 160.33,66.03 160.22,66.15 160.22,67.88 160.27,67.93 v1(160.27,68.32) RC45.2
  IN1 w0.089: v2(161.4,65.33) 160.6,64.54 160.6,63.03 161.24,62.39 161.24,61.35 160,60.11 160,52.65 162.71,49.94 162.71,44.88 163.17,44.42 163.17,36.23 162.49,35.55 162.49,25.45 161.41,24.37 160.51,24.37 157.84,21.71 148.44,21.71 146.31,19.57 141.04,19.57 139.51,21.11 137.64,21.11 136.88,20.35 136.18,20.35 v2(135.73,20.8)
CLK_PCI_LPDEBUG: length 99
  TOP w0.102: RC54.2 159.38,68.89 v2(159.13,68.64)
  IN3 w0.102: v2(159.13,68.64) 159.13,67.67 159.59,67.21 159.59,65.13 160.58,64.14 160.58,63.43 160.96,63.05 161.83,63.05 162.34,62.54 162.34,62.26 162.95,61.64 162.95,58.32 163.76,57.51 163.76,56.63 163.98,56.41 163.98,54.75 168.97,49.76 168.97,44.01 169.51,43.47 169.51,38.11 170.87,36.75 170.87,34.91 171.82,33.95 171.82,24.95 169.73,22.85 150.17,22.85 146.74,19.42 141.6,19.42 140.9,18.72 139.82,18.72 138.27,17.18 137.41,17.18 136.12,18.47 133.09,18.47 132.58,17.96 v2(128.99,17.96)
  BOTTOM w0.102: v1(158.68,68.89) 158.89,68.89 v2(159.13,68.64) ; DB1.1 128.3,18.18 128.52,17.96 128.99,17.96 v2(128.99,17.96)
CLK_PCIE_LAN_N2: length 55.4
  IN3 w0.089: v2(129.09,103.74) 129.16,103.67 129.34,103.67 129.59,103.92 136.75,103.92 139.99,107.15 158.01,107.15 164.14,101.02 166.89,101.02 169.01,98.9 169.16,98.9 v2(169.43,99.17)
  BOTTOM w0.076: UC1.D41 127.91,101.56 127.91,101.78 128.04,101.92 128.04,102.23 128.28,102.48 128.28,102.87 128.46,103.05 128.46,103.18 128.73,103.45 128.8,103.45 v2(129.09,103.74)
  BOTTOM w0.089: UL1.16 174.17,101.05 174.34,100.88 174.34,100.75 172.65,99.05 v4(171.44,99.05) 170.25,99.05 169.97,98.77 169.82,98.77 v2(169.43,99.17)
CLK_PCIE_LAN_P2: length 55.4
  IN3 w0.089: v2(129.09,103.15) 129.67,103.73 136.83,103.73 140.06,106.96 157.93,106.96 164.07,100.83 166.81,100.83 168.93,98.71 169.3,98.71 v2(169.43,98.58)
  BOTTOM w0.076: UC1.C41 128.19,101.44 128.27,101.36 128.38,101.36 128.52,101.49 128.52,101.82 128.41,101.92 128.26,101.92 128.2,101.99 128.2,102.17 128.45,102.42 128.45,102.8 128.62,102.97 128.62,103.1 128.8,103.28 128.96,103.28 v2(129.09,103.15)
  BOTTOM w0.089: UL1.15 174.57,101.04 174.53,100.99 174.53,100.67 172.72,98.87 171.83,98.87 171.8,98.84 171.09,98.84 171.06,98.87 170.33,98.87 170.05,98.58 v2(169.43,98.58)
CLK_PCIE_LAN_REQ#: length 81.6
  TOP w0.102: v2(147.16,83.4) 147.48,83.08 147.48,80.92 149.24,79.15 149.24,78.6 151.71,76.14 153.79,76.14 153.94,75.99 v1(153.94,75.62) v2(153.94,74.64) 154.48,74.1 RPC10.2
  IN1 w0.102: v2(177.48,99.5) 177.48,95.06 178.26,94.27 178.26,85.82 v2(188.14,75.94)
  BOTTOM w0.076: UC1.AT8 147.5,83.75 v2(147.16,83.4)
  BOTTOM w0.102: v2(188.14,75.94) 187.99,75.78 168.36,75.78 167.47,74.89 164.03,74.89 163.41,74.27 163.08,74.27 162.01,73.21 159.63,73.21 158.88,73.96 154.63,73.96 v2(153.94,74.64) ; UL1.12 175.77,100.18 176.21,99.75 177.22,99.75 v2(177.48,99.5)
CLK_PCIE_WLAN_N1: length 112.2
  IN3 w0.089: v2(128.07,103.3) 128.07,103.39 128.24,103.56 128.37,103.56 128.45,103.48 128.45,102.8 129.03,102.23 136.33,102.23 140.48,106.38 157.69,106.38 163.87,100.19 166.62,100.19 179.25,87.56 184.7,87.56 192.1,80.16 192.1,79.53 194.18,77.45 194.18,76.43 195.1,75.51 195.1,67.67 193.15,65.72 193.15,62.86 191.49,61.2 191.49,60.72 191.28,60.51 191.28,60.22 191.19,60.13 v2(191.1,60.13)
  BOTTOM w0.076: UC1.B42 127.63,102.15 127.88,102.4 127.88,103.11 v2(128.07,103.3)
  BOTTOM w0.089: v2(191.1,60.13) 191.26,60.28 191.26,60.59 191.19,60.66 190.14,60.66 189.74,60.26 184.92,60.26 184.16,59.5 184.16,58.84 184.27,58.73 184.4,58.73 184.48,58.65 JNGFF.41
CLK_PCIE_WLAN_P1: length 112.2
  IN3 w0.089: v2(128.07,103.88) 128.19,103.75 128.45,103.75 128.64,103.56 128.64,102.88 129.1,102.42 136.25,102.42 140.4,106.57 157.77,106.57 163.95,100.38 166.7,100.38 179.33,87.75 184.78,87.75 192.29,80.24 192.29,79.61 194.37,77.53 194.37,76.51 195.29,75.59 195.29,67.59 193.34,65.64 193.34,62.78 191.68,61.13 v2(191.68,60.33)
  BOTTOM w0.076: UC1.A42 127.71,102.7 127.71,103.52 v2(128.07,103.88)
  BOTTOM w0.089: JNGFF.39 183.98,59.58 184.84,60.44 189.67,60.44 190.07,60.84 191.27,60.84 191.44,60.67 191.44,60.55 191.67,60.33 v2(191.68,60.33)
CLK_PCIE_WLAN_REQ#: length 77.5
  TOP w0.102: RPC10.1 154.98,75.94 154.55,76.37 151.8,76.37 149.54,78.63 v1(149.54,78.99) 149.54,79.18 147.67,81.05 147.67,83.46 v2(148.07,83.86)
  IN1 w0.076: 154.87,77.3 153.76,77.3 153.03,78.03 151.5,78.03 147.71,81.82 147.71,83.51 v2(148.07,83.86)
  IN1 w0.102: 154.87,77.3 159.86,77.3 162.32,74.84 162.32,68.67 165.68,65.32 165.68,62.75 165.01,62.08 164.4,62.08 163.89,61.57 163.89,61.15 164.67,60.36 164.67,59.58 v2(164.58,59.49)
  BOTTOM w0.076: v2(148.07,83.86) 148.18,83.75 UC1.AT7
  BOTTOM w0.102: v2(164.58,59.49) 164.58,59.49 164.85,59.22 167.28,59.22 171.23,55.27 172.94,55.27 173.18,55.52 173.18,55.88 174.06,56.76 185.16,56.76 185.48,57.08 JNGFF.45
CLK_PEG_VGA: length 96.3
  IN1 w0.089: v2(72.57,63.4) 72.77,63.6 72.77,64.58 74.54,66.35 78.8,66.35 87.31,74.86 87.31,79.37 87.12,79.56 87.12,89.53 96.19,98.6 97.46,98.6 101.12,102.26 103.08,102.26 108.51,107.68 122.22,107.68 123.68,109.14 126.41,109.14 v2(126.61,109.34)
  BOTTOM w0.076: 127.36,104.18 127.36,104.16 127.36,104.15 127.36,102.54 127.39,102.45 127.42,102.39 127.42,102.24 127.39,102.14 127.36,102.05 127.36,101.88 127.51,101.43 UC1.C42 ; v2(72.57,63.4) 72.8,63.63 72.8,64.9 72.59,65.12 72.24,65.12 71.94,65.43 71.94,65.73 71.74,65.92 70.05,65.92 69.96,65.83 UV1.AE8
  BOTTOM w0.089: 127.36,104.18 127.36,108.59 v2(126.61,109.34)
CLK_PEG_VGA#: length 96.3
  IN1 w0.089: v2(126.61,108.76) 126.41,108.96 123.76,108.96 122.29,107.5 108.58,107.5 103.16,102.07 101.19,102.07 97.53,98.42 96.26,98.42 87.3,89.45 87.3,79.63 87.49,79.44 87.49,74.78 78.87,66.17 74.62,66.17 72.95,64.5 72.95,63.6 v2(73.15,63.4)
  BOTTOM w0.076: 127.18,104.18 127.18,104.16 127.18,104.15 127.18,102.51 127.22,102.4 127.23,102.38 127.23,102.19 127.2,102.1 127.2,101.85 127.21,101.8 127.25,101.65 127.34,101.37 127.34,101.26 127.41,100.99 UC1.D42 ; UV1.AD8 70.28,66.08 71.81,66.08 72.1,65.79 72.1,65.49 72.31,65.28 72.39,65.28 72.39,65.28 72.68,65.28 72.97,64.99 72.97,63.58 v2(73.15,63.4)
  BOTTOM w0.089: v2(126.61,108.76) 126.68,108.83 126.86,108.83 127.18,108.51 127.18,104.18
CLK_SMB: length 3.7
  BOTTOM w0.254: PBATT.7 17.35,24.52 PR18.1
CLK_TP_SIO: length 142.2
  TOP w0.102: RE338.2 19.83,65.03 19.83,63.83 CE92.2 20.44,63.36 21.39,62.41 v1(21.39,61.97) 21.39,61.3 21.24,61.14 20.95,61.14 20.66,60.85 JTP.1 20.66,59.2 v2(21.19,58.67) ; UE5.78 132.06,12.55 v2(132.27,12.75)
  IN1 w0.102: v2(132.27,12.75) 130.59,14.43 128.46,14.43 126.35,16.54 120.36,16.54 118.61,18.28 111,18.28 109.57,19.71 109.57,21.15 107.95,22.78 106.14,22.78 95.26,33.65 83.81,33.65 82.98,34.48 81.16,34.48 80.33,33.65 53.79,33.65 53.02,34.43 53.02,35.3 44.53,43.78 39.82,43.78 29.21,54.39 27.13,54.39 22.85,58.67 v2(21.19,58.67)
CLKREQ_PCIE#0_R: length 9.5
  TOP w0.102: QV3.3 77.41,67.57 77.02,67.17 v1(76.76,67.17) 76.5,67.17 RV5.1 75.1,68.57 73.51,68.57 RV68.2 72.59,67.65 v2(71.96,67.65)
  BOTTOM w0.102: v2(71.96,67.65) 71.6,67.29 UV1.AC6
CLKRUN#: length 103.4
  TOP w0.102: UE5.63 133,20.23 132.8,20.44 132.06,20.44 v2(132.01,20.49) ; v2(156.9,72.76) v1(156.36,72.22) 156.36,71.01 156.64,70.74 RC107.1
  IN1 w0.102: v2(132.01,20.49) 134.28,20.49 134.65,20.85 134.65,21.36 135.57,22.28 142.87,22.28 143.76,21.39 145.59,21.39 146.04,21.84 147.29,21.84 148.06,22.6 157.47,22.6 160.75,25.88 160.75,35.06 162.28,36.6 162.28,44.05 161.82,44.51 161.82,49.21 157.33,53.7 157.33,59.55 156.52,60.36 156.52,64.96 156.36,65.13 156.36,67.39 155.94,67.81 155.94,68.85 156.38,69.29 156.38,70.95 156.2,71.13 156.2,72.06 v2(156.9,72.76)
  BOTTOM w0.076: UC1.AW11 145.93,81.81 146.22,81.52 146.22,80.78 146.27,80.73 146.27,79.95 148.03,78.19 148.3,78.19 149.35,77.14
  BOTTOM w0.102: 149.35,77.14 150.81,75.68 151.49,75.68 153.9,73.27 156.39,73.27 v2(156.9,72.76)
CMP_STRAP0: length 19.2
  TOP w0.102: v2(141.09,7.67) 140.77,7.36 140.77,5.07 141,4.84 UE5.118 ; v1(152.79,7.55) 153.16,7.55 153.4,7.79 v2(153.4,8.07) 153.4,8.22 154.23,9.06 RE379.1
  IN1 w0.102: v2(141.09,7.67) 141.31,7.46 149.6,7.46 149.88,7.74 153,7.74 153.34,8.07 v2(153.4,8.07)
CMP_VIN0: length 42.3
  TOP w0.102: v2(143.73,15.5) 143.73,13.86 144.64,12.95 UE5.20 ; v2(122.83,11.68) 123.11,11.68 RE387.1 ; v1(152.01,18.6) 151.76,18.34 v2(151.76,17.62) 152.05,17.33 RE375.1
  IN1 w0.102: v2(151.76,17.62) 151.54,17.62 150.66,16.74 147.73,16.74 146.69,15.7 143.93,15.7 v2(143.73,15.5)
  IN3 w0.102: v2(122.83,11.68) 123.31,11.68 124.01,10.98 125.26,10.98 125.85,11.57 128.17,11.57 128.87,10.87 128.87,10.07 129.03,9.91 129.03,9.58 129.34,9.26 130.11,9.26 131.99,11.14 137.66,11.14 141.15,14.63 141.38,14.86 143.09,14.86 v2(143.73,15.5)
CMP_VOUT0: length 169.1
  TOP w0.102: UE5.85 130.13,9.75 129.91,9.96 129.91,10.52 128.76,11.68 125.38,11.68 v2(125.14,11.43) 124.8,11.43 RE387.2 RE384.2 ; QV4.1 77.24,75.66 v2(77.97,74.92)
  TOP w0.254: PR116.1 v2(57.89,30.92)
  IN3 w0.102: v2(77.97,74.92) 77.97,72.96 79.19,71.74 79.19,68.82 78.06,67.69 78.06,66.19 73.84,61.97 73.84,51.49 76.38,48.95 82.23,48.95 84.42,46.75 84.42,45.48 v2(84.83,45.08) ; v2(125.14,11.43) 124.31,11.43 123.63,12.12 108.77,12.12 107.37,13.52 105.09,13.52 104.64,13.96 104.64,16.95 89.21,32.38 86.85,32.38 84.94,34.28 79.54,34.28 77.63,32.38 58.35,32.38 57.89,31.92 v2(57.89,30.92)
  BOTTOM w0.102: v2(84.83,45.08) 84.83,37.21 80.28,32.67 59.72,32.67 v1(58.95,31.9) 57.96,30.92 v2(57.89,30.92)
CMSRC: length 54.7
  TOP w0.102: v2(27.81,33.52) v1(27.11,33.52)
  TOP w0.254: PR763.2 28.39,32.94 v2(27.81,33.52)
  IN1 w0.254: v2(27.81,33.52) 24.95,33.52 24.12,32.69 24.12,24.25 22.41,22.53 22.41,18.6 26.79,14.22 27.62,14.22 32.59,9.24 37.88,9.24 39.62,10.98 47.43,10.98 48.48,12.02 48.48,12.91 48.82,13.26 v2(49.33,13.26)
  BOTTOM w0.203: PU703.29 49.19,13.12 v2(49.33,13.26)
COMP: length 4.6
  BOTTOM w0.203: PU703.10 42.93,12.32 v1(42.73,12.12) 42.54,11.93 42.54,11.46 PR754.2
  BOTTOM w0.254: PC751.2 PR754.2
COMP_IA: length 3.5
  BOTTOM w0.203: PC636.2 85.1,113.66 85.4,113.66 85.78,114.04 PU602.16
  BOTTOM w0.254: PC636.2 84.88,113.44 PR639.2
COMP_VSA: length 3.8
  BOTTOM w0.203: PR630.1 88.29,118.13 88.51,117.91 88.51,117.28 88.76,117.03 PU602.24
  BOTTOM w0.254: PR630.1 86.96,118.96 PC628.1
CORE_SNUB: length 1.8
  TOP w0.102: PR663.2 v1(109.13,113.51)
CORE_SW: length 48.5
  IN1 w0.254: v2(80.07,117.2) 80.79,117.93 82.15,117.93 82.61,118.39 88.77,118.39 90.09,119.71 93.53,119.71 95.02,118.23 96.1,118.23 98,116.32 109.89,116.32 111.21,117.64 116.54,117.64 v2(116.64,117.75)
  BOTTOM w0.254: PR661.1 80.7,115.12 80.07,115.75 v2(80.07,117.2) ; v2(116.64,117.75) 116.83,117.56 116.83,115.37 116.58,115.12 PL603.1
  vias: v1(112.13,116.89) v2(112.67,115.69) v2(112.67,115.05)
CPU_B+: length 92.8
  TOP w0.254: 101.91,118.67 100.89,119.69 v3(97.59,119.69) 96.39,119.69 95.24,118.54 PR603.2
  IN1 w1.524: 103.88,119.88 106.99,119.88 107.1,119.77 121.54,119.77 122.64,118.67 141.79,118.67 ; 101.47,119.31 100.04,120.73 76.16,120.73 75.62,120.2
  IN1 w2.54: 53.59,117.4 54.79,117.4 57.08,119.69 70.92,119.69
  vias: v2(49.59,118.1) v2(49.59,117.4) v2(49.59,116.77) v2(49.59,116.13) v2(50.16,117.78) v2(50.16,117.09) v2(50.16,116.45) v2(50.16,115.75) v2(72.64,119.56) v2(72.95,119.05) v2(73.27,119.56) v2(73.59,119.05) v2(73.91,119.56) v2(74.22,119.05) v2(74.54,119.56) v2(74.86,119.05) v2(101.59,117.97) v2(101.59,117.34) v2(102.23,117.97) v2(102.23,117.34) v2(102.89,115.24) v2(102.89,114.29) v2(103.6,115.24) v2(103.6,114.29) v2(143.25,119.56) v2(143.69,120.01) v2(144.07,119.56)
CPU_DPB_CTRLCLK_R: length 14.7
  TOP w0.089: v2(195.97,76.7) 195.97,76.51 QX4.6
  IN3 w0.102: v2(195.97,76.7) 195.97,76.82 196.04,76.88 196.52,76.88 199.45,79.82 202.44,79.82 202.88,80.26 202.88,82.03 JHDMI.15
  BOTTOM w0.089: RX16.1 197.49,76.56 197.16,76.89 v1(197.1,76.89) 196.16,76.89 v2(195.97,76.7)
CPU_DPB_CTRLDAT_R: length 14.6
  TOP w0.089: QX4.3 194.1,77.73 194.52,77.31 v2(195.83,77.31)
  IN3 w0.102: JHDMI.16 202.66,81.54 202.66,80.35 202.35,80.03 199.36,80.03 196.43,77.1 196.06,77.1 195.85,77.31 v2(195.83,77.31)
  BOTTOM w0.089: v2(195.83,77.31) 195.29,77.31 194.8,76.82 RX17.1
CPU_POPIRCOMP: length 10.1
  TOP w0.254: RC5.1 143.06,75.3 142.37,75.99 v1(142.37,78.16) 142.37,79.44 142.19,80.78 142.19,81.88 142.13,82.24 142.13,82.99 142.28,83.14 v2(142.58,83.4)
  BOTTOM w0.254: v2(142.58,83.4) 142.93,83.75 UC1.AT16
CPU_XDP_TCK0: length 10.4
  IN3 w0.102: v2(117.15,105.66) 117.6,106.1 118.55,106.1 v2(118.99,105.66)
  BOTTOM w0.076: UC1.A59 118.84,103.24 118.82,103.26 118.82,103.59 118.95,103.71 118.95,105.34 ; 117.15,105.34 117.43,105.06 117.43,102.95 117.45,102.93 117.45,102.51 117.51,102.39 117.51,102.17 UC1.B61
  BOTTOM w0.102: v2(118.99,105.66) 118.95,105.61 118.95,105.34 ; RC35.1 117.47,106.04 117.15,105.72 v2(117.15,105.66) 117.15,105.34
CS_1.35V: length 2.7
  TOP w0.102: v2(85.4,15.99) v1(85.4,16.76)
  TOP w0.254: v2(85.4,15.99) 85.4,15.12 PR205.2
  BOTTOM w0.203: PU200.13 85.3,15.89 v2(85.4,15.99)
CSI2_COMP: length 1.4
  TOP w0.254: RC80.2 144.41,100.34 v2(144.41,100.11)
  BOTTOM w0.254: v2(144.41,100.11) UC1.E13
DAT_SMB: length 3.9
  BOTTOM w0.254: PBATT.6 15.82,22.52 16.63,21.71 PR20.1
DAT_TP_SIO: length 139.4
  TOP w0.102: v2(21.2,58.08) 21.66,58.54 JTP.2 21.66,61.64 21.72,61.7 21.72,62.87 CE91.2 21.77,63.88 21.77,64.69 21.41,65.05 21.41,65.56 RE339.2 ; UE5.79 129.82,12.15 v1(129.34,12.63) 129.13,12.84 v2(129.13,13.14)
  IN1 w0.102: v2(21.2,58.08) 23.11,58.08 27.03,54.16 29.12,54.16 39.72,43.55 44.38,43.55 52.76,35.17 52.76,34.3 53.64,33.43 80.42,33.43 81.25,34.26 82.88,34.26 83.71,33.43 95.17,33.43 106.05,22.55 107.85,22.55 109.31,21.09 109.31,19.64 110.94,18.01 118.56,18.01 120.26,16.31 123.75,16.31 124.54,15.52 126.51,15.52 128.9,13.14 v2(129.13,13.14)
DBC_EN: length 258.2
  TOP w0.102: RC329.1 v2(162.54,60.14) ; RX23.1 v2(11.87,90.61) 12.12,90.61 v1(12.63,90.1)
  IN2 w0.102: v2(169.1,40.19) 167.07,40.19 165.02,42.23 159.74,42.23 157.28,39.76 91.45,39.76 88.28,36.59 82.03,36.59 80.12,34.69 55.97,34.69 45.58,45.08 42.23,45.08 32.34,54.97 32.34,61.94 25.2,69.08 25.2,79.37 24.28,80.29 24.28,87.79 23.72,88.35 19.08,88.35 16.46,90.97 12.23,90.97 v2(11.87,90.61)
  IN3 w0.076: v2(149.03,86.03) 149.03,85.89 149.35,85.57 149.35,79.05 151.25,77.14
  IN3 w0.102: v2(169.1,40.19) 169.27,40.35 169.27,43.39 168.75,43.91 168.75,49.67 163.76,54.66 163.76,56.21 162.11,57.86 162.11,59.71 v2(162.54,60.14) 162.54,61.4 161.97,61.97 161.54,61.97 160.35,63.16 160.35,64.05 156.43,67.97 156.43,68.71 156.88,69.16 156.88,70.82 156.43,71.26 156.43,73.42 154.3,75.56 152.84,75.56 151.25,77.14
  BOTTOM w0.076: UC1.AM5 149.35,86.35 v2(149.03,86.03)
DBC_EN_R: length 12
  TOP w0.102: RX49.1 11.16,88.76 v1(11.74,88.76) ; RX49.1 9.65,89.65 v2(9.58,89.59) ; RX49.1 RX23.2
  BOTTOM w0.102: JEDP.23 2.23,88 2.77,88.54 3.71,88.54 4.25,89.08 5.52,89.08 5.77,89.34 9.33,89.34 v2(9.58,89.59)
DDR_A_BS0: length 47.6
  IN1 w0.089: v2(123.35,82.74) 123.35,80.79 124.26,79.87 124.26,78.67 125.01,77.92 125.01,70.65 124.07,69.71 124.07,68.53
  IN1 w0.132: 124.07,68.53 124.07,59.23 125.52,57.78 125.52,57.59 125.27,57.34 125.27,57.15 125.45,56.97 125.64,56.97 125.89,57.22 126.08,57.22 126.27,57.03 126.27,56.84 126.01,56.59 126.01,56.41 126.2,56.22 126.39,56.22 126.64,56.47 126.83,56.47 127.01,56.28 127.01,56.1 126.76,55.84 126.76,55.66 126.95,55.47 127.14,55.47 127.39,55.72 127.57,55.72 127.76,55.54 127.76,55.35 127.51,55.1 127.51,54.91 127.7,54.72 127.88,54.72 128.13,54.98 128.32,54.98 128.51,54.79 128.51,54.6 128.26,54.35 128.26,54.16 128.44,53.98 128.63,53.98 128.88,54.23 129.07,54.23 129.26,54.04 129.26,53.85 129,53.6 129,53.42 130.1,52.32 130.1,49.27 131.26,48.1 v2(131.26,46.24)
  BOTTOM w0.076: v2(123.35,82.74) 122.99,83.1 UC1.AU52
  BOTTOM w0.165: v2(131.26,46.24) 130.95,46.55 JDIMM1.109
DDR_A_BS1: length 50.5
  IN1 w0.089: 124.84,68.58 124.84,69.59 125.44,70.19 125.44,78.26 124.9,78.79 124.9,80.26 124.01,81.14 124.01,83.1 v2(124.36,83.44)
  IN1 w0.132: 124.84,68.58 124.84,61.5 126.67,59.67 126.67,57.72 131.69,52.7 131.69,48.42 132.06,48.04 132.06,45.71 131.93,45.58 131.82,45.58 131.69,45.45 131.69,45.18 131.82,45.05 131.93,45.05 132.06,44.92 132.06,44.48 131.93,44.36 131.39,44.36 131.26,44.48 v2(131.26,44.72)
  BOTTOM w0.076: UC1.AT48 124.67,83.75 v2(124.36,83.44)
  BOTTOM w0.165: JDIMM1.108 130.65,44.1 v2(131.26,44.72)
DDR_A_BS2: length 49.3
  IN1 w0.132: v2(118.45,73.19) 118.02,72.76 118.02,71.85 116.36,70.2 116.36,53.08 119.69,49.75 119.69,48.96 120.54,48.11 120.54,43.01 120.33,42.79 120.07,42.79 119.78,43.08 v2(119.78,43.09)
  BOTTOM w0.076: 119.11,76.19 119.11,76.43 120.94,78.27 120.94,78.91 121.28,79.25 121.28,79.56 121.08,79.76 121.08,80.13 121.09,80.16 121.13,80.24 121.13,80.36 121.06,80.58 121.06,80.72 121.12,80.88 121.12,81.06 121.04,81.22 120.75,81.51 UC1.AY55
  BOTTOM w0.102: 119.11,76.19 119.11,73.85 v2(118.45,73.19)
  BOTTOM w0.165: v2(119.78,43.09) 120.68,43.99 120.68,45.81 121.33,46.46 121.6,46.46 121.95,46.81 JDIMM1.79
DDR_A_CAS#: length 50.9
  IN1 w0.089: 126,68.56 125.99,68.56 125.99,78.56 126.31,78.87 126.31,82.09 125.72,82.67 125.72,82.99 125.17,83.54 v2(125.17,84.11)
  IN1 w0.132: v2(133.64,43.19) 133.22,43.61 133.22,48.52 132.84,48.9 132.84,53.18 127.83,58.2 127.83,60.15 126,61.98 126,68.56
  BOTTOM w0.076: UC1.AU48 124.75,83.34 125.17,83.76 v2(125.17,84.11)
  BOTTOM w0.165: v2(133.64,43.19) 133.45,43.19 132.75,43.89 JDIMM1.115
DDR_A_CKE0: length 48.4
  IN1 w0.132: v2(118.48,73.76) 117.64,72.92 117.64,72 115.98,70.34 115.98,52.92 118.53,50.37 118.53,50.18 118.27,49.92 118.27,49.74 118.46,49.55 118.64,49.55 118.9,49.81 119.09,49.81 119.3,49.59 119.3,48.55 119.44,48.42 119.69,48.42 119.82,48.29 119.82,48.01 119.69,47.89 119.35,47.89 119.22,47.76 119.22,47.49 119.35,47.36 120.03,47.36 120.15,47.23 120.15,46.96 120.03,46.83 119.35,46.83 119.22,46.7 119.22,46.43 119.35,46.3 119.64,46.3 119.77,46.18 119.77,45.9 119.64,45.77 119.35,45.77 119.22,45.65 119.22,44.58 119.3,44.5 119.7,44.5 119.78,44.58 v2(119.78,44.61)
  BOTTOM w0.076: UC1.BA56 120.19,80.49 120.04,80.35 120.04,80.34 120.04,80.34 119.93,80.12 119.93,79.8 119.98,79.75 119.98,79.04 120.11,78.92 120.11,78.49 119.71,78.09 119.55,78.09 117.79,76.33 117.79,75.97
  BOTTOM w0.102: 117.79,75.97 117.79,74.93 118.04,74.68 118.04,74.19 v2(118.48,73.76)
  BOTTOM w0.165: JDIMM1.73 120.15,46.53 119.22,45.6 119.22,45.17 v2(119.78,44.61)
DDR_A_CKE1: length 47.5
  IN1 w0.132: v2(118.5,74.92) 116.93,73.35 116.93,71.84 115.59,70.5 115.59,51.87 115.67,51.79 115.85,51.79 116.12,52.05 116.3,52.05 116.49,51.86 116.49,51.68 116.23,51.42 116.23,51.23 116.41,51.05 116.6,51.05 116.86,51.31 117.04,51.31 117.24,51.11 117.24,50.93 116.97,50.67 116.97,50.49 117.16,50.3 117.35,50.3 117.48,50.43 117.66,50.43 117.85,50.23 117.85,50.05 117.72,49.92 117.72,49.74 118.84,48.62 118.84,42.51 v2(119.78,41.57)
  BOTTOM w0.076: 118.05,76.04 118.05,76.36 119.6,77.91 119.76,77.91 120.27,78.42 120.27,78.99 120.15,79.11 120.15,79.95 UC1.BB56
  BOTTOM w0.102: 118.05,76.04 118.05,75.36 v2(118.5,74.92)
  BOTTOM w0.165: JDIMM1.74 120.45,40.9 v2(119.78,41.57)
DDR_A_CLK0: length 49.2
  IN1 w0.089: v2(121.52,83.41) 122.15,83.41 122.67,82.89 122.67,80.83 123.82,79.68 123.82,78.48 124.8,77.5 124.8,70.83 123.75,69.79 123.75,67.42 123.58,67.24 123.58,58.15 129.61,52.12 129.61,49.07 130.34,48.34 130.34,44.8 130.07,44.54 129.87,44.54 v2(129.66,44.33)
  BOTTOM w0.076: v2(121.52,83.41) 121.97,83.75 UC1.AT53
  BOTTOM w0.102: v2(129.66,44.33) 129.52,44.48 129.04,44.48 128.59,44.93 128.59,46.55 128.55,46.59 JDIMM1.101
DDR_A_CLK1: length 49.8
  IN1 w0.089: v2(120.59,83.37) 120.84,83.13 120.97,83.13 121.15,82.95 121.15,80.07 123.31,77.91 123.31,67.62 122.92,67.23 122.92,57.88 128.95,51.85 128.95,42.74 129.13,42.56 129.42,42.56 v2(129.66,42.81)
  BOTTOM w0.076: UC1.AT55 v2(120.59,83.37)
  BOTTOM w0.102: JDIMM1.102 128.85,40.5 128.96,40.62 128.96,42.4 129.19,42.63 129.48,42.63 v2(129.66,42.81)
DDR_A_CLK#0: length 49.2
  IN1 w0.089: v2(121.52,82.77) 121.72,82.77 121.8,82.85 121.8,83.15 121.87,83.23 122.07,83.23 122.49,82.81 122.49,80.75 123.64,79.61 123.64,78.4 124.61,77.42 124.61,70.91 123.57,69.87 123.57,67.5 123.39,67.32 123.39,58.07 129.42,52.04 129.42,48.99 130.15,48.26 130.15,44.88 130,44.72 129.79,44.72 129.66,44.84 v2(129.66,45.1)
  BOTTOM w0.076: v2(121.52,82.77) 121.97,83.1 UC1.AU53
  BOTTOM w0.102: v2(129.66,45.1) 129.66,44.89 129.47,44.7 129.13,44.7 128.81,45.02 128.81,46.38 129.15,46.72 JDIMM1.103
DDR_A_CLK#1: length 49.8
  IN1 w0.089: v2(120.59,82.73) 120.8,82.94 120.9,82.94 120.97,82.87 120.97,79.99 123.13,77.83 123.13,67.69 122.74,67.31 122.74,57.8 128.77,51.77 128.77,42.66 129.06,42.38 129.33,42.38 v2(129.66,42.05)
  BOTTOM w0.076: v2(120.59,82.73) 120.59,82.74 120.82,82.9 UC1.AU55
  BOTTOM w0.102: v2(129.66,42.05) 129.66,42.31 129.56,42.41 129.28,42.41 129.18,42.31 129.18,40.89 129.45,40.62 JDIMM1.104
DDR_A_CS#0: length 53.1
  IN1 w0.089: v2(127.04,82.69) 127.46,83.11 127.95,83.11 128.13,82.93 128.13,82.17 128.45,81.84 128.45,76.56 128.59,76.42 128.59,72.82 127.99,72.21
  IN1 w0.132: 127.99,72.21 127.32,71.55 127.32,68.52 127.16,68.35 127.16,62.46 134.46,55.16 134.46,41.13 133.81,40.48 133.46,40.48 133.22,40.73 133.22,41.25 v2(133.64,41.67)
  BOTTOM w0.076: v2(127.04,82.69) 126.62,83.1 UC1.AU45
  BOTTOM w0.165: v2(133.64,41.67) 133.38,41.67 132.45,40.74 JDIMM1.114
DDR_A_CS#1: length 53.8
  IN1 w0.089: v2(127.76,82.69) 127.76,79.73 127.52,79.49 127.52,72.28 127.37,72.13
  IN1 w0.132: 127.37,72.13 127.1,71.85 127.1,68.61 126.77,68.28 126.77,62.3 131.14,57.93 131.14,57.75 131,57.61 131,57.43 131.2,57.24 131.38,57.24 131.51,57.37 131.7,57.37 131.89,57.19 131.89,57 131.1,56.21 131.1,56.02 131.28,55.84 131.47,55.84 132.26,56.63 132.45,56.63 132.63,56.44 132.63,56.25 131.84,55.46 131.84,55.28 132.03,55.09 132.22,55.09 133.01,55.88 133.2,55.88 133.38,55.69 133.38,55.51 132.59,54.71 132.59,54.53 132.78,54.34 132.96,54.34 133.76,55.13 133.94,55.13 134.07,55 134.07,44.82 133.97,44.72 v2(133.64,44.72)
  BOTTOM w0.076: v2(127.76,82.69) 127.5,82.96 UC1.AU43
  BOTTOM w0.165: JDIMM1.121 134.55,45.3 133.96,44.72 v2(133.64,44.72)
