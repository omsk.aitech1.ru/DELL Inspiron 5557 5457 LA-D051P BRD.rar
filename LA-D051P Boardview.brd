# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
FB_A_DQM5: length 23.5
  TOP w0.102: v2(43.62,68.83) 43.62,68.06 43.32,67.76 UV6.E7
  IN3 w0.102: 47.15,68.71 46.97,68.71 46.28,69.4 45.01,69.4 44.63,69.02 44.63,68.44 44.51,68.32 43.3,68.32 43.17,68.44 43.17,68.7 43.3,68.83 v2(43.62,68.83) ; v2(57.12,70.19) 56.65,69.72 54.52,69.72 53.02,68.23
  IN3 w0.127: 53.02,68.23 51.94,68.23 51.81,68.1 51.81,67.86 51.68,67.73 49.88,67.73 49.75,67.86 49.75,68.58 49.63,68.71 49.37,68.71 49.24,68.58 49.24,67.86 49.12,67.73 48.86,67.73 48.74,67.86 48.74,68.58 48.61,68.71 47.15,68.71
  BOTTOM w0.102: v2(43.62,68.83) 43.62,69.2 43.32,69.5 UV14.E7
  BOTTOM w0.127: UV1.W24 56.74,70.58 v2(57.12,70.19)
FB_A_DQM6: length 18.4
  TOP w0.102: UV6.D3 44.49,70.43 44.62,70.3 44.62,69.97 44.49,69.84 44.25,69.84 44.12,69.71 44.12,69.42 v2(44.31,69.22)
  IN1 w0.102: v2(44.31,69.22) 44.31,69.7 44.5,69.88 48.87,69.88 50.92,67.83 55.11,67.83 55.34,68.05 55.88,68.05 v2(56.31,68.49)
  BOTTOM w0.102: UV14.D3 44.31,67.42 v2(44.31,69.22)
  BOTTOM w0.127: UV1.AA25 v2(56.31,68.49)
FB_A_DQM7: length 23.6
  TOP w0.102: v2(44.42,83.11) 44.42,84.04 44.12,84.34 UV7.D3
  IN1 w0.102: v2(44.42,83.11) 44.42,82.99 44.92,82.49 48.32,82.49 51.66,79.15 51.66,73.36 52.71,72.31 55.01,72.31 v2(55.54,71.78)
  BOTTOM w0.102: UV15.D3 44.3,81.7 44.42,81.81 44.42,82.51 44.57,82.67 44.57,82.96 v2(44.42,83.11)
  BOTTOM w0.127: UV1.U25 55.9,72.14 v2(55.54,71.78)
FB_A_DQS0: length 22.9
  TOP w0.102: v2(54.87,96.83) 55.06,97.02 55.59,97.02 56.04,97.47 56.17,97.47 UV9.F3
  IN3 w0.127: v2(54.87,96.83) 55.05,97.01 55.19,97.01 55.28,96.92 55.28,92.41 59.18,88.51 59.18,85.43 60.89,83.72 60.89,81.97 60.73,81.81 v2(60.46,81.81)
  BOTTOM w0.102: v2(54.87,96.83) 54.68,97.02 54.34,97.02 53.94,97.42 53.51,97.42 UV4.F3
  BOTTOM w0.112: UV1.E19 60.88,81.97 60.72,81.81 v2(60.46,81.81)
FB_A_DQS1: length 21.2
  TOP w0.102: v2(69.35,96.88) 69.54,97.07 70.17,97.07 70.51,97.41 70.72,97.41 UV5.F3
  IN1 w0.102: v2(64.62,84.22) 64.62,83.95 64.75,83.81 64.95,83.81 65.08,83.94 65.08,84.45 64.75,84.77 64.75,85.96 68.77,89.98 68.77,93.61 68.5,93.88 68.5,95.99 68.83,96.32 68.83,96.98 68.93,97.08 69.15,97.08 v2(69.35,96.88)
  BOTTOM w0.102: UV8.F3 67.94,97.37 68.09,97.37 68.39,97.08 69.15,97.08 v2(69.35,96.88)
  BOTTOM w0.112: UV1.C15 64.21,83.85 64.53,83.85 64.62,83.93 v2(64.62,84.22)
FB_A_DQS2: length 17.4
  TOP w0.102: UV5.C7 68.05,94.48 69.15,94.48 v2(69.35,94.67)
  IN3 w0.127: v2(63.01,84.99) 63.35,85.32 63.54,85.32 63.81,85.59 63.81,86.48 70.11,92.77 70.11,94.28 69.79,94.59 69.43,94.59 v2(69.35,94.67)
  BOTTOM w0.102: v2(69.35,94.67) 69.54,94.48 70.65,94.48 UV8.C7
  BOTTOM w0.112: UV1.B16 63.36,84.64 v2(63.01,84.99)
FB_A_DQS3: length 16.2
  TOP w0.102: v2(54.87,94.47) 54.68,94.27 53.78,94.27 UV9.C7
  IN1 w0.102: v2(54.87,94.47) 54.76,94.36 54.33,94.36 54.15,94.18 54.15,93.14 54.58,92.72 54.58,91.22 58.06,87.73 v2(58.06,87.4)
  BOTTOM w0.102: v2(54.87,94.47) 54.89,94.45 56.14,94.45 UV4.C7
  BOTTOM w0.112: 57.85,86.22 57.75,86.12 57.75,84.96 58,84.72 58.28,84.72 UV1.B22
  BOTTOM w0.127: v2(58.06,87.4) 57.91,87.24 57.91,86.28 57.85,86.22
FB_A_DQS4: length 26.6
  TOP w0.102: UV7.F3 42.28,84.67 42.28,84.44 42.68,84.05 42.68,83.5 v2(42.87,83.3)
  IN3 w0.114: 46.86,82.6 46.86,83.44 46.59,83.71 42.77,83.71 42.67,83.6 42.67,83.43 42.79,83.3 v2(42.87,83.3) ; 53.11,74.48 53.29,74.48 53.4,74.37 53.4,74.03 53.63,73.8 54.17,73.8 54.53,74.16 54.75,74.16 55.01,73.91 55.27,73.91 55.34,73.84 55.42,73.84 55.5,73.76 v2(55.5,73.52)
  IN3 w0.127: 53.11,74.48 52.48,73.85 52.13,73.85 51.68,74.3 51.68,74.63 51.91,74.86 51.91,75.01 51.69,75.23 51.51,75.23 51.46,75.19 51.31,75.03 51.28,75.03 50.95,75.03 47.75,78.23 47.75,81.71 46.86,82.6
  BOTTOM w0.102: UV15.F3 42.22,82 42.22,82.04 42.68,82.49 42.68,83.11 v2(42.87,83.3)
  BOTTOM w0.112: v2(55.5,73.52) 55.58,73.52 55.9,73.84 UV1.R25
FB_A_DQS5: length 23.7
  TOP w0.102: UV6.F3 42.33,70.23 42.33,70.08 42.62,69.79 42.62,69.02 v2(42.82,68.83)
  IN3 w0.102: 52.76,68.73 53.18,68.73 54.38,69.94 56.31,69.94 57.09,70.71 57.65,70.71 57.97,70.39 57.97,70.3 v2(57.86,70.19) ; 47.15,69.22 47.14,69.22 47.12,69.23 46.81,69.23 46.36,69.68 43.49,69.68 43.22,69.4 42.66,69.4 42.53,69.27 42.53,69.07 42.77,68.83 v2(42.82,68.83)
  IN3 w0.127: 47.15,69.22 50.13,69.22 50.26,69.09 50.26,68.52 50.54,68.24 51.15,68.24 51.43,68.52 51.43,69.09 51.56,69.22 52.06,69.22 52.54,68.73 52.76,68.73
  BOTTOM w0.102: UV1.W23 57.86,70.22 v2(57.86,70.19) ; UV14.F3 42.22,67.52 42.22,67.67 42.62,68.07 42.62,68.64 v2(42.82,68.83)
FB_A_DQS6: length 15.7
  TOP w0.102: UV6.C7 45.22,67.52 45.22,68.63 v2(45.03,68.82)
  IN1 w0.102: v2(45.03,68.82) 45.22,69.02 45.22,69.18 45.44,69.4 48.67,69.4 50.72,67.35 53.68,67.35 53.97,67.06 v2(54.14,67.06)
  BOTTOM w0.102: v2(45.03,68.82) 45.22,69.02 45.22,70.12 UV14.C7
  BOTTOM w0.112: UV1.AB26 55.01,68.01 55.01,67.76 54.69,67.44 54.36,67.44 54.14,67.22 v2(54.14,67.06)
FB_A_DQS7: length 23.3
  TOP w0.102: v2(45.17,83.3) 45.27,83.2 45.27,82.05 UV7.C7
  IN1 w0.102: v2(45.17,83.3) 45.39,83.08 45.39,82.94 45.65,82.69 46.58,82.69 46.86,82.97 48.52,82.97 52.14,79.35 52.14,76.19 52.36,75.98 52.45,75.98 52.55,75.87 52.55,75.57 52.45,75.47 52.36,75.47 52.14,75.25 52.14,74.79 52.36,74.57 52.45,74.57 52.55,74.47 52.55,74.16 52.45,74.06 52.36,74.06 52.14,73.84 52.14,73.56 52.93,72.76 54.22,72.76 54.5,73.04 54.5,73.31 v2(54.71,73.52)
  BOTTOM w0.102: v2(45.17,83.3) 45.36,83.5 45.36,84.46 UV15.C7
  BOTTOM w0.112: v2(54.71,73.52) 55.1,73.12 UV1.T26
FB_A_DQS#0: length 22.9
  TOP w0.102: v2(54.87,97.41) 55,97.28 55.48,97.28 55.93,97.73 56.23,97.73 UV9.G3
  IN3 w0.127: v2(54.87,97.41) 55.01,97.27 55.3,97.27 55.54,97.03 55.54,92.52 59.44,88.62 59.44,85.54 61.16,83.83 61.16,81.91 v2(61.25,81.81)
  BOTTOM w0.102: UV4.G3 53.57,97.67 54.05,97.67 54.45,97.28 54.74,97.28 v2(54.87,97.41)
  BOTTOM w0.112: v2(61.25,81.81) 60.88,81.44 UV1.F19
FB_A_DQS#1: length 21.2
  TOP w0.102: UV5.G3 70.58,97.61 70.42,97.61 70.09,97.28 69.54,97.28 v2(69.35,97.47)
  IN1 w0.102: v2(69.35,97.47) 69.16,97.28 68.85,97.28 68.63,97.06 68.63,96.4 68.3,96.07 68.3,93.8 68.57,93.53 68.57,90.06 64.56,86.04 64.56,84.72 64.22,84.38 64.22,84.07 64.56,83.73 v2(64.56,83.46)
  BOTTOM w0.102: UV8.G3 68.15,97.57 68.17,97.57 68.47,97.27 69.15,97.27 v2(69.35,97.47)
  BOTTOM w0.112: v2(64.56,83.46) 64.89,83.8 UV1.C14
FB_A_DQS#2: length 17.3
  TOP w0.102: v2(69.35,94.09) 69.16,94.27 68.04,94.27 UV5.B7
  IN3 w0.127: v2(63.03,86.13) 62.92,86.02 62.92,85.9 63.24,85.59 63.43,85.59 63.54,85.7 63.54,86.59 69.84,92.88 69.84,94.17 69.68,94.33 69.54,94.33 69.35,94.14 v2(69.35,94.09)
  BOTTOM w0.102: UV8.B7 70.64,94.28 69.54,94.28 v2(69.35,94.09)
  BOTTOM w0.112: v2(63.03,86.13) 63.36,85.8 UV1.A16
FB_A_DQS#3: length 16.1
  TOP w0.102: v2(54.87,93.88) 54.69,94.07 53.36,94.07 UV9.B7
  IN1 w0.102: v2(58.67,87.4) 54.77,91.3 54.77,92.8 54.35,93.22 54.35,94.1 54.41,94.16 54.59,94.16 v2(54.87,93.88)
  BOTTOM w0.102: UV4.B7 56.26,94.19 55.18,94.19 v2(54.87,93.88)
  BOTTOM w0.112: UV1.A22 58.4,85.05 58.33,84.98 58.11,84.98 58.02,85.08 58.02,85.99 58.05,86.02
  BOTTOM w0.127: v2(58.67,87.4) 58.19,86.92 58.19,86.16 58.05,86.02
FB_A_DQS#4: length 26.7
  TOP w0.102: v2(42.29,83.3) 42.42,83.44 42.42,83.94 42.02,84.33 42.02,84.6 UV7.G3
  IN3 w0.114: 47.11,82.75 47.11,82.75 47.11,83.55 46.69,83.96 42.67,83.96 42.42,83.72 42.42,83.44 v2(42.29,83.3) ; 53,74.73 53.4,74.73 53.65,74.48 53.65,74.14 53.74,74.05 54.06,74.05 54.42,74.41 54.86,74.41 55.11,74.16 55.44,74.16 v2(55.49,74.21)
  IN3 w0.127: 47.11,82.75 47.11,82.74 47.66,82.19 48.02,81.83 48.02,78.34 51.06,75.3 51.17,75.3 51.17,75.3 51.2,75.3 51.4,75.5 51.8,75.5 52.18,75.12 52.18,74.75 51.95,74.52 51.95,74.41 52.24,74.12 52.39,74.12 53,74.73
  BOTTOM w0.102: UV15.G3 41.96,81.95 41.96,82.14 42.42,82.6 42.42,83.17 v2(42.29,83.3)
  BOTTOM w0.112: v2(55.49,74.21) 55.9,74.62 UV1.P25
FB_A_DQS#5: length 23.6
  TOP w0.102: v2(42.23,68.83) 42.42,69.02 42.42,69.7 42.12,70 42.12,70.02 UV6.G3
  IN3 w0.102: v2(57.92,70.95) 56.99,70.95 56.21,70.18 54.28,70.18 53.08,68.97 52.88,68.97 52.87,68.99 52.79,68.99 52.77,69 52.76,69 ; 47.15,69.48 47.14,69.48 47.12,69.47 46.91,69.47 46.46,69.92 43.39,69.92 43.12,69.64 42.56,69.64 42.29,69.37 42.29,68.88 v2(42.23,68.83)
  IN3 w0.127: 52.76,69 52.65,69 52.17,69.48 51.45,69.48 51.16,69.2 51.16,68.63 51.03,68.51 50.65,68.51 50.53,68.63 50.53,69.2 50.24,69.48 47.15,69.48
  BOTTOM w0.102: v2(42.23,68.83) 42.42,68.64 42.42,68.15 42.02,67.75 42.02,67.53 UV14.G3 ; UV1.W22 58.3,70.58 v2(57.92,70.95)
FB_A_DQS#6: length 15.7
  TOP w0.102: UV6.B7 45.42,67.53 45.42,68.63 v2(45.61,68.82)
  IN1 w0.102: v2(53.63,66.82) 53.63,67.07 53.55,67.15 50.64,67.15 48.59,69.21 45.52,69.21 45.41,69.1 45.41,69.02 v2(45.61,68.82)
  BOTTOM w0.102: UV14.B7 45.42,70.13 45.42,69.01 v2(45.61,68.82)
  BOTTOM w0.112: UV1.AB27 54.33,68.13 54.64,68.13 54.74,68.03 54.74,67.87 54.58,67.71 54.25,67.71 53.73,67.19 53.73,66.92 v2(53.63,66.82)
FB_A_DQS#7: length 23.2
  TOP w0.102: UV7.B7 45.52,81.9 45.52,83.07 v2(45.75,83.3)
  IN1 w0.102: v2(45.75,83.3) 45.59,83.14 45.59,83.02 45.73,82.88 46.5,82.88 46.78,83.16 48.6,83.16 52.34,79.43 52.34,76.27 52.44,76.17 52.53,76.17 52.75,75.96 52.75,75.49 52.53,75.27 52.44,75.27 52.34,75.17 52.34,74.87 52.44,74.76 52.53,74.76 52.75,74.55 52.75,74.08 52.53,73.87 52.44,73.87 52.34,73.76 52.34,73.64 53.02,72.96 54.14,72.96 54.3,73.12 54.3,73.58 54.25,73.64 54.12,73.64 53.93,73.44 v2(53.93,73.42)
  BOTTOM w0.102: v2(45.75,83.3) 45.57,83.49 45.57,84.75 UV15.B7
  BOTTOM w0.112: v2(53.93,73.42) 54.03,73.52 54.2,73.52 54.35,73.37 54.35,73.11 UV1.T27
FB_CLAMP: length 11.8
  TOP w0.102: RPV7.4 84.59,79.51 84.02,80.08 81,80.08 v2(80.96,80.04)
  BOTTOM w0.102: v2(80.96,80.04) v1(77.91,80.04) 76.66,80.04 75.8,80.91 74.46,80.91 74.1,81.27 UV1.F3
FB_IA: length 6.3
  TOP w0.102: v2(82.53,114.43) v1(82.53,115.29)
  TOP w0.254: PR650.1 v2(82.53,114.43)
  BOTTOM w0.203: PU602.17 85.67,114.44 85.27,114.04 84.63,114.04 PR645.2
  BOTTOM w0.254: PR645.2 84.05,114.62 PR648.2 82.72,114.62 v2(82.53,114.43)
FB_VREF: length 1.3
  TOP w0.102: T2401.1 57.34,83.71 v2(57.12,83.5)
  BOTTOM w0.134: v2(57.12,83.5) 57.55,83.07 UV1.D23
FB_VSA: length 4.7
  TOP w0.102: v2(89.02,117.47) 88.7,117.15 v1(88.58,117.15)
  TOP w0.254: v2(89.02,117.47) 89.02,117.83 PR652.1 90.24,119.05 PR649.1
  BOTTOM w0.203: PU602.25 89.16,117.09 89.02,117.22 v2(89.02,117.47)
  BOTTOM w0.254: v2(89.02,117.47) 89.02,117.96 PR646.1
FCCM_GT: length 26.3
  IN1 w0.254: v2(75.71,110.84) 77.45,112.58 82.99,112.58 83.62,111.94 85.91,111.94 v2(86.04,111.81)
  BOTTOM w0.102: PR671.2 v1(78.47,99.3) 78.35,99.42 78.35,103.31 77.08,104.58 77.08,108.7 75.71,110.07 v2(75.71,110.84)
  BOTTOM w0.203: v2(86.04,111.81) 86.26,112.04 PU602.11
FCCM_IA: length 16.1
  IN1 w0.254: v2(87.12,116.89) 87.34,116.89 87.69,116.54 91.22,116.54 91.75,116.01 92.51,116.01 93.4,116.89 93.85,116.89 96.13,114.61 98.1,114.61 98.42,114.29 v2(98.42,113.97)
  BOTTOM w0.203: v2(87.12,116.89) 87.37,116.89 87.56,116.7 PU602.21
  BOTTOM w0.254: v2(98.42,113.97) 98.42,113.85 98.8,113.47 99.14,113.47 99.65,112.96 PR659.2
FCCM_VSA: length 69.5
  IN2 w0.254: v2(92.26,117.02) 92.83,117.02 93.4,117.59 97.18,117.59 98,116.77 104.86,116.77 105.43,116.2 110.09,116.2 113.07,119.18 121.18,119.18 122.55,117.81 143.82,117.81 144.65,116.98 v2(144.65,114.67)
  BOTTOM w0.203: v2(92.26,117.02) 92.18,117.1 91.07,117.1 90.76,116.79 PU602.29
  BOTTOM w0.254: v2(144.65,114.67) 144.65,113.28 145.54,112.39 v1(148.08,112.39) 150.68,112.39 151.39,113.1 PR679.2
FW_UPDATE: length 313.8
  TOP w0.076: DC5.2 149.68,85.32 v2(149.98,85.02)
  TOP w0.102: DX8.2 160.4,4.95 v3(161.79,6.34) v2(161.79,8.56) ; RI55.2 16.69,59.41 16.2,58.92 16.2,53.47 v2(15.8,53.08)
  IN1 w0.102: v2(161.79,8.56) 159.71,8.56 159.16,9.11 148.74,9.11 148.28,9.57 145.27,9.57 145.09,9.39 142.23,9.39 142.11,9.52 136.93,9.52 135.71,10.74 133.41,10.74 132.23,11.92 128.15,11.92 127.69,12.37 127.69,13.65 127,14.34 121.48,14.34 118.42,17.4 110.71,17.4 107.24,20.87 107.24,21.58 106.74,22.09 105.86,22.09 94.98,32.97 53.45,32.97 52.19,34.22 52.19,34.98 44.08,43.1 38.56,43.1 29.08,52.58 16.3,52.58 v2(15.8,53.08)
  IN3 w0.076: v2(149.98,85.02) 149.68,84.72 149.68,79.33 151.1,77.91 151.63,77.91 152.39,77.14
  IN3 w0.102: v2(161.79,8.56) 163.38,6.98 176.27,6.98 180.59,11.29 180.59,17.83 178.44,19.98 178.44,22.97 176.8,24.62 176.8,33.82 181.59,38.61 182.19,38.61 184.63,41.05 184.63,53.39 183.06,54.96 178.9,54.96 177.58,56.28 173.64,56.28 173.31,55.95 173.31,55.61 172.73,55.03 170.65,55.03 168.84,56.84 167.2,56.84 165.18,58.85 165.18,59.85 164.36,60.68 164.36,61.85 163.48,62.73 163.48,63.53 163.66,63.71 163.66,64.99 160.69,67.97 160.69,70.94 154.61,77.01 152.52,77.01 152.39,77.14
  BOTTOM w0.102: JCAM3D.3 11.56,52 RI89.2 14.48,51.76 v2(15.8,53.08)
FW_UPDATE_EC: length 55
  TOP w0.102: v2(158.11,2.85) 158.1,2.86 DX8.1 ; UE5.113 v2(139,5) ; v2(112.07,5.09) v1(112.07,4.56) 112.07,2.96 RE403.2
  IN1 w0.102: v2(158.11,2.85) 157.73,3.23 143.7,3.23 141.93,5 v2(139,5) 139,4.99 137.34,3.33 129.94,3.33 129.05,2.44 125.72,2.44 125.29,2.87 124.92,2.87 124.15,2.1 122.8,2.1 121.68,3.22 120.47,3.22 118.55,5.13 114.67,5.13 114.22,4.68 112.48,4.68 v2(112.07,5.09)
FW_UPDATE_R: length 3.2
  TOP w0.076: v2(148.99,84.64) 150.46,84.64 DC5.1 v1(151.28,84.23)
  BOTTOM w0.076: UC1.AP5 149.41,85.05 v2(148.99,84.64)
GC6_FB_EN: length 94.9
  TOP w0.102: RC195.2 160.41,59.72 160.41,60.67 161.25,61.51 161.25,61.68 161.28,61.71 161.28,62.35 161.26,62.37 161.26,63.72 v2(161.03,63.95) ; UV23.2 83.56,76.87 v2(82.8,76.87) RV88.2 81.19,76.87 RV202.2
  BOTTOM w0.102: v2(161.03,63.95) 160.84,63.95 160.4,64.39 158.24,64.39 157.69,63.84 156.65,63.84 156.39,63.58 152.88,63.58 150.63,65.84 101.28,65.84 87.55,79.57 85.5,79.57 v1(84.56,78.62) v2(82.8,76.87)
GC6_THM_DIS#: length 145
  TOP w0.102: v2(139.25,20.62) 139.4,20.46 UE5.47 ; v2(172.37,55.68) 170.59,55.68 170.15,56.13 167.51,56.13 167.2,55.81 167.2,53.85 165.25,51.9 156.06,51.9 154.12,49.95 154.12,34.22 154.82,33.52 154.82,28.28 155.8,27.3 155.8,25.47 155.21,24.88 154.01,24.88 153.85,24.73 v2(152.67,24.73)
  IN1 w0.076: v2(153.38,102.4) 154.26,101.53 154.87,101.53
  IN1 w0.102: v2(172.37,55.68) 172.37,55.95 172.56,56.15 174.91,58.49 174.91,60.16 175.47,60.72 175.47,64.34 176.29,65.16 176.29,77.28 174.67,78.91 174.67,81.74 173.35,83.06 173.35,90.81 173.35,91.86 165.84,99.37 162.52,99.37 160.36,101.53 154.87,101.53
  IN3 w0.102: v2(152.67,24.73) 152.67,24.38 152.29,23.99 147.1,23.99 146,22.89 143.66,22.89 142.96,22.19 140.87,22.19 139.29,20.62 v2(139.25,20.62)
  BOTTOM w0.076: UC1.J3 150.8,98.6 151.15,98.95 151.15,99.29 151.43,99.57 151.43,99.88 151.75,100.19 151.75,101.15 151.91,101.31 153.05,101.31 153.38,101.64 v2(153.38,102.4) 153.38,102.81 153.85,103.28 153.85,103.62 154.1,103.86 154.83,103.86
  BOTTOM w0.102: 154.83,103.86 154.95,103.98 154.95,105.01 155.37,105.43 157.27,105.43 157.85,106.01 RC206.1 ; v2(172.37,55.68) v1(171.81,55.68)
GPIO0_GC6_FB_EN: length 13.8
  TOP w0.102: RV202.1 78.73,78.38 78.73,79.37 v1(77.56,80.54) 75.6,82.5 71.95,82.5 71.51,82.94 71.51,83.65 v2(72.02,84.16)
  BOTTOM w0.102: UV1.C6 71.96,84.16 v2(72.02,84.16)
GPIO8_OVERT#: length 22.2
  TOP w0.102: RV69.1 78.58,83.52 v1(76.61,85.49) 75.85,86.25 73.06,86.25 71.99,85.18 v2(71.99,85.03) ; QV4.3 v2(77.92,76.71)
  IN3 w0.076: v2(71.99,85.03) 72.51,84.51 72.51,83.18 74.86,80.83 74.86,79.24 76.13,77.97
  IN3 w0.102: v2(77.92,76.71) 77.38,76.71 76.13,77.97
  BOTTOM w0.102: UV1.A6 71.62,85.4 v2(71.99,85.03)
GPIO9_ALERT#: length 19.3
  TOP w0.076: v2(70.42,81.77) 70.42,81.78 v1(70.1,82.11)
  IN3 w0.102: v2(70.42,81.77) 70.42,79.97 72.46,77.93 72.93,77.93 75.81,75.05 75.81,74.41 78.73,71.49 78.73,69.26 v2(78.42,68.95)
  BOTTOM w0.102: UV1.F8 70.01,81.36 v2(70.42,81.77) ; v2(78.42,68.95) 78.65,69.18 RPV6.1
GPU_B+:
  vias: v1(83.43,106.8) v2(82.35,104.7) v2(82.35,104.07) v2(82.35,103.43) v2(82.67,102.23) v2(82.67,101.27) v2(82.67,100.32) v2(83.37,101.72) v2(83.37,100.77)
GPU_BUFRST: length 18.1
  IN3 w0.102: v2(67.94,82.59) 67.94,82.58 67.94,82.46 69.92,80.47 69.92,79.77 72.27,77.42 73.06,77.42 75.43,75.05 75.43,74 v2(77.53,71.9)
  BOTTOM w0.102: v2(77.53,71.9) v1(78.23,71.9) RV67.1 ; v2(67.94,82.59) 67.53,83 UV1.D11
GPU_EVENT#: length 88
  TOP w0.102: RC204.2 165.53,61.33 165.35,61.33 164.97,61.71 v2(164.97,62.61) ; DV1.1 v2(86.54,78.41)
  BOTTOM w0.102: v2(86.54,78.41) v1(87.35,78.41) 100.82,64.95 150.49,64.95 152.54,62.9 156.67,62.9 156.83,63.05 159.89,63.05 160.82,62.12 164.11,62.12 164.6,62.61 v2(164.97,62.61)
GPU_EVENT#_D: length 18.2
  TOP w0.102: v2(73.67,84.98) v1(74.03,85.34) 74.18,85.49 74.62,85.49 74.94,85.17 74.94,84.99 79.26,80.67 86.25,80.67 DV1.2 86.54,79.87 85.68,79.01 RPV7.3
  BOTTOM w0.102: v2(73.67,84.98) 73.3,85.35 UV1.A4
GPU_JTAG_TCK: length 1.1
  TOP w0.076: T231.1 72.78,65.84 v2(72.88,65.94)
  BOTTOM w0.076: UV1.AE5 72.54,65.6 v2(72.88,65.94)
GPU_JTAG_TDI: length 1.9
  TOP w0.076: v2(72.02,64.38) 72.02,64.37 T242.1
  BOTTOM w0.076: v2(72.02,64.38) 72.02,64.98 71.6,65.4 UV1.AE6
GPU_JTAG_TDO: length 1.4
  TOP w0.076: v2(71.24,64.38) 71.24,63.68 T243.1
  BOTTOM w0.076: UV1.AF6 71.6,64.74 v2(71.24,64.38)
GPU_JTAG_TMS: length 1.3
  TOP w0.076: T232.1 71.49,67.28 v2(71.95,66.82)
  BOTTOM w0.076: v2(71.95,66.82) 71.61,66.47 71.6,66.47 UV1.AD6
GPU_JTAG_TRST#: length 13.5
  TOP w0.102: v2(77.91,68.44) 78.99,68.44 v3(79.37,68.83)
  BOTTOM w0.102: RPV6.2 78.33,69.68 77.91,69.26 v2(77.91,68.44) 77.91,64.76 76.74,63.58 74.03,63.58 73.61,64 UV1.AG4
GPU_PLLVDD: length 1.4
  BOTTOM w0.203: v2(72.1,75.97) 72.1,76.74 UV1.L6
  vias: v1(72.32,76.51)
GPU_PWR_LEVEL: length 157.5
  TOP w0.102: RPV5.3 79.4,78.51 78.99,78.92 78.99,79.62 75.66,82.95 72.41,82.95 v2(72.02,83.34) ; UE5.21 144.57,13.35 144.14,13.78 144.14,16.96 145.24,18.06 145.24,18.44 146.01,19.21 146.46,19.21 148.63,21.39 148.63,22.52 v3(149.03,22.91) 150.08,23.96 150.65,23.96 151.06,24.38 v2(151.06,24.95)
  IN1 w0.102: v2(84.83,45.66) 88.96,41.53 88.96,40.57 91.05,38.47 99.76,38.47 105.63,32.6 105.63,29.59 108.05,27.18 138.05,27.18 139,26.23 149.4,26.23 150.68,24.95 v2(151.06,24.95)
  IN3 w0.076: v2(72.02,83.34) 72.02,82.91 73.15,81.78 73.15,80.38 76.13,77.4 ; 76.13,63.87 75.43,63.17
  IN3 w0.102: 76.13,77.4 78.42,75.11 78.42,73.09 79.52,71.99 79.52,68.83 78.31,67.62 78.31,66.06 76.13,63.87 ; 75.43,63.17 74.2,61.94 74.2,51.64 76.53,49.31 82.37,49.31 84.83,46.85 v2(84.83,45.66)
  BOTTOM w0.102: UV1.D7 71.14,83.34 v2(72.02,83.34)
GPU_TESTMODE: length 14.1
  TOP w0.076: v2(69.54,65.99) v1(69.54,66.48)
  IN3 w0.127: v2(69.54,65.99) 70.06,65.47 73.98,65.47 77.59,69.08 77.59,69.71 v2(78.29,70.41)
  BOTTOM w0.076: v2(69.54,65.99) 69.13,66.4 UV1.AD9
  BOTTOM w0.102: RPV6.3 78.52,70.18 v2(78.29,70.41)
GPU_THM_SMBCLK: length 230.7
  TOP w0.102: Q2409.3 157.8,18.04 R2459.2 157.37,18.18 157.16,17.96 v2(157.16,16.5) ; UE5.12 147.67,9.75 147.76,9.66 147.87,9.66 148.34,10.13 148.57,10.13 v2(148.75,10.3) 148.84,10.21 148.95,10.21 RE351.1
  IN1 w0.102: v2(164.33,96) 164.18,95.85 164.18,95.59 164.31,95.46 167.85,95.46 171.67,91.63 171.67,77.73 172.74,76.66 172.74,66.97 170.51,64.73 170.51,63.7 169.78,62.97 169.78,62.78 v2(169.96,62.6) 169.84,62.48 169.84,62.24 170.4,61.68 170.4,58.14 169.74,57.48 169.74,49.53 169.09,48.89 169.09,43.77 169.86,43.01 169.86,33.25 169.64,33.04 169.64,26.19 168.88,25.42 168.88,23.54 163.71,18.37 161.72,18.37 160.32,16.97 157.06,16.97 156.94,16.85 156.94,16.72 v2(157.16,16.5)
  IN3 w0.102: v2(157.16,16.5) 156.95,16.7 156.95,17.02 156.74,17.24 152.55,17.24 150.39,15.07 150.39,11.45 149.13,10.19 148.87,10.19 v2(148.75,10.3)
  BOTTOM w0.102: QC3.3 158.92,96.07 RC399.2 158.82,96.12 158.36,96.57 158.36,98.16 159.89,99.69 160.65,99.69 v2(164.33,96) ; QV2.3 80.78,74.93 80.51,74.67 80.51,74.09 RV74.2 80.79,73.44 81.05,73.18 81.55,73.18 83.64,75.27 83.64,76.59 86.39,79.34 87.33,79.34 95.85,70.83 101.06,65.61 150.53,65.61 152.79,63.35 156.48,63.35 156.74,63.61 157.79,63.61 158.27,64.1 159.85,64.1 160.45,63.49 162.62,63.49 163,63.87 166.44,63.87 166.97,63.34 169.4,63.34 169.78,62.96 169.78,62.78 v2(169.96,62.6)
GPU_THM_SMBDAT: length 228.9
  TOP w0.102: RE350.1 149.33,9.96 148.99,9.96 v2(148.75,9.72) 148.57,9.9 148.43,9.9 147.97,9.43 147.76,9.43 147.67,9.35 UE5.11 ; Q2409.6 155.9,15.57 R2458.2 156.43,15.46 156.52,15.55 v2(156.52,16.5)
  IN1 w0.102: v2(163.73,96) 163.95,95.79 163.95,95.5 164.21,95.23 167.75,95.23 171.44,91.54 171.44,77.63 172.51,76.57 172.51,67.06 170.28,64.83 170.28,63.79 169.55,63.07 169.55,62.78 v2(169.37,62.6) 169.61,62.37 169.61,62.15 170.17,61.58 170.17,58.23 169.51,57.57 169.51,49.63 168.87,48.98 168.87,43.68 169.63,42.92 169.63,33.35 169.41,33.13 169.41,26.28 168.65,25.52 168.65,23.64 163.61,18.6 161.63,18.6 160.23,17.2 156.97,17.2 156.71,16.95 156.71,16.69 v2(156.52,16.5)
  IN3 w0.102: v2(148.75,9.72) 148.99,9.96 149.22,9.96 150.62,11.35 150.62,14.98 152.65,17.01 156.64,17.01 156.72,16.93 156.72,16.7 v2(156.52,16.5)
  BOTTOM w0.102: QV2.6 79.79,76.23 80.13,76.57 RV75.2 79.57,77.68 78.62,76.73 78.62,74.21 79.5,73.33 80.57,73.33 80.96,72.95 81.64,72.95 83.87,75.18 83.87,76.5 86.48,79.11 87.24,79.11 100.97,65.38 150.44,65.38 152.7,63.13 156.58,63.13 156.84,63.38 157.88,63.38 158.37,63.87 159.76,63.87 160.36,63.26 162.71,63.26 163.09,63.64 166.34,63.64 166.87,63.11 169.3,63.11 169.55,62.86 169.55,62.78 v2(169.37,62.6) ; v2(163.73,96) 163.73,96.22 162.92,97.03 RC397.2 161.24,97.97 QC3.6
GT_SNUB1:
  vias: v1(94.42,103.94)
GT_SW1: length 11
  TOP w0.102: v2(90.62,102.61) v1(89.72,102.61)
  BOTTOM w0.254: 88.95,101.15 PL605.1 91.18,101.15 91.5,101.46 91.5,104.29 91.28,104.51 89.15,104.51 PR674.2
  vias: v2(90.62,101.97)
H_CATERR#: length 9.3
  BOTTOM w0.076: 116.71,105.34 116.71,105.21 v1(116.9,105.02) 117.09,104.83 117.09,104.38 116.48,103.77 116.48,103.15 116.8,102.84 116.8,102.48 116.76,102.38 116.76,102.19 116.8,102.1 116.8,101.85 116.78,101.8 116.74,101.65 116.66,101.37 116.66,101.26 116.58,100.99 UC1.D63
  BOTTOM w0.102: RC14.1 116.9,108.44 116.9,106.29 116.71,106.1 116.71,105.34
H_CPU_SVIDALRT#: length 12.8
  BOTTOM w0.076: UC1.B63 116.12,101.96 115.99,102.1 115.99,103.61 115.74,103.86 115.74,103.94 115.93,104.14 116.15,104.14 116.35,104.34 116.35,104.52 116.2,104.67 116.02,104.67 115.53,104.18 115.41,104.18 115.32,104.27 115.32,104.4 115.82,104.89 115.82,105.02 115.73,105.11 115.59,105.11 v1(115.12,104.64) 114.96,104.48 114.85,104.48 114.76,104.57 114.76,104.7 115.11,105.05 115.11,105.21 114.98,105.34 114.8,105.34 114.67,105.21 114.67,105.02 114.41,104.75 113.7,104.75 113.62,104.83 113.62,104.95 113.75,105.08 114.17,105.08 114.26,105.17 114.26,105.34
  BOTTOM w0.102: RC180.1 115.08,106.63 115.08,105.87 114.95,105.74 114.38,105.74 114.26,105.62 114.26,105.34
H_CPUPWRGD: length 6.8
  BOTTOM w0.076: UC1.A68 113.24,102.68 112.38,103.54 108.64,103.54
  BOTTOM w0.102: 108.64,103.54 108.3,103.54 107.64,102.87 RC102.2
H_PROCHOT#: length 416.4
  TOP w0.102: v2(124.77,21.2) 124.64,21.07 v1(124.64,20.69) 124.64,20.63 124.55,20.54 124.55,19.64 125.09,19.1 125.09,16.68 CE84.1 124.47,16.06 UE6.4 ; v2(45.19,7.88) 46,8.69 49.46,8.69 53.14,12.37 55.81,12.37 57.08,12.06 58.64,11.39 63.18,6.85 96.77,6.85 98.16,8.25 102.93,8.25 105.1,6.07 111.98,6.07 v2(112.97,5.09)
  TOP w0.254: v2(32,112.51) 32,112.89 32.43,113.32 PQ2.6
  IN1 w0.102: v2(108.04,107.81) 108.01,107.81 107.63,108.2 103.2,108.2 102.87,108.52 100.51,108.52 98.91,106.93 98.35,106.93 v2(96.26,104.83)
  IN1 w0.254: v2(32,112.51) 31.79,112.31 22.2,112.31 18.98,109.08 18.98,106.73 8.5,96.26 8.5,86.54 5.84,83.87 3.42,83.87 1.61,82.07 1.61,69.68 4.69,66.6 4.69,54.35 10.41,48.63 20.69,48.63 22.15,47.17 22.15,35.04 23.36,33.84 23.36,24.69 21.65,22.98 21.65,17.83 v2(23.77,15.71) 24.06,15.71 26.31,13.45 27.14,13.45 32.12,8.47 44.6,8.47 v2(45.19,7.88)
  IN3 w0.102: v2(96.26,104.83) 96.3,104.83 98.86,102.27 98.86,100.07 91.12,92.32 91.12,73.65 89.85,72.38 89.85,42.92 86.73,39.81 86.73,35.55 87.56,34.73 89.91,34.73 94.83,29.8 95.38,29.8 104.44,20.74 112.19,20.74 112.83,20.1 121.6,20.1 122.29,20.79 124.36,20.79 v2(124.77,21.2)
  BOTTOM w0.102: v2(112.97,5.09) 113,5.12 113,12.34 112.48,12.86 112.48,20.84 112.9,21.26 113.59,21.26 114.06,20.79 124.36,20.79 v2(124.77,21.2) ; RC4.1 110.48,106.3 RC3.2 109.73,107.23 109.15,107.81 v2(108.04,107.81) ; PR678.1 95.06,111.5 95.99,111.5 PC605.2 96.2,111.31 96.97,110.53 96.97,107.83 96.7,107.56 96.7,105.27 v2(96.26,104.83)
  BOTTOM w0.254: PR777.1 45.21,7.89 v2(45.19,7.88) ; PQ3.3 v2(23.77,15.71)
H_PROCHOT#_R: length 9.8
  BOTTOM w0.076: UC1.C65 115.05,101.62 114.97,101.88 114.97,102.05 115.03,102.24 115.03,102.39 114.97,102.51 114.97,102.77 115.16,102.96 115.16,103.49 114.83,103.82 114.31,103.82 114.04,104.09 113.07,104.09 112.73,104.43 110.5,104.43 109.59,105.34
  BOTTOM w0.102: RC4.2 109.4,106.11 109.4,105.53 109.59,105.34
H_PROCHOT_EC: length 19.1
  TOP w0.102: UE6.2 123.82,12.26 RE388.2 123.59,12.08 122.26,12.08 v2(121.85,11.68) ; UE5.83 132.03,10.55 v2(132.2,10.72)
  BOTTOM w0.102: v2(121.85,11.68) 123.37,13.2 125.85,13.2 126.93,12.12 126.93,10.09 127.95,9.07 129.41,9.07 v1(131.06,10.72) v2(132.2,10.72)
H_THERMTRIP#: length 6.1
  BOTTOM w0.076: 116.13,105.34 116.13,105.2 116.8,104.54 116.8,104.32 116.32,103.84 116.32,103.08 116.63,102.77 116.63,102.51 116.57,102.39 116.57,102.24 116.63,102.05 116.63,101.88 116.55,101.62 UC1.C63
  BOTTOM w0.102: 116.13,105.34 116.13,106.6 RC2.2
HDA_BIT_CLK: length 11.8
  TOP w0.076: v2(141.67,71.34) 142.09,71.34 RPC9.8
  BOTTOM w0.076: v2(141.67,71.34) 141.03,71.34 140.7,71.67 v1(140.7,76.7) 140.7,76.96 139.84,77.82 139.84,79.45 139.67,79.62 139.67,80.27 139.52,80.42 139.52,80.87 UC1.AY22
HDA_CODEC_BITCLK: length 100.1
  TOP w0.076: RPC9.1 142.12,69.14 CA26.1 141.8,68.14
  TOP w0.102: v2(166.23,53.89) v1(165.45,53.11) 156.87,53.11 146.63,63.35 146.63,65.13 146.03,65.73 144.16,65.73 141.8,68.08 141.8,68.14
  IN3 w0.102: v2(166.23,53.89) 170.45,49.67 170.45,38.5 174.45,34.5 174.45,23.57 175.89,22.13 175.89,18.28 v2(177.8,16.37)
  BOTTOM w0.102: v2(177.8,16.37) 178.25,15.92 178.7,15.92 179.28,15.33 188.63,15.33 189.65,14.3 192.14,14.3 192.47,13.97 193.44,13.97 194.22,13.2 195.64,13.2 195.76,13.33 195.76,14.15 196.22,14.61 RA1112.1 197.03,15.55 196.73,15.86 UA1.6
HDA_CODEC_RST#: length 94.1
  TOP w0.102: RPC9.4 143.62,67.98 144.68,66.92 146.68,66.92 147.82,65.78 v1(147.82,64.03) 157.55,54.3 163.84,54.3 165.73,56.19 v2(166.32,56.19)
  IN3 w0.102: v2(166.32,56.19) 167.19,55.32 167.19,54.62 171.64,50.17 171.64,39.01 175.64,35.01 175.64,24.06 177.13,22.58 177.13,19.27 179.34,17.05 v2(179.34,16.88)
  BOTTOM w0.102: v2(179.34,16.88) 179.69,16.88 180.05,16.52 189.39,16.52 189.79,16.12 192.02,16.12 193.1,15.04 193.86,15.04 194.73,15.9 UA1.11
HDA_CODEC_SDIN0: length 2.3
  BOTTOM w0.102: RA130.2 195.23,14.61 v1(195.93,15.3) UA1.8
HDA_CODEC_SDOUT: length 104.1
  TOP w0.102: v2(166.29,55.35) 166.11,55.17 v1(165.73,55.17) 164.37,53.82 157.35,53.82 147.34,63.83 147.34,65.55 146.45,66.44 144.48,66.44 143.12,67.8 RPC9.3
  IN3 w0.102: v2(166.29,55.35) 166.71,54.94 166.71,54.42 171.16,49.97 171.16,38.81 175.16,34.81 175.16,23.86 176.62,22.4 176.62,19.08 178.86,16.85 178.86,15.68 v2(178.56,15.37)
  BOTTOM w0.102: v2(178.56,15.37) 179.08,14.85 188.43,14.85 189.45,13.82 191.94,13.82 192.27,13.49 193.24,13.49 194.72,12.02 197.88,12.02 198.3,12.44 198.3,14.15 197.73,14.72 197.73,15.23 197.13,15.84 UA1.5
HDA_CODEC_SYNC: length 95.3
  TOP w0.102: RPC9.2 142.62,67.98 144.38,66.21 146.35,66.21 147.11,65.45 147.11,63.57 v1(157.08,53.59) 164.47,53.59 165.64,54.77 v2(166.3,54.77)
  IN3 w0.102: v2(166.3,54.77) 166.3,54.5 170.93,49.87 170.93,38.7 174.93,34.7 174.93,23.77 176.4,22.3 176.4,18.46 v2(178.45,16.4)
  BOTTOM w0.102: v2(178.45,16.4) 179.49,16.4 179.85,16.04 188.92,16.04 189.95,15.02 192.44,15.02 192.77,14.69 193.95,14.69 195.13,15.86 UA1.10
HDA_RST#: length 12.5
  TOP w0.076: 142.52,72.89 v2(142.11,72.89)
  TOP w0.102: 142.52,72.89 142.66,72.89 143.62,71.93 RPC9.5
  BOTTOM w0.076: UC1.AW22 139.94,81.8 140.2,81.55 140.2,80.83 140.37,80.66 140.37,78.01 141.72,76.67 v1(141.72,74.16) 141.72,73.28 v2(142.11,72.89)
HDA_SDIN0: length 109
  IN3 w0.102: v2(179.39,15.93) 179.83,16.37 179.83,17.26 177.61,19.48 177.61,22.78 176.13,24.26 176.13,35.21 172.13,39.21 172.13,52.9 169.16,55.87 167.32,55.87 164.91,58.28 164.59,58.28 163.63,59.24 163.63,61.93 163.02,62.54 163.02,63.85 161.98,64.89 161.05,64.89 v2(160.58,65.36)
  BOTTOM w0.076: UC1.BA21 140.68,80.8 140.68,78.95
  BOTTOM w0.102: v2(160.58,65.36) 160.44,65.5 158.7,65.5 157.59,64.38 156.39,64.38 156.14,64.13 154.13,64.13 151.62,66.63 145.7,66.63 142.64,69.69 142.64,74.25 141.98,74.91 141.98,76.79 140.68,78.09 140.68,78.95 ; RA130.1 194.41,13.69 v1(193.9,14.2) 193.64,14.46 192.68,14.46 192.34,14.79 189.85,14.79 188.83,15.81 179.51,15.81 v2(179.39,15.93)
HDA_SDOUT: length 14.8
  TOP w0.076: 142.52,72.35 142.47,72.39 v2(141.06,72.39)
  TOP w0.102: 142.52,72.35 143.12,71.75 RPC9.6 143.12,70.86 143.32,70.66 144.08,70.66 144.27,70.48 144.27,70.08 RC17.2 RC218.2
  BOTTOM w0.076: UC1.BB22 140.01,79.92 140.01,77.89 141.06,76.84 v1(141.06,75.37) v2(141.06,72.39)
HDA_SYNC: length 10.9
  TOP w0.076: 142.52,71.78 142.42,71.88 v2(141.72,71.88)
  TOP w0.102: 142.52,71.78 142.62,71.68 RPC9.7
  BOTTOM w0.076: v2(141.72,71.88) 141.72,72.58 v1(141.57,72.73) 141.34,72.96 141.34,76.81 140.21,77.94 140.21,80.37 UC1.BA22
HDD_A0_PRE0: length 6.5
  TOP w0.102: v1(182.1,17.34) 181.95,17.19 181.95,15.93 181.49,15.47 ; 181.49,15.47 RS27.2 ; 181.49,15.47 RS24.1 183.05,14.85 184.33,14.85 184.72,14.46 US2.9
HDD_A0_PRE1: length 2.8
  TOP w0.102: RS23.1 RS30.2 185.72,8.78 US2.19
HDD_B0_EQ: length 9.3
  TOP w0.102: v2(182.06,11.57) 182.36,11.87 US2.13 ; v2(181.86,9.87) 180.51,9.87 179.99,9.35 v1(179.57,9.35) 178.42,9.35 RS37.1 177.76,8.69 177.76,7.81 RS38.1
  IN1 w0.102: v2(182.06,11.57) 182.06,10.07 v2(181.86,9.87)
HDD_B0_PRE0: length 3.1
  TOP w0.102: 185.22,13.77 185.22,14.56 184.89,14.89 184.79,14.89 RS28.2 RS21.1
HDD_B0_PRE1: length 3.1
  TOP w0.102: RS29.2 183.57,8.25 RS18.1 184.72,9.4 US2.17
HDD_REXT_SATA0: length 5
  TOP w0.102: v1(189.85,8.26) RS26.2
  TOP w0.254: US2.20 186.22,9.09 186.49,8.82 187.76,8.82 188.02,8.56 RS31.1 RS26.2
HDMI_CLK: length 105
  IN3 w0.089: v2(193.22,82.86) 193.41,83.05 193.41,83.78 192.53,84.67 192.53,90.42 187.14,95.8 175.34,95.8 173.69,97.45 173.69,100.49 171.28,102.9 171.28,107.6 167.58,111.3 139.22,111.3 138.55,110.63 136.84,110.63 135.78,109.57 135.78,106.5 135.31,106.04 127.44,106.04 124.96,103.56 124.96,102.42 124.58,102.04 121.51,102.04 120.29,100.81 120.29,99.27 120.07,99.05 119.93,99.05 v2(119.72,98.84)
  BOTTOM w0.076: UC1.G56 119.75,98.83 v2(119.72,98.84)
  BOTTOM w0.089: v2(193.22,82.86) 193.41,83.05 193.41,83.3 193.58,83.47 194.32,83.47 CX13.2
HDMI_CLK#: length 105.2
  IN3 w0.089: v2(119.72,99.48) 119.72,99.34 119.82,99.24 119.99,99.24 120.1,99.34 120.1,100.89 121.43,102.23 124.5,102.23 124.77,102.5 124.77,103.64 127.36,106.23 135.23,106.23 135.58,106.58 135.58,109.65 136.76,110.82 138.47,110.82 139.14,111.49 167.66,111.49 171.47,107.68 171.47,102.98 173.88,100.57 173.88,97.52 175.42,95.99 187.22,95.99 192.72,90.5 192.72,84.75 193.6,83.86 193.6,83.06 v2(193.81,82.86)
  BOTTOM w0.076: v2(119.72,99.48) UC1.F56
  BOTTOM w0.089: v2(193.81,82.86) 193.6,83.07 193.6,83.23 193.66,83.29 194.32,83.29 CX12.2
HDMI_DATA0: length 103.4
  IN3 w0.089: v2(121.55,98.84) 121.91,99.21 121.91,99.94 122.61,100.64 125.42,100.64 127.56,102.78 127.56,104.31 127.96,104.7 136.45,104.7 137.1,105.34 137.1,109.02 137.39,109.31 139.09,109.31 139.76,109.98 166.29,109.98 169.16,107.12 169.16,101.76 171.55,99.37 171.55,97.48 174.55,94.48 184.96,94.48 191.7,87.74 191.7,83.45 194.49,80.65 194.49,79.89 194.44,79.84 194.05,79.84 v2(193.66,80.23)
  BOTTOM w0.076: UC1.G53 v2(121.55,98.84)
  BOTTOM w0.089: v2(193.66,80.23) 193.86,80.03 194.19,80.03 CX15.2
HDMI_DATA0#: length 103.4
  IN3 w0.089: v2(193.66,79.65) 194.52,79.65 194.68,79.81 194.68,80.73 191.89,83.53 191.89,87.82 185.04,94.67 174.63,94.67 171.74,97.56 171.74,99.45 169.35,101.84 169.35,107.19 166.37,110.17 139.68,110.17 139.02,109.5 137.31,109.5 136.91,109.1 136.91,105.42 136.38,104.89 127.88,104.89 127.37,104.39 127.37,102.86 125.34,100.83 122.54,100.83 121.72,100.02 121.72,99.65 v2(121.55,99.48)
  BOTTOM w0.076: UC1.F53 v2(121.55,99.48)
  BOTTOM w0.089: v2(193.66,79.65) 193.86,79.85 194.32,79.85 CX14.2
HDMI_DATA1: length 100.3
  IN3 w0.089: v2(118.81,99.48) 119.35,100.03 119.35,101 121.15,102.8 123.2,102.8 125.6,105.2 130.5,110.1 135.38,110.1 136.57,111.29 138.27,111.29 138.94,111.96 167.87,111.96 172.01,107.81 172.01,105.96 173.41,104.56 173.41,102.14 174.36,101.19 174.36,97.71 175.61,96.46 187.42,96.46 193.41,90.46 193.41,86.61 v2(193.22,86.41)
  BOTTOM w0.076: UC1.F58 v2(118.81,99.48)
  BOTTOM w0.089: CX17.2 194.19,87.03 193.65,87.03 193.4,86.79 193.4,86.6 v2(193.22,86.41)
HDMI_DATA1#: length 100.1
  IN3 w0.089: v2(118.81,100.11) 119.1,100.11 119.16,100.18 119.16,101.08 121.07,102.99 123.12,102.99 125.6,105.47 130.42,110.29 135.3,110.29 136.49,111.48 138.19,111.48 138.86,112.15 167.95,112.15 172.21,107.89 172.21,106.04 173.6,104.64 173.6,102.22 174.55,101.27 174.55,97.79 175.69,96.65 187.5,96.65 193.6,90.54 193.6,86.62 v2(193.81,86.41)
  BOTTOM w0.076: UC1.E58 v2(118.81,100.11)
  BOTTOM w0.089: v2(193.81,86.41) 193.59,86.63 193.59,86.71 193.72,86.84 194.19,86.84 CX16.2
HDMI_DATA2: length 96.2
  IN3 w0.089: v2(190.59,89.84) 190.79,90.04 190.79,90.18 185.83,95.14 175.04,95.14 172.27,97.91 172.27,99.62 170.62,101.27 170.62,106.73 166.71,110.64 139.49,110.64 138.82,109.97 137.11,109.97 136.44,109.29 136.44,105.83 135.88,105.27 127.63,105.27 125.53,103.18 125.53,101.91 124.99,101.36 121.95,101.36 121.53,100.94 121.53,100.12 121.1,99.69 120.77,99.69 120.65,99.56 v2(120.65,99.47)
  BOTTOM w0.076: UC1.F55 v2(120.65,99.47)
  BOTTOM w0.089: CX19.2 194.43,90.48 191.06,90.48 190.79,90.22 190.79,90.05 v2(190.59,89.84)
HDMI_DATA2#: length 96.3
  IN3 w0.089: v2(191.17,89.84) 190.98,90.04 190.98,90.26 185.91,95.33 175.12,95.33 172.46,97.99 172.46,99.7 170.81,101.35 170.81,106.81 166.79,110.83 139.41,110.83 138.74,110.16 137.04,110.16 136.25,109.37 136.25,105.91 135.8,105.46 127.55,105.46 125.34,103.26 125.34,101.99 124.91,101.55 121.88,101.55 121.34,101.02 121.34,100.19 121.02,99.88 120.88,99.88 v2(120.65,100.11)
  BOTTOM w0.076: UC1.E55 v2(120.65,100.11)
  BOTTOM w0.089: v2(191.17,89.84) 190.98,90.04 190.98,90.14 191.13,90.29 194.21,90.29 CX18.2
HDMI_DET: length 84
  TOP w0.076: v2(147.69,96.18) 147.69,95.49 RC312.2
  TOP w0.102: QX5.3 195.78,74.36 196.53,75.11 RX14.1 197.78,75.68 198.56,75.68 v2(198.72,75.53)
  IN1 w0.076: 154.87,92.84 154.48,93.22 152.34,93.22 150.65,94.91 148.16,94.91 147.69,95.39 v2(147.69,96.18)
  IN1 w0.102: v2(169.92,75.3) 169.92,76.25 169.39,76.78 169.39,84.6 166.03,87.95 158.45,87.95 157.56,87.06 156.92,87.06 156.03,86.17 154.43,86.17 154.31,86.06 153.83,86.06 153.66,86.22 153.66,86.44 153.43,86.67 152.33,86.67 151.99,87.01 151.99,87.6 153.34,88.95 153.81,88.95 155.12,90.27 155.12,92.58 154.87,92.84
  BOTTOM w0.076: UC1.L9 147.42,96.62 v2(147.69,96.18)
  BOTTOM w0.102: v2(169.92,75.3) 170.05,75.44 v1(189.35,75.44) 191.58,75.44 193.99,77.84 194.81,77.84 195.51,78.54 197.29,78.54 198.72,77.11 v2(198.72,75.53)
HDMI_HPLUG: length 13.3
  TOP w0.102: v1(199.13,72.38) 198.84,72.67 v2(198.84,73.33)
  TOP w0.254: RX34.1 RX15.2 v2(198.84,73.33)
  IN1 w0.254: v2(198.84,73.33) 199.32,73.33 199.7,73.71 199.7,78.54 201.29,80.13 202.98,80.13 JHDMI.19
HOST_DEBUG_TX: length 130.7
  TOP w0.102: UE5.81 133.21,11.35 v2(133.66,11.8) ; v2(181.28,63.69) 181.67,64.08 RM13.2 RM12.2 ; v2(119.69,9.14) 120.14,9.58 120.14,10.15 120.33,10.34 121.08,10.34 RE392.2
  IN1 w0.102: v2(133.66,11.8) 134.04,11.42 141.05,11.42 142.04,12.41 148.34,12.41 149.21,13.28 152.66,13.28 154.37,11.57 157.66,11.57 158.11,11.12 163.05,11.12 163.98,12.04 163.98,12.82 170.07,18.91 174.75,18.91 176.37,20.53 176.37,34.83 177.68,36.14 179.68,36.14 184.3,40.75 184.3,51.12 185.83,52.65 185.83,53.9 184.08,55.65 184.08,60.44 181.28,63.25 v2(181.28,63.69)
  BOTTOM w0.102: v2(133.66,11.8) v1(133.66,11.17) 133.66,10.72 132.71,9.77 130.55,9.77 129.6,8.82 127.69,8.82 126.61,9.9 126.61,11.99 125.66,12.95 123.5,12.95 122.29,11.74 122.29,11.29 121.53,10.53 119.56,10.53 119.25,10.21 119.25,9.58 v2(119.69,9.14) 120.16,8.67 JDEG1.8
HPOUT-L: length 2.5
  BOTTOM w0.203: RA55.1 197.4,24.2 v1(197.4,23.65) 197.13,23.38 UA1.32
HPOUT-R: length 3.3
  BOTTOM w0.203: v1(198.62,24.95) 197.95,24.95 RA56.1 197.75,24.48 197.81,24.41 197.81,23.4 197.53,23.11 UA1.33
I2C_SCL_TP: length 275.2
  IN1 w0.102: v2(160.6,91.18) 160.47,91.05 160.47,90.8 161.22,90.05 165.88,90.05 166.42,89.5 167.79,89.5 170.76,86.53 170.76,77.35 171.82,76.28 171.82,67.9 168.19,64.27 168.19,60.96 167.24,60.01 167.24,53.39 167.48,53.15 167.48,46.82 168.19,46.11 168.19,43.95 168.98,43.16 168.98,40.87 168.36,40.25 168.36,23.67 163.52,18.83 161.54,18.83 160.16,17.45 155.57,17.45 152.9,14.79 147.45,14.79 146.58,13.92 140.59,13.92 140.43,13.76 135.09,13.76 133.78,15.08 132.16,15.08 129.85,17.39 129.34,17.39 129.22,17.26 128.53,17.26 127.06,18.74 123.31,18.74 122.17,19.88 115.7,19.88 114.93,19.1 112.65,19.1 108.29,23.46 106.43,23.46 95.53,34.36 84.07,34.36 83.26,35.17 80.87,35.17 80.06,34.36 54.7,34.36 44.68,44.38 40.5,44.38 28.63,56.25 28.63,61.77 28.47,61.94 28.09,61.94 27.55,62.48 25.39,62.48 v2(24.95,62.03)
  IN3 w0.102: v2(149.05,93.21) 148.88,93.03 148.88,92.79 148.96,92.7 149.79,92.7 150.23,93.15 155,93.15 155.38,92.76 158.49,92.76 159.4,91.85 160.17,91.85 160.43,91.58 160.43,91.34 v2(160.6,91.18)
  BOTTOM w0.076: v2(149.05,93.21) 149.37,93.53 UC1.U6
  BOTTOM w0.102: v2(160.6,91.18) 160.43,91.34 160.43,91.65 160.21,91.88 159.77,91.88 RC395.2 ; v2(24.95,62.03) 24.69,62.28 RE337.1 23.62,63.8 23.62,65.78 24.25,66.41 26.28,66.41 26.71,65.98 QE6.4
I2C_SCL_TP_R: length 8.6
  TOP w0.102: v2(25.65,61.27) 25.66,61.28 JTP.6
  BOTTOM w0.102: QE6.3 25.57,65.98 25.96,65.59 25.96,64.44 25.71,64.19 25.03,64.19 24.69,63.86 RE337.2 RE334.2 25.89,63.63 26.06,63.46 26.05,63.46 26.05,61.68 v2(25.65,61.27)
I2C_SDA_TP: length 269.3
  IN1 w0.102: v2(24.61,64.6) 24.61,63.45 25.36,62.7 27.65,62.7 28,62.35 v2(28.38,62.35) 28.86,61.87 28.86,56.34 40.6,44.61 44.77,44.61 54.79,34.59 79.97,34.59 80.78,35.4 83.36,35.4 84.17,34.59 95.63,34.59 106.52,23.69 108.38,23.69 112.74,19.33 114.84,19.33 115.61,20.1 122.27,20.1 123.41,18.97 127.15,18.97 128.62,17.49 129.12,17.49 129.25,17.62 129.94,17.62 132.26,15.31 133.87,15.31 135.19,13.99 140.33,13.99 140.49,14.15 146.49,14.15 147.35,15.02 152.81,15.02 155.47,17.68 160.06,17.68 161.44,19.06 163.42,19.06 168.13,23.76 168.13,40.35 168.75,40.97 168.75,43.06 167.96,43.86 167.96,46.02 167.25,46.72 167.25,53.05 167.01,53.3 167.01,60.1 167.96,61.06 167.96,64.37 171.6,68 171.6,76.19 170.53,77.25 170.53,86.43 167.69,89.27 166.33,89.27 165.78,89.82 161.12,89.82 160.24,90.7 160.24,90.95 160.14,91.05 v2(160.01,91.18)
  IN3 w0.102: v2(148.39,93.21) 148.65,92.96 148.65,92.7 148.87,92.47 149.88,92.47 150.33,92.92 154.9,92.92 155.28,92.54 158.39,92.54 159.31,91.62 160.07,91.62 160.2,91.49 160.2,91.37 v2(160.01,91.18)
  BOTTOM w0.076: v2(148.39,93.21) 148.72,93.54 UC1.U7
  BOTTOM w0.102: v2(28.38,62.35) 28.01,62.72 RE336.1 ; v2(160.01,91.18) 160.2,91.37 160.2,91.56 160.11,91.65 159.67,91.65 RC394.2 ; v2(24.61,64.6) 24.69,64.68 QE6.1
I2C_SDA_TP_R: length 6.3
  TOP w0.102: v2(26.28,61.27) 26.66,60.89 JTP.7
  BOTTOM w0.102: QE6.6 27.18,64.7 27.49,64.7 27.74,64.44 RE336.2 RE335.2 26.55,63.63 26.28,63.36 v2(26.28,61.27)
I2CA_SCL: length 16.4
  BOTTOM w0.102: UV1.B7 71.19,84.99 71.19,85.58 71.35,85.74 76.27,85.74 78.42,87.9 80.54,87.9 80.73,88.09 81.65,88.09 81.82,88.25 83.05,88.25 v1(83.05,88.26) 83.05,88.25 83.24,88.25 84.13,87.37 84.45,87.37 84.63,87.19 RPV3.1
I2CA_SDA: length 16
  BOTTOM w0.102: RPV3.2 84.58,87.69 84.48,87.6 84.23,87.6 83.18,88.64 v1(81.78,88.64) 81.46,88.32 80.64,88.32 80.44,88.13 78.33,88.13 76.17,85.97 71.23,85.97 70.8,85.54 UV1.A7
I2CB_SCL: length 21.7
  IN3 w0.102: 71.95,86.57 71.94,86.55 71.94,86.53 71.3,85.89 70.26,85.89 69.74,85.37 69.74,83.51 v2(69.62,83.4)
  IN3 w0.127: v2(83.56,89.02) 83.75,88.83 83.75,88.68 83.58,88.51 80.43,88.51 78.81,90.12 75.51,90.12 71.95,86.57
  BOTTOM w0.102: v2(83.56,89.02) 83.73,88.85 83.73,88.53 83.94,88.32 84.59,88.32 84.73,88.19 RPV3.3 ; v2(69.62,83.4) 69.22,83.8 UV1.C9
I2CB_SDA: length 21.3
  IN3 w0.102: 72.13,86.39 72.12,86.37 72.1,86.37 71.39,85.66 70.36,85.66 69.97,85.27 69.97,83.8 v2(70.35,83.42)
  IN3 w0.127: 72.13,86.39 75.61,89.87 78.71,89.87 80.32,88.26 83.69,88.26 84,88.57 84,88.88 v2(84.14,89.02)
  BOTTOM w0.102: v2(70.35,83.42) 69.97,83.8 UV1.C8 ; RPV3.4 84.73,88.69 84.59,88.55 84.03,88.55 83.96,88.62 83.96,88.83 v2(84.14,89.02)
I2CC_SCL: length 10.5
  BOTTOM w0.102: RV205.1 76.63,90.26 76.38,90.26 73.31,87.2 v4(70.92,87.2) 69.99,87.2 69.12,86.33 UV1.A9
I2CC_SDA: length 12
  BOTTOM w0.102: UV1.B9 69.12,84.76 68.71,85.17 68.71,86.26 69.89,87.43 v4(72.38,87.43) 73.22,87.43 76.28,90.49 76.63,90.49 RV206.1
I2CS_SCL: length 33
  IN3 w0.102: v2(69.62,82.59) 70.05,83.03 70.68,83.03 70.94,83.28 70.94,84.85 71.95,85.87 72.59,85.87 73.25,86.53 73.25,86.55 73.27,86.57
  IN3 w0.127: v2(79.18,74.29) 79.18,78.52 78.92,78.78 78.92,88.44 v2(79.08,88.61) 78.87,88.82 78.87,89.07 78.58,89.36 77.17,89.36 75.71,87.9 74.6,87.9 73.27,86.57
  BOTTOM w0.102: UV1.D9 69.21,83 v2(69.62,82.59) ; v2(79.18,74.29) 79.66,73.8 RV74.1 79.88,73.81 79.88,74.67 79.61,74.93 QV2.4 ; RV203.1 79.37,89.17 79.15,89.17 78.91,88.93 78.91,88.79 v2(79.08,88.61)
I2CS_SDA: length 32.7
  IN3 w0.102: 73.45,86.39 73.43,86.37 73.41,86.37 72.68,85.64 72.05,85.64 71.17,84.76 71.17,83.19 70.78,82.8 70.51,82.8 v2(70.35,82.63)
  IN3 w0.127: 73.45,86.39 74.71,87.65 75.82,87.65 77.28,89.11 78.47,89.11 78.62,88.96 78.62,88.73 v2(78.5,88.61) 78.66,88.44 78.66,78.67 78.92,78.41 78.92,78.16 78.44,77.68 v2(77.6,77.68)
  BOTTOM w0.102: v2(77.6,77.68) v1(78.35,77.68) 78.81,77.68 79.29,78.16 80.56,78.16 RV75.1 81.53,77.2 81.53,76.51 81.25,76.23 QV2.1 ; RV204.1 79.46,89.4 79.06,89.4 78.68,89.02 78.68,88.79 v2(78.5,88.61) ; v2(70.35,82.63) 69.98,83 UV1.D8
I_ADP: length 91.3
  TOP w0.102: v2(44.31,7.88) 45.63,9.2 49.46,9.2 52.95,12.69 55.81,12.69 57.21,12.37 59.02,11.58 63.43,7.17 96.45,7.17 97.85,8.56 103.18,8.56 v1(104.51,7.23) 105.44,6.3 114.14,6.3 115.14,5.31 118.62,5.31 120.78,3.15 123.39,3.15 123.62,2.93 RE386.2
  TOP w0.254: v2(44.31,7.88) 44.06,8.12 44.06,9.06 PC748.1
  BOTTOM w0.254: PR774.1 v2(44.31,7.88)
I_ADP_R: length 17.3
  TOP w0.102: v1(137.47,1.26) 137.47,2.33 v2(137.48,2.34) 137.48,2.42 137.8,2.74 UE5.110 ; v2(125.15,2.28) 124.83,2.59 RE386.1 CE83.1
  IN1 w0.102: v2(137.48,2.34) 136.72,3.1 130.04,3.1 129.14,2.2 125.23,2.2 v2(125.15,2.28)
I_BATT: length 89.9
  TOP w0.102: RE389.2 120.57,3.04 118.53,5.08 114.81,5.08 v2(113.79,4.06)
  TOP w0.254: PC749.2 v1(43.81,9.76) 43.44,9.39 v2(43.44,7.87)
  IN2 w0.254: v2(113.79,4.06) 113.37,3.64 111.49,3.64 110.57,4.56 106.1,4.56 103.11,7.55 63.55,7.55 57.97,13.14 52.7,13.14 48.32,8.75 43.94,8.75 43.44,8.26 v2(43.44,7.87)
  BOTTOM w0.254: PR775.1 v2(43.44,7.87)
I_BATT_R: length 22.5
  TOP w0.102: UE5.114 139.4,2.45 v2(139.31,2.35) ; v2(121.16,1.87) 121.16,2.28 RE389.1 122.35,2.59 CE90.1
  IN1 w0.102: v2(121.16,1.87) 121.16,1.79 121.55,1.41 138.37,1.41 v2(139.31,2.35)
  BOTTOM w0.102: v2(121.16,1.87) 121.24,1.79 v1(121.67,1.79)
I_SYS: length 210.7
  TOP w0.102: RE403.1 113.02,2.93 v1(113.02,3.48) v2(113.02,4.12)
  IN2 w0.254: v2(42.73,10.09) 42.73,9.58 43.17,9.14 48.06,9.14 52.44,13.52 58.22,13.52 63.8,7.94 103.27,7.94 106.26,4.94 110.73,4.94 111.55,4.12 v2(113.02,4.12)
  IN3 w0.102: v2(95.61,104.84) 95.61,104.58 95.94,104.26 96.36,104.26 98.42,102.2 98.42,100.32 90.61,92.51 90.61,74.1 89.46,72.95 89.46,43.23 86.1,39.87 86.1,35.3 87.72,33.67 89.78,33.67 94.44,29.01 95.31,29.01 104.26,20.06 111.12,20.06 v2(111.57,19.61)
  BOTTOM w0.102: v2(111.57,19.61) 112.01,19.17 112.01,10.91 112.52,10.41 112.52,4.82 113.02,4.31 v2(113.02,4.12) ; PR620.1 95.61,105.94 v2(95.61,104.84)
  BOTTOM w0.203: PU703.8 44.68,10.9 44.25,10.47 43.11,10.47 v2(42.73,10.09) 42.54,9.9 PR727.1
ICSP_CLK: length 16.6
  TOP w0.102: UE5.101 134.2,4.76 134.29,4.85 134.29,4.93 v2(134.11,5.11) ; RE395.1 v2(122.89,4.5) RE365.2
  IN1 w0.102: v2(134.11,5.11) 134.29,5.28 134.29,5.39 134.16,5.52 132.08,5.52 130.75,4.18 125.15,4.18 124.26,5.07 123.44,5.07 122.89,4.53 v2(122.89,4.5)
  BOTTOM w0.102: v2(122.89,4.5) 122.89,4.53 v1(123.37,5.01)
ICSP_CLR: length 13.3
  TOP w0.102: UE5.87 132.17,8.95 v2(132.18,8.94) ; RE396.1 v2(123.01,5.45)
  BOTTOM w0.102: v2(132.18,8.94) 132.18,8.61 v1(131.09,7.52) 128.96,5.39 127.18,5.39 126.55,6.02 123.58,6.02 v2(123.01,5.45)
ICSP_DAT: length 17.4
  TOP w0.102: RE398.1 122.82,7.29 v2(122.89,7.22) 122.97,7.29 RE367.2 ; v2(134.7,5.11) 134.52,4.93 134.52,4.78 134.6,4.7 UE5.102
  IN1 w0.102: v2(122.89,7.22) 122.93,7.18 122.93,6.15 123.78,5.3 124.35,5.3 125.24,4.41 130.65,4.41 131.98,5.74 134.26,5.74 134.52,5.48 134.52,5.28 v2(134.7,5.11)
ILMT_+1VALWP: length 4.3
  BOTTOM w0.254: PR310.1 PR307.2 181.54,48.19 180.84,48.89 v1(180.84,49.2) 180.84,49.58 180.57,49.86 PU301.3
IMON_IA: length 3.3
  TOP w0.102: v2(85.97,113.02) v1(85.46,113.02)
  TOP w0.254: v2(85.97,113.02) 86.16,113.21 PC625.2 PR629.2
  BOTTOM w0.203: PU602.14 86.19,113.24 v2(85.97,113.02)
IMON_VSA: length 4.7
  TOP w0.102: PR651.1 86.67,116.74 v1(86.67,117.21)
  TOP w0.254: PR651.1 87.12,116.23 PC643.1 88,116.25 v2(88,117.47)
  BOTTOM w0.203: PU602.23 88.36,116.92 88,117.28 v2(88,117.47)
IMVP_VR_ON: length 74.3
  TOP w0.102: RC345.2 107.68,100.38 107.68,102.72 108.71,103.75 108.71,105.78 107.63,106.86 107.63,108.43 104.83,111.23 99.24,111.23 97.99,109.97 96.88,109.97 v2(96.56,110.29)
  IN1 w0.102: v2(98.96,112.96) 98.96,112.11 97.85,110.99 97.26,110.99 v2(96.56,110.29) 96.45,110.29 96.27,110.11 94.47,110.11 93.4,111.18 87.94,111.18 87.09,110.33 83.9,110.33 83.28,110.95 77.81,110.95 76.51,109.66 75.75,109.66 74.61,110.8 v2(74.61,111.62)
  BOTTOM w0.102: PR664.1 100.76,111.87 100.32,111.43 99.12,111.43 98.74,111.81 98.74,112.73 v2(98.96,112.96) ; v2(96.56,110.29) 96.56,110.15 95.92,109.51 PR616.1 ; PR683.1 79.24,97.34 77.84,98.73 77.84,102.99 76.45,104.39 76.45,108.26 v1(76.07,108.64) 74.61,110.1 v2(74.61,111.62)
INT-SPK-L+:
  vias: v1(201.8,19.3) v2(201.25,19.87) v2(201.53,20.45)
INT-SPK-L-:
  vias: v1(204.72,20.44) v2(202.7,20.45) v2(203.51,20.45)
INT-SPK-R+:
  vias: v1(207,19.36) v2(200.79,18.24) v2(201.05,17.71) v2(206.75,18.85) v2(207.45,18.85)
INT-SPK-R-:
  vias: v1(212.08,18.66) v2(202.11,17.07) v2(202.16,17.73) v2(211.64,19.1) v2(212.53,19.1)
INT_TP#: length 4.6
  TOP w0.102: QE7.3 25.47,63.56 RE329.2 24.25,62.34 v1(24.25,61.95) 24.25,61.71 23.66,61.12 JTP.4
INTRUDER#: length 17.1
  TOP w0.076: 143.35,81.93 143.35,82.26 143.12,82.49 143.12,83.65 142.58,84.19 v2(142.58,84.67)
  TOP w0.102: 143.35,81.93 143.35,79.43 144.23,78.56 144.23,77.63 v1(144.61,77.24) 146.9,74.95 146.9,72.25 147.28,71.88 147.28,70.95 RC94.2
  BOTTOM w0.076: UC1.AP16 v2(142.58,84.67)
ISOLATEB: length 3.9
  TOP w0.102: RL33.2 RL35.2 172.14,101.83 v1(172.14,102.8) v2(172.14,103.36)
  BOTTOM w0.102: UL1.20 172.92,103.36 172.82,103.46 172.24,103.46 v2(172.14,103.36)
ISUMP_GT: length 8.6
  TOP w0.254: PR637.1 88.05,110.43 v2(88.38,110.1) 88.4,110.08 v1(88.4,109.53) PR628.1
  BOTTOM w0.203: PU602.7 88.76,110.54 88.38,110.16 v2(88.38,110.1) PC626.1
  BOTTOM w0.254: PR674.1 88.64,106.42 88.45,106.42 88.13,106.74 88.13,107.42 PR633.1 PR628.1 88.4,109.44 PC626.1
ISUMP_IA: length 9.8
  TOP w0.254: v2(85.65,117.02) 86.29,116.39 PR655.1
  BOTTOM w0.102: PR657.1 v1(81.15,117.71)
  BOTTOM w0.203: PC642.1 84.97,117.71 v2(85.65,117.02) 86.1,116.58 86.1,115.5 86.36,115.24 PU602.19
  BOTTOM w0.254: PC642.1 84.92,117.71 PC646.1 PR656.1 PR657.1 82.1,116.58 PR661.2
ISUMP_VSA: length 14.1
  TOP w0.254: v2(90.29,117.47) PR654.1
  BOTTOM w0.203: PC637.1 90.29,117.9 v2(90.29,117.47) 90.29,117.35 89.96,117.02 PU602.27
  BOTTOM w0.254: PR642.1 95.8,119.13 PR624.2 ; PR642.1 PR643.2 94.54,120.01 93.95,120.6 90.63,120.6 90.06,120.03 PC633.1 PC637.1 ; PR642.1 v1(95.43,120.2)
JACK_PLUG#: length 15.4
  TOP w0.102: RA4.1 191.57,20.43 v3(191.57,21.58) v2(191.57,22.18)
  IN1 w0.102: v2(191.57,22.18) 191.57,22.66 193.89,24.98 196.84,24.98 197.51,25.65 199.19,25.65 200.91,27.36 JHP.5
JACK_SENSE#: length 7.1
  TOP w0.254: RA4.2 192.77,20.58 192.99,20.36 192.99,19.47 193.22,19.23 v1(193.22,18.66) 193.22,18.41 192.97,18.15 192.97,17.38 v2(192.67,17.08)
  BOTTOM w0.203: v2(192.67,17.08) 192.88,17.29 UA1.13
  BOTTOM w0.254: v2(192.67,17.08) 192.54,16.95 191.71,16.95 RA13.1
JHDD_P10: length 7.1
  TOP w0.102: v3(181.1,14.22) 181.98,14.22 182.56,13.64 v2(183.57,13.64)
  BOTTOM w0.102: RS8.2 182.57,13.64 v2(183.57,13.64) 184.91,13.64 185.53,13.02 JHDD.7
JTAG_CLK: length 2.6
  TOP w0.102: v1(120.07,6.98) v2(120.64,6.4) 120.71,6.34 RE397.2
  BOTTOM w0.102: JDEG1.4 120.91,6.67 v2(120.64,6.4)
JTAG_TDI: length 3
  TOP w0.102: RE395.2 121.27,4.5 v2(120.64,5.13) 120.14,5.64 v1(120.14,5.64)
  BOTTOM w0.102: JDEG1.2 121.03,5.67 120.64,5.28 v2(120.64,5.13)
JTAG_TDO: length 4.9
  TOP w0.102: RE398.2 120.83,7.29 120.64,7.1 120.45,7.1 v2(119.92,7.63) 119.07,7.63 v1(118.8,7.36)
  BOTTOM w0.102: JDEG1.5 120.38,7.17 v2(119.92,7.63)
JTAG_TMS: length 4.9
  TOP w0.102: RE396.2 120.78,6 120.41,6 v2(120.01,6.4) 119.31,6.4 v1(118.87,5.96)
  BOTTOM w0.102: JDEG1.3 121.11,6.17 120.94,6 120.41,6 v2(120.01,6.4)
KB_BL_PWM: length 10.8
  TOP w0.305: 121.44,14.19 121.07,13.82 JKBBL.4
  TOP w0.508: 122.8,23.17 122.8,21.85 122.73,21.77 122.73,20.81 v3(122.36,20.44) 121.44,19.52 121.44,14.19
KB_DET#: length 182.1
  TOP w0.102: JKB.30 94.76,24.55 102.42,16.89 102.42,11.42 107.3,6.53 113.85,6.53 v1(114.17,6.85) 114.55,7.23 114.55,8.5 116.64,10.6 v2(116.64,21.43) ; RC327.1 160.78,63.49 160.52,63.75 160.52,64.28 160.84,64.6 162.2,64.6 162.55,64.95 163.63,64.95 164.08,64.5 164.87,64.5 v2(165.1,64.27)
  IN1 w0.102: v2(160.24,75.05) 160.24,72.75 161.98,71 161.98,68.65 164.61,66.02 164.61,64.76 v2(165.1,64.27) 165.1,63.9 164.56,63.36 164.56,62.56 163.66,61.66 163.66,61.06 164.45,60.27 164.45,59.93 163.66,59.14 163.66,57.72 163.53,57.59 163.53,57.25 163.23,56.95 162.68,56.95 161.98,56.25 161.98,53.33 164.57,50.74 164.57,45.65 165.04,45.19 165.04,37.59 165.61,37.01 165.61,35.37 164.97,34.73 164.97,24.63 161.49,21.16 160.57,21.16 159.2,19.78 154.06,19.78 153.72,19.44 149.13,19.44 146.3,16.62 140,16.62 139.34,15.96 136.36,15.96 136.07,16.26 136.07,16.81 136.39,17.14 136.39,18.22 135.95,18.66 133.28,18.66 132.56,17.94 132.02,17.94 129.55,20.41 128.36,20.41 126.94,21.84 117.05,21.84 v2(116.64,21.43)
  BOTTOM w0.076: 152.46,77.14 152.01,77.59 151.08,77.59 148.88,79.79 148.52,79.79 148.4,79.91 UC1.BB7
  BOTTOM w0.102: v2(160.24,75.05) 159.7,75.05 159.57,75.18 155.28,75.18 154.39,76.06 153.54,76.06 152.46,77.14
