# Allegro board LA-D051P Boardview.brd (continued)
## Routing (per net, layer and track width the routed paths; a pad name or vN(x,y) marks a point on that pad's centre or on a via; arc(x,y) is an arc through that point) (continued)
DDR_A_D0: length 65.2
  IN1 w0.089: v2(109.61,87.01) 109.18,87.43 105.2,87.43 104.93,87.7 99.9,87.7 95.68,83.48 95.68,78.48 96.99,77.17 96.99,52.85 97.08,52.76 97.53,52.76 97.62,52.67 97.62,52.46 97.53,52.37 97.08,52.37 96.99,52.28 96.99,52.06 97.08,51.97 97.53,51.97 97.62,51.88 97.62,51.67 97.53,51.58 97.08,51.58 96.99,51.49 96.99,51.27 97.08,51.19 97.53,51.19 97.62,51.1 97.62,50.88 97.53,50.79 97.08,50.79 96.99,50.7 96.99,50.49 97.08,50.4 97.53,50.4 97.62,50.31 97.62,50.09 97.53,50 97.08,50 96.99,49.92 96.99,49.7 97.08,49.61 97.53,49.61 97.62,49.52 97.62,49.31 97.53,49.22 97.08,49.22 96.99,49.13 96.99,48.91 97.08,48.82 97.53,48.82 97.62,48.73 97.62,48.52 97.53,48.43 97.08,48.43 96.99,48.34 96.99,48.12 97.08,48.04 97.53,48.04 97.62,47.95 97.62,47.73 97.53,47.64 97.08,47.64 96.99,47.55 96.99,47.34 97.17,47.16 97.17,46.95 96.99,46.77 v2(96.99,46.1)
  BOTTOM w0.076: UC1.AL71 111.37,86.81 111.32,86.86 109.76,86.86 v2(109.61,87.01)
  BOTTOM w0.102: v2(96.99,46.1) 97.28,46.1 97.35,46.17 JDIMM1.5
DDR_A_D1: length 66.2
  IN1 w0.089: v2(96.99,44.57) 96.72,44.57 96.59,44.7 96.59,77.15 95.39,78.36 95.39,83.6 99.78,87.99 105.11,87.99 105.38,87.72 109.41,87.72 110.15,86.98 v2(110.15,85.87)
  BOTTOM w0.076: UC1.AL68 113.42,86.16 113.22,85.95 112.7,85.95 112.55,85.88 112.36,85.88 112.21,85.93 112.06,85.93 111.84,85.87 111.73,85.87 111.65,85.9 111.62,85.91 111.01,85.91 110.77,85.67 110.36,85.67 v2(110.15,85.87)
  BOTTOM w0.102: v2(96.99,44.57) 97.74,44.57 97.95,44.78 JDIMM1.7
DDR_A_D2: length 67.1
  IN1 w0.076: v2(106.89,84.46) 105.99,83.56 105.76,83.56
  IN1 w0.089: 105.76,83.56 104.84,83.56 103.82,84.57 100.45,84.57 98.39,82.51 98.39,79.69 101.75,76.33 101.75,74.83 101.2,74.29 101.2,73.54 101.29,73.45 101.59,73.45 101.69,73.35 101.69,73.11 101.59,73.01 101.29,73.01 101.2,72.92 101.2,72.65 101.29,72.56 101.66,72.56 101.75,72.47 101.75,72.21 101.66,72.12 101.29,72.12 101.2,72.03 101.2,71.76 101.29,71.67 101.66,71.67 101.75,71.59 101.75,71.32 101.66,71.23 101.29,71.23 101.2,71.14 101.2,70.87 101.29,70.79 101.66,70.79 101.75,70.7 101.75,70.43 101.66,70.34 101.29,70.34 101.2,70.25 101.2,69.99 101.29,69.9 101.66,69.9 101.75,69.81 101.75,69.54 101.66,69.45 101.29,69.45 101.2,69.36 101.2,69.1 101.29,69.01 101.66,69.01 101.75,68.92 101.75,68.65 101.66,68.56 101.29,68.56 101.2,68.47 101.2,68.21 101.29,68.12 101.66,68.12 101.75,68.03 101.75,67.76 101.66,67.67 101.29,67.67 101.2,67.59 101.2,67.32 101.29,67.23 101.66,67.23 101.75,67.14 101.75,66.87 101.66,66.78 101.29,66.78 101.2,66.7 101.2,66.43 101.29,66.34 101.66,66.34 101.75,66.25 101.75,65.98 101.66,65.9 101.29,65.9 101.2,65.81 101.2,65.54 101.29,65.45 101.66,65.45 101.75,65.36 101.75,65.1 101.66,65.01 101.29,65.01 101.2,64.92 101.2,64.65 101.29,64.56 101.66,64.56 101.75,64.47 101.75,49.69 101.28,49.22 101.28,47.05 v2(100.32,46.1)
  BOTTOM w0.076: UC1.AN68 113.42,85.58 112.84,85.29 112.35,85.29 112.11,85.05 111.18,85.05 111.14,85.01 109.47,85.01 108.94,84.48 107.97,84.48 107.58,84.09 107.26,84.09 v2(106.89,84.46)
  BOTTOM w0.102: JDIMM1.17 100.95,46.72 v2(100.32,46.1)
DDR_A_D3: length 66.4
  IN1 w0.076: 105.76,84.57 v2(105.78,84.57)
  IN1 w0.089: v2(100.32,41.52) 99.63,42.22 99.63,46.38 100.53,47.29 100.53,49.3 100.76,49.53 100.76,55.56 100.67,55.65 100.31,55.65 100.22,55.74 100.22,56.01 100.31,56.1 100.67,56.1 100.76,56.19 100.76,56.45 100.67,56.54 100.31,56.54 100.22,56.63 100.22,56.9 100.31,56.99 100.67,56.99 100.76,57.08 100.76,57.34 100.67,57.43 100.31,57.43 100.22,57.52 100.22,57.79 100.31,57.88 100.67,57.88 100.76,57.96 100.76,58.23 100.67,58.32 100.31,58.32 100.22,58.41 100.22,58.68 100.31,58.76 100.67,58.76 100.76,58.85 100.76,59.12 100.67,59.21 100.31,59.21 100.22,59.3 100.22,59.56 100.4,59.74 100.4,60.01 100.22,60.19 100.22,74.63 100.76,75.16 100.76,76.5 97.81,79.44 97.81,82.75 100.21,85.16 104.56,85.16 105.15,84.57 105.76,84.57
  BOTTOM w0.076: v2(105.78,84.57) 106.19,84.98 108.67,84.98 109.19,85.5 110.88,85.5 111.13,85.75 111.58,85.75 111.7,85.69 111.72,85.69 111.73,85.69 111.74,85.69 111.84,85.69 112.07,85.76 112.2,85.76 112.42,85.68 112.67,85.68 UC1.AN69
  BOTTOM w0.102: JDIMM1.16 100.65,41.19 v2(100.32,41.52)
DDR_A_D4: length 66.4
  IN1 w0.089: v2(108.85,86.22) 107.96,87.11 105.07,87.11 104.78,87.41 100.03,87.41 96.09,83.47 96.09,78.73 97.91,76.91 97.91,55.93 97.85,55.87 97.34,55.87 97.29,55.82 97.29,54.11 97.38,54.02 97.61,54.02 97.71,53.92 97.71,53.73 97.61,53.62 97.38,53.62 97.29,53.54 97.29,53.32 97.38,53.23 97.83,53.23 97.91,53.14 97.91,47.16 97.39,46.64 97.39,43.42 v2(96.99,43.05)
  BOTTOM w0.076: v2(108.85,86.22) 108.85,86.81 109.49,87.46 110.03,87.46 110.47,87.02 111.12,87.02 111.16,87.06 111.6,87.06 111.67,87.04 111.8,86.98 111.97,86.81 UC1.AL70
  BOTTOM w0.102: v2(96.99,43.05) 97.65,42.39 JDIMM1.6
DDR_A_D5: length 66.9
  IN1 w0.089: v2(108.46,85.84) 107.44,86.86 104.86,86.86 104.6,87.11 100.15,87.11 96.38,83.35 96.38,78.86 98.37,76.87 98.37,50.73 98.46,50.64 98.7,50.64 98.79,50.55 98.79,50.34 98.7,50.25 98.46,50.25 98.37,50.16 98.37,49.94 98.46,49.85 98.7,49.85 98.79,49.76 98.79,49.55 98.7,49.46 98.46,49.46 98.37,49.37 98.37,49.15 98.46,49.07 98.55,49.07 98.65,48.96 98.65,48.77 98.55,48.67 98.46,48.67 98.37,48.58 98.37,47.13 97.69,46.45 97.69,42.22 v2(96.99,41.52)
  BOTTOM w0.076: UC1.AL69 112.57,86.81 112.3,87.07 112.13,87.07 111.95,87.15 111.95,87.15 111.82,87.19 111.74,87.2 111.67,87.21 111.61,87.23 111.1,87.23 111.05,87.19 110.54,87.19 110.1,87.62 109.42,87.62 108.46,86.66 v2(108.46,85.84)
  BOTTOM w0.102: v2(96.99,41.52) 97.05,41.47 JDIMM1.4
DDR_A_D6: length 65.2
  IN1 w0.089: v2(107.44,84.45) 106.86,83.87 106.67,83.87 105.85,83.05 104.93,83.05 103.7,84.28 100.57,84.28 98.68,82.39 98.68,79.81 102.29,76.2 102.29,74.3 102.2,74.22 101.86,74.22 101.77,74.13 101.77,73.86 101.86,73.77 102.2,73.77 102.29,73.68 102.29,47.55 101.31,46.57 101.31,46.35 101.23,46.26 101.07,46.26 100.98,46.17 100.98,45.9 101.07,45.81 101.23,45.81 101.31,45.72 101.31,45.46 101.23,45.37 101.07,45.37 100.98,45.28 100.98,45.01 101.07,44.92 101.23,44.92 101.31,44.83 101.31,42.97 101.21,42.87 100.91,42.87 100.81,42.97 100.81,44.47 100.7,44.57 v2(100.32,44.57)
  BOTTOM w0.076: v2(107.44,84.45) 107.63,84.64 108.83,84.64 109.36,85.17 111.07,85.17 111.11,85.22 111.86,85.22 UC1.AN70
  BOTTOM w0.102: v2(100.32,44.57) 99.65,45.24 99.65,46.31 99.87,46.53 100.12,46.53 100.35,46.76 JDIMM1.15
DDR_A_D7: length 64.7
  IN1 w0.076: v2(106.34,84.45) 105.93,84.03 105.76,84.03
  IN1 w0.089: v2(100.32,43.05) 99.92,43.45 99.92,46.26 100.98,47.32 100.98,49.34 101.25,49.61 101.25,59.65 101.07,59.83 101.07,60.09 101.25,60.27 101.25,60.54 101.16,60.63 100.84,60.63 100.76,60.72 100.76,60.98 100.84,61.07 101.16,61.07 101.25,61.16 101.25,61.43 101.16,61.52 100.84,61.52 100.76,61.61 100.76,61.87 100.84,61.96 101.16,61.96 101.25,62.05 101.25,62.32 101.16,62.41 100.84,62.41 100.76,62.49 100.76,62.76 100.84,62.85 101.16,62.85 101.25,62.94 101.25,63.21 101.16,63.29 100.84,63.29 100.76,63.38 100.76,63.65 100.84,63.74 101.16,63.74 101.25,63.83 101.25,64.09 101.16,64.18 100.84,64.18 100.76,64.27 100.76,74.36 101.25,74.86 101.25,76.41 98.1,79.57 98.1,82.63 100.33,84.87 104.19,84.87 105.03,84.03 105.76,84.03
  BOTTOM w0.076: UC1.AN71 111.4,85.41 111.07,85.41 111,85.34 109.28,85.34 108.76,84.81 106.71,84.81 v2(106.34,84.45)
  BOTTOM w0.102: JDIMM1.18 101.25,42.12 v2(100.32,43.05)
DDR_A_D8: length 52.7
  IN1 w0.089: v2(107.7,83.12) 107.38,83.12 106.86,82.6 106.26,82.6 105.47,81.81 105.47,78.36 103.05,75.94 103.05,47.23 102.08,46.26 102.08,43.45 v2(102.48,43.05)
  BOTTOM w0.076: UC1.AR70 111.97,84.45 111.71,84.72 111.32,84.72 111.28,84.68 110.04,84.68 109.51,84.15 108.15,84.15 107.7,83.69 v2(107.7,83.12)
  BOTTOM w0.102: v2(102.48,43.05) 102.93,43.05 103.05,42.93 JDIMM1.24
DDR_A_D9: length 54
  IN1 w0.089: v2(102.48,41.52) 101.78,42.22 101.78,46.38 102.76,47.35 102.76,76.06 105.17,78.48 105.17,81.93 106.32,83.08 v2(106.72,83.08)
  BOTTOM w0.076: v2(106.72,83.08) 106.72,83.48 107.05,83.81 107.58,83.81 108.08,84.31 109.13,84.31 109.66,84.84 111.21,84.84 111.25,84.89 112.11,84.89 112.35,84.65 112.89,84.65 UC1.AR68
  BOTTOM w0.102: v2(102.48,41.52) 102.45,41.49 JDIMM1.22
DDR_A_D10: length 50.4
  IN1 w0.089: v2(105.41,41.52) 105.01,41.92 105.01,46.26 105.06,46.31 105.06,50.57 105.73,51.24 105.73,64.15 105.82,64.24 105.92,64.24 106.01,64.32 106.01,64.54 105.92,64.63 105.82,64.63 105.73,64.72 105.73,64.93 105.82,65.02 105.92,65.02 106.01,65.11 106.01,65.33 105.92,65.42 105.82,65.42 105.73,65.51 105.73,65.72 105.82,65.81 105.92,65.81 106.01,65.9 106.01,66.11 105.92,66.2 105.82,66.2 105.73,66.29 105.73,66.51 105.82,66.6 105.92,66.6 106.01,66.69 106.01,66.9 105.92,66.99 105.82,66.99 105.73,67.08 105.73,67.3 105.82,67.38 105.92,67.38 106.01,67.47 106.01,67.69 105.92,67.78 105.82,67.78 105.73,67.87 105.73,68.08 105.82,68.17 105.92,68.17 106.01,68.26 106.01,68.48 105.92,68.57 105.82,68.57 105.73,68.65 105.73,68.87 105.82,68.96 105.92,68.96 106.01,69.05 106.01,69.26 105.92,69.35 105.82,69.35 105.73,69.44 105.73,69.66 105.82,69.75 105.85,69.75 105.95,69.85 105.95,70.04 105.85,70.14 105.82,70.14 105.73,70.23 105.73,75.79 107.98,78.04 v2(107.98,80.36)
  BOTTOM w0.076: v2(107.98,80.36) 107.98,80.85 108.71,81.57 108.71,81.99 108.94,82.22 109.36,82.22 110.16,83.02 111.37,83.02 UC1.AU71
  BOTTOM w0.102: v2(105.41,41.52) 106.05,40.88 JDIMM1.34
DDR_A_D11: length 52.4
  IN1 w0.089: v2(102.48,46.1) 102.48,46.25 103.34,47.11 103.34,53.94 103.43,54.03 103.87,54.03 104,54.16 104,54.38 103.91,54.47 103.43,54.47 103.34,54.56 103.34,54.77 103.43,54.86 103.91,54.86 104,54.95 104,55.17 103.91,55.26 103.43,55.26 103.34,55.35 103.34,55.56 103.43,55.65 103.91,55.65 104,55.74 104,55.95 103.91,56.04 103.43,56.04 103.34,56.13 103.34,56.35 103.43,56.44 103.91,56.44 104,56.53 104,56.74 103.91,56.83 103.72,56.83 103.62,56.93 103.62,76.1 105.76,78.24 105.76,81.63 106.42,82.29 107.54,82.29 108.29,83.04 v2(108.29,83.12)
  BOTTOM w0.076: v2(108.29,83.12) 109.45,83.12 110.51,84.18 111.09,84.18 111.25,84.02 111.62,84.02 111.65,84.03 111.73,84.07 111.84,84.07 112.06,84 112.21,84 112.36,84.06 112.95,84.06 112.98,84.08 113.22,84.08 113.38,83.92 113.38,83.19 UC1.AU68
  BOTTOM w0.102: v2(102.48,46.1) 102.66,46.1 102.75,46.18 JDIMM1.23
DDR_A_D12: length 51
  IN1 w0.089: v2(108.78,83.63) 108.86,83.55 108.86,82.48 108.53,82.15 108.18,82.15 108.01,81.98 106.43,81.98 106.06,81.61 106.06,78.13 104.31,76.38 104.31,54.05 103.63,53.38 103.63,46.99 102.93,46.29 102.93,45.02 v2(102.48,44.57)
  BOTTOM w0.076: v2(108.78,83.63) 109.14,83.98 109.61,83.98 110.14,84.51 111.41,84.51 UC1.AR71
  BOTTOM w0.102: v2(102.48,44.57) 102.29,44.38 102.02,44.38 101.91,44.49 101.91,45.41 101.8,45.52 101.38,45.52 101.28,45.63 101.28,45.83 101.38,45.94 101.83,45.94 101.99,46.09 101.99,46.49 102.15,46.65 JDIMM1.21
DDR_A_D13: length 52.2
  IN1 w0.089: v2(105.41,43.05) 106.61,44.25 106.61,58.48 106.7,58.57 107.05,58.57 107.14,58.66 107.14,58.87 107.05,58.96 106.97,58.96 106.86,59.06 106.86,59.25 106.97,59.36 107.05,59.36 107.14,59.44 107.14,72.04 106.61,72.57 106.61,74.67 110.27,78.33 110.27,82.69 v2(109.33,83.62)
  BOTTOM w0.076: UC1.AR69 112.67,84.25 112.42,84.25 112.2,84.18 112.07,84.18 111.84,84.24 111.74,84.24 111.73,84.25 111.72,84.24 111.7,84.24 111.58,84.19 111.32,84.19 111.16,84.35 110.42,84.35 109.84,83.77 109.69,83.62 v2(109.33,83.62)
  BOTTOM w0.102: v2(105.41,43.05) 105.91,43.05 106.65,42.31 JDIMM1.36
DDR_A_D14: length 50.7
  IN1 w0.089: v2(108.9,81.17) 108.9,78.29 106.03,75.41 106.03,72.11 106.38,71.76 106.38,64 106.03,63.64 106.03,50.64 105.94,50.55 105.45,50.55 105.35,50.44 105.35,50.3 105.45,50.19 105.94,50.19 106.03,50.1 106.03,49.89 105.94,49.8 105.44,49.8 105.35,49.71 105.35,49.53 105.44,49.44 105.94,49.44 106.03,49.35 106.03,49.14 105.94,49.05 105.5,49.05 105.4,48.95 105.4,48.8 105.5,48.69 105.94,48.69 106.03,48.61 106.03,48.43 105.94,48.34 105.45,48.34 105.35,48.23 105.35,48.09 105.45,47.98 105.94,47.98 106.03,47.89 106.03,47.72 105.94,47.63 105.45,47.63 105.35,47.52 105.35,47.38 105.45,47.27 105.94,47.27 106.03,47.18 106.03,47 105.94,46.92 105.45,46.92 105.35,46.81 105.35,46.66 105.45,46.56 105.94,46.56 106.03,46.47 106.03,45.84 105.9,45.71 105.54,45.71 105.41,45.84 v2(105.41,46.1)
  BOTTOM w0.076: UC1.AU70 111.84,82.85 110.35,82.85 109.54,82.03 109.02,82.03 108.9,81.91 v2(108.9,81.17)
  BOTTOM w0.102: v2(105.41,46.1) 105.75,46.44 JDIMM1.33
DDR_A_D15: length 51.3
  IN1 w0.089: v2(109.35,81.51) 109.58,81.28 109.58,78.3 106.32,75.04 106.32,72.39 106.83,71.89 106.83,63.7 106.74,63.61 106.41,63.61 106.32,63.52 106.32,63.3 106.41,63.22 106.74,63.22 106.83,63.13 106.83,62.91 106.74,62.82 106.41,62.82 106.32,62.73 106.32,62.52 106.41,62.43 106.74,62.43 106.83,62.34 106.83,62.12 106.74,62.03 106.41,62.03 106.32,61.95 106.32,61.73 106.41,61.64 106.74,61.64 106.83,61.55 106.83,61.34 106.74,61.25 106.41,61.25 106.32,61.16 106.32,60.94 106.41,60.85 106.74,60.85 106.83,60.76 106.83,60.55 106.74,60.46 106.41,60.46 106.32,60.37 106.32,60.16 106.41,60.07 106.74,60.07 106.83,59.98 106.83,59.76 106.74,59.67 106.41,59.67 106.32,59.58 106.32,45.48 v2(105.41,44.57)
  BOTTOM w0.076: UC1.AU69 112.57,83.13 112.19,82.75 112.01,82.75 111.93,82.67 110.64,82.67 109.71,81.74 109.58,81.74 v2(109.35,81.51)
  BOTTOM w0.102: v2(105.41,44.57) 105.92,44.57 106.3,44.95 106.3,47.65 JDIMM1.35
DDR_A_D16: length 48.4
  IN1 w0.089: v2(110.04,75.66) 110.04,75.63 108.63,74.23 108.63,53.78 108.38,53.52 108.38,50.15 108.29,50.06 108.13,50.06 108.07,50 108.07,49.7 108.25,49.52 108.25,49.37 108.16,49.28 108.04,49.28 107.96,49.19 107.96,48.97 108.04,48.88 108.29,48.88 108.38,48.79 108.38,48.58 108.29,48.49 108.04,48.49 107.96,48.4 107.96,48.18 108.04,48.1 108.29,48.1 108.38,48.01 108.38,47.79 108.29,47.7 108.04,47.7 107.96,47.61 107.96,47.4 108.04,47.31 108.29,47.31 108.38,47.22 108.38,47 108.29,46.91 108.04,46.91 107.96,46.83 107.96,46.61 108.04,46.52 108.29,46.52 108.38,46.43 108.38,43.47 v2(107.85,42.94)
  BOTTOM w0.076: 110.19,75.82 110.59,76.21 110.59,77.6 111.23,78.24 114.42,78.24 115.21,79.02 115.21,79.96 UC1.BB65
  BOTTOM w0.089: 110.19,75.82 v2(110.04,75.66)
  BOTTOM w0.102: v2(107.85,42.94) 107.85,42.75 107.44,42.34 107.44,41.23 107.85,40.82 JDIMM1.40
DDR_A_D17: length 51
  IN1 w0.089: v2(107.54,73.85) 108.04,73.35 108.04,57.55 107.37,56.87 107.37,44.96 v2(107.87,44.46)
  BOTTOM w0.076: 116.28,79.23 116.28,79.56 116.12,79.71 116.12,80.13 116.17,80.24 116.17,80.36 116.11,80.58 116.11,80.72 116.16,80.88 116.16,81.06 116.09,81.22 116.09,81.73 115.88,81.94 UC1.AW65
  BOTTOM w0.089: 111.42,76.87 111.42,77.3 111.73,77.62 113.34,77.62 113.4,77.67 113.42,77.67 114.57,77.67 115.87,78.97 116.02,78.97 116.28,79.23 ; 111.42,73.88 110.54,73
  BOTTOM w0.102: v2(107.54,73.85) 108.44,73.85 109.54,72.76 110.31,72.76 110.54,73 ; v2(107.87,44.46) 108.36,44.95 108.36,46.49 108.15,46.7 JDIMM1.41 ; 111.42,76.87 111.42,73.88
DDR_A_D18: length 50.6
  IN1 w0.089: v2(111.32,45.78) 111.98,45.12 111.98,41.96 112.08,41.86 112.48,41.86 112.58,41.96 112.58,47.06 111.22,48.42 111.22,71.66 111.88,72.32 v2(111.88,73.89)
  BOTTOM w0.076: UC1.AW63 116.46,81.72 116.77,81.41 116.77,80.86 116.99,80.64 116.99,79 116.29,78.3 116.14,78.3 114.85,77.01 113.83,77.01 113.59,76.77
  BOTTOM w0.102: JDIMM1.51 111.15,45.95 v2(111.32,45.78) ; v2(111.88,73.89) 113.28,75.29 113.28,76.46 113.59,76.77
DDR_A_D19: length 49.1
  IN1 w0.089: v2(111.32,41.21) 111.26,41.15 111.26,40.57 111.17,40.48 110.34,40.48 110.25,40.57 110.25,45.36 110.06,45.55 110.06,72.73 110.63,73.3 110.63,75.2 111.04,75.61 111.04,76.88 111.39,77.23 v2(111.88,77.23)
  BOTTOM w0.076: UC1.AY63 116.36,81.18 116.36,80.93 116.28,80.71 116.28,80.58 116.34,80.35 116.34,80.21 116.29,80.09 116.29,79.83 116.47,79.65 116.47,79.18 116.08,78.79 115.93,78.79 114.64,77.5 113.49,77.5 113.22,77.23 v2(111.88,77.23)
  BOTTOM w0.102: JDIMM1.50 110.85,40.74 v2(111.32,41.21)
DDR_A_D20: length 48.5
  IN1 w0.089: v2(110.03,76.22) 108.34,74.53 108.34,56.75 108.24,56.65 107.75,56.65 107.66,56.56 107.66,56.35 107.75,56.26 108.24,56.26 108.34,56.16 108.34,55.97 108.24,55.87 107.75,55.87 107.66,55.78 107.66,55.56 107.75,55.47 108.24,55.47 108.34,55.37 108.34,55.18 108.24,55.08 107.75,55.08 107.66,54.99 107.66,54.77 107.75,54.68 108.24,54.68 108.34,54.58 108.34,54.39 108.24,54.29 107.75,54.29 107.66,54.2 107.66,53.99 107.75,53.9 107.99,53.9 108.08,53.81 108.08,53.59 107.99,53.5 107.75,53.5 107.66,53.41 107.66,53.2 107.75,53.11 107.99,53.11 108.08,53.02 108.08,52.81 107.99,52.72 107.75,52.72 107.66,52.63 107.66,52.41 107.75,52.32 107.99,52.32 108.08,52.23 108.08,52.02 107.99,51.93 107.75,51.93 107.66,51.84 107.66,51.62 107.75,51.54 107.99,51.54 108.08,51.45 108.08,51.23 107.99,51.14 107.75,51.14 107.66,51.05 107.66,50.84 107.75,50.75 107.99,50.75 108.08,50.66 108.08,50.44 107.99,50.35 107.75,50.35 107.66,50.27 107.66,46.19 v2(107.87,45.99)
  BOTTOM w0.076: UC1.BA65 115.23,80.49 115.09,80.35 115.09,80.34 115.08,80.34 114.98,80.12 114.98,79.81 115.04,79.75 115.04,79.09 114.35,78.4 111.11,78.4 110.42,77.72 110.42,76.61 v2(110.03,76.22)
  BOTTOM w0.102: v2(107.87,45.99) 107.72,45.99 107.55,46.16 JDIMM1.39
DDR_A_D21: length 48.8
  IN1 w0.089: v2(110.01,77.36) 107.08,74.43 107.08,72.84 107.61,72.31 107.61,58.37 107.52,58.28 107.44,58.28 107.33,58.18 107.33,57.99 107.44,57.89 107.52,57.89 107.61,57.8 107.61,57.58 107.52,57.49 107.17,57.49 107.08,57.4 107.08,42.18 v2(107.85,41.41)
  BOTTOM w0.076: v2(110.01,77.36) 110.23,77.58 110.23,77.78 111.01,78.57 114.28,78.57 114.88,79.16 114.88,79.68 114.81,79.75 114.81,80.15 114.91,80.36 114.91,80.4 114.96,80.53 114.96,80.82 115.23,81.08 UC1.AY65
  BOTTOM w0.102: v2(107.85,41.41) 108.16,41.41 108.45,41.11 JDIMM1.42
DDR_A_D22: length 49.2
  IN1 w0.089: v2(111.32,44.26) 110.85,44.73 110.85,46.26 110.94,46.35 112.18,46.35 112.29,46.46 112.29,46.63 112.18,46.74 110.94,46.74 110.85,46.83 110.85,47.05 110.94,47.14 111.7,47.14 111.82,47.25 111.82,47.41 111.7,47.53 110.94,47.53 110.85,47.62 110.85,72.18 111.47,72.8 111.47,74.86 111.88,75.27 v2(111.88,75.28)
  BOTTOM w0.076: 113.3,76.85 113.63,77.17 114.78,77.17 116.07,78.46 116.22,78.46 116.82,79.06 116.82,80.16 116.56,80.42 UC1.BA63
  BOTTOM w0.102: JDIMM1.53 111.75,45.25 111.86,45.14 112.34,45.14 112.45,45.03 112.45,44.87 112.34,44.76 111.94,44.76 111.82,44.63 111.82,44.38 111.69,44.25 111.33,44.25 v2(111.32,44.26) ; v2(111.88,75.28) 112.69,76.09 112.69,76.23 113.3,76.85
DDR_A_D23: length 47.8
  IN1 w0.089: v2(111.88,75.93) 111.01,75.06 111.01,73.01 110.36,72.36 110.36,45.67 110.54,45.49 110.54,44.32 110.63,44.23 110.8,44.23 110.89,44.15 110.89,43.93 110.8,43.84 110.63,43.84 110.54,43.75 110.54,43.54 110.63,43.45 110.8,43.45 110.89,43.36 110.89,43.14 110.8,43.05 110.63,43.05 110.54,42.96 110.54,42.1 110.64,42 110.84,42 110.94,42.1 110.94,42.65 111.03,42.73 v2(111.32,42.73)
  BOTTOM w0.076: UC1.BB63 116.63,79.91 116.63,79.11 116.15,78.63 116,78.63 114.71,77.34 113.56,77.34 113.24,77.02 112.97,77.02 112.89,76.94
  BOTTOM w0.102: v2(111.32,42.73) 111.67,42.73 111.9,42.51 111.9,40.93 111.45,40.48 JDIMM1.52 ; 112.89,76.94 v2(111.88,75.93)
DDR_A_D24: length 47.3
  IN1 w0.089: v2(113.45,45.78) 113.45,47.38 112.51,48.32 112.51,48.52 112.69,48.7 112.69,48.84 112.58,48.95 112.43,48.95 112.26,48.78 112.12,48.78 112.01,48.88 112.01,49.03 112.41,49.42 112.41,49.55 112.22,49.74 112.22,52.56 112.13,52.65 112.07,52.65 111.98,52.74 111.98,52.96 112.07,53.05 112.13,53.05 112.22,53.13 112.22,53.35 112.13,53.44 112.07,53.44 111.98,53.53 111.98,53.74 112.07,53.83 112.13,53.83 112.22,53.92 112.22,54.14 112.13,54.23 112.07,54.23 111.98,54.32 111.98,54.53 112.07,54.62 112.13,54.62 112.22,54.71 112.22,54.93 112.13,55.01 112.07,55.01 111.98,55.1 111.98,55.32 112.07,55.41 112.13,55.41 112.22,55.5 112.22,55.71 112.13,55.8 112.07,55.8 111.98,55.89 111.98,56.11 112.07,56.2 112.13,56.2 112.22,56.28 112.22,56.5 112.13,56.59 112.07,56.59 111.98,56.68 111.98,56.89 112.07,56.98 112.13,56.98 112.22,57.07 112.22,57.29 112.13,57.38 112.07,57.38 111.98,57.47 111.98,57.68 112.07,57.77 112.13,57.77 112.22,57.86 112.22,58.08 112.13,58.16 112.07,58.16 111.98,58.25 111.98,58.47 112.07,58.56 112.13,58.56 112.22,58.65 112.22,58.86 112.13,58.95 112.07,58.95 111.98,59.04 111.98,59.26 112.07,59.35 112.13,59.35 112.22,59.43 112.22,59.65 112.13,59.74 112.07,59.74 111.98,59.83 111.98,60.04 112.07,60.13 112.13,60.13 112.22,60.22 112.22,60.44 112.13,60.53 112.07,60.53 111.98,60.62 111.98,60.83 112.07,60.92 112.13,60.92 112.22,61.01 112.22,61.22 112.13,61.31 112.07,61.31 111.98,61.4 111.98,61.62 112.07,61.71 112.13,61.71 112.22,61.8 112.22,62.01 112.13,62.1 112.07,62.1 111.98,62.19 111.98,62.41 112.07,62.49 112.13,62.49 112.22,62.58 112.22,62.8 112.13,62.89 112.07,62.89 111.98,62.98 111.98,63.19 112.07,63.28 112.13,63.28 112.22,63.37 112.22,63.59 112.13,63.68 112.07,63.68 111.98,63.76 111.98,63.98 112.07,64.07 112.13,64.07 112.22,64.16 112.22,64.37 112.13,64.46 112.07,64.46 111.98,64.55 111.98,64.77 112.07,64.86 112.13,64.86 112.22,64.95 112.22,65.16 112.13,65.25 112.07,65.25 111.98,65.34 111.98,65.56 112.07,65.64 112.13,65.64 112.22,65.73 112.22,65.95 112.13,66.04 112.07,66.04 111.98,66.13 111.98,66.34 112.07,66.43 112.13,66.43 112.22,66.52 112.22,66.74 112.13,66.83 112.07,66.83 111.98,66.91 111.98,67.13 112.07,67.22 112.13,67.22 112.22,67.31 112.22,67.52 112.13,67.61 112.07,67.61 111.98,67.7 111.98,67.92 112.07,68.01 112.13,68.01 112.22,68.1 112.22,68.31 112.13,68.4 112.07,68.4 111.98,68.49 111.98,68.7 112.07,68.79 112.13,68.79 112.22,68.88 112.22,69.1 112.13,69.19 112.07,69.19 111.98,69.28 111.98,69.49 112.07,69.58 112.13,69.58 112.22,69.67 112.22,69.89 112.13,69.97 112.07,69.97 111.98,70.06 111.98,70.28 112.07,70.37 112.13,70.37 112.22,70.46 112.22,70.67 112.13,70.76 112.07,70.76 111.98,70.85 111.98,71.07 112.07,71.16 112.13,71.16 112.22,71.24 112.22,71.44 113.18,72.4 113.18,74.51 v2(114.01,75.34)
  BOTTOM w0.076: UC1.BA61 117.58,80.41 117.32,80.15 117.32,78.86 116.43,77.97 116.28,77.97 114.37,76.07 114.37,75.71 v2(114.01,75.34)
  BOTTOM w0.102: JDIMM1.57 112.95,45.97 113.14,45.78 v2(113.45,45.78)
DDR_A_D25: length 48.3
  IN1 w0.089: v2(114.01,76.64) 112.87,75.5 112.87,72.61 111.69,71.43 111.69,52.35 111.78,52.26 111.82,52.26 111.92,52.16 111.92,51.97 111.82,51.87 111.78,51.87 111.69,51.78 111.69,51.56 111.78,51.47 111.82,51.47 111.92,51.37 111.92,51.18 111.82,51.08 111.78,51.08 111.69,50.99 111.69,50.77 111.78,50.68 111.82,50.68 111.92,50.58 111.92,50.39 111.82,50.29 111.78,50.29 111.69,50.2 111.69,48.62 113.05,47.26 113.05,42.52 113.15,42.42 113.35,42.42 113.45,42.52 v2(113.45,42.73)
  BOTTOM w0.076: v2(114.01,76.64) 114.71,76.64 116.21,78.13 116.36,78.13 117.15,78.93 117.15,80.67 117.36,80.88 117.36,81.42 117.68,81.75 UC1.AW61
  BOTTOM w0.102: JDIMM1.56 112.65,42.56 112.83,42.73 v2(113.45,42.73)
DDR_A_D26: length 46.8
  IN1 w0.089: v2(115.97,74.86) 115.12,74.01 115.12,71.94 114.22,71.04 114.22,50.57 116.35,48.45 116.35,42.46 116.26,42.37 115.96,42.37 115.87,42.28 115.87,42.06 115.96,41.97 116.36,41.97 116.47,41.87 116.47,41.68 116.36,41.58 115.61,41.58 115.51,41.48 115.51,41.29 115.61,41.19 117.12,41.19 v2(117.14,41.21)
  BOTTOM w0.076: UC1.BB59 119.01,79.88 119.01,79.2 118.77,78.96 118.77,78.7 116.77,76.7 116.77,76.55
  BOTTOM w0.089: 116.77,76.55 116.77,75.66 v2(115.97,74.86)
  BOTTOM w0.102: JDIMM1.70 116.85,40.78 117.14,41.08 v2(117.14,41.21)
DDR_A_D27: length 49.3
  IN1 w0.089: v2(115.95,73.57) 115.55,73.57 115.42,73.45 115.42,71.72 114.52,70.81 114.52,51.42 115.13,50.81 115.13,50.68 114.92,50.48 114.92,50.34 115.06,50.2 115.2,50.2 115.41,50.41 115.53,50.41 115.69,50.25 115.69,50.13 115.46,49.9 115.46,49.76 115.59,49.62 115.74,49.62 115.96,49.85 116.09,49.85 116.24,49.7 116.24,49.57 116.01,49.34 116.01,49.2 116.15,49.06 116.29,49.06 116.52,49.29 116.65,49.29 116.74,49.2 116.74,43.13 v2(117.14,42.73)
  BOTTOM w0.076: UC1.AW59 118.26,81.94 117.98,81.66 117.98,80.86 118.02,80.74 118.02,80.51 118.02,80.5 118.02,80.5 118.02,80.5 117.98,80.41 117.98,80.21 118.02,80.12 118.02,79.76 117.81,79.56 117.81,78.54 116.51,77.23 116.37,77.23 116.11,76.97
  BOTTOM w0.089: 116.11,76.97 115.54,76.4 115.54,73.98 v2(115.95,73.57)
  BOTTOM w0.102: JDIMM1.68 116.25,40.57 116.45,40.77 116.45,42.4 116.79,42.73 v2(117.14,42.73)
DDR_A_D28: length 46.7
  IN1 w0.089: v2(114,74.66) 113.52,74.18 113.52,72.39 112.51,71.38 112.51,49.86 113.85,48.52 113.85,47.64 113.94,47.55 114.53,47.55 114.64,47.45 114.64,47.26 114.53,47.16 113.94,47.16 113.85,47.07 113.85,46.85 113.94,46.76 114.53,46.76 114.64,46.66 114.64,46.47 114.53,46.37 113.94,46.37 113.85,46.28 113.85,46.07 113.94,45.98 114.38,45.98 114.48,45.87 114.48,45.68 114.38,45.58 114.19,45.58 114.08,45.48 114.08,44.28 113.93,44.12 113.59,44.12 v2(113.45,44.26)
  BOTTOM w0.076: UC1.BB61 117.48,79.88 117.48,78.79 116.5,77.8 116.34,77.8 114.66,76.12 114.66,75.69
  BOTTOM w0.102: v2(114,74.66) 114.66,75.32 114.66,75.69 ; v2(113.45,44.26) 114.14,44.95 114.14,46.03 113.55,46.63 JDIMM1.59
DDR_A_D29: length 47.9
  IN1 w0.089: v2(114.01,73.31) 114.01,72.45 112.8,71.24 112.8,49.99 114.93,47.86 114.93,45.72 114.38,45.16 114.38,40.77 114.28,40.67 113.09,40.67 112.99,40.77 112.99,41.11 113.09,41.21 v2(113.45,41.21)
  BOTTOM w0.076: UC1.AY61 117.78,81.18 117.78,80.92 117.82,80.82 117.82,80.82 117.85,80.74 117.85,80.53 117.82,80.44 117.82,80.18 117.85,80.09 117.85,79.83 117.65,79.63 117.65,78.72 116.56,77.64 116.5,77.64 116.06,77.2
  BOTTOM w0.102: JDIMM1.58 113.25,41.01 v2(113.45,41.21) ; v2(114.01,73.31) 115,74.3 115,76.14 116.06,77.2
DDR_A_D30: length 48.2
  IN1 w0.089: v2(115.96,72.9) 116.46,72.9 116.58,72.78 116.58,71.95 115.1,70.47 115.1,51.67 118.35,48.42 118.35,43.17 118.26,43.08 117.9,43.08 117.81,43.17 117.81,44.14 117.69,44.26 v2(117.14,44.26)
  BOTTOM w0.076: 116.99,75.53 116.99,76.59 118.94,78.53 118.94,78.89 119.18,79.13 119.18,80.08 119.12,80.23 UC1.BA59
  BOTTOM w0.102: v2(117.14,44.26) 116.1,44.26 115.95,44.41 JDIMM1.67 ; 116.99,75.53 116.99,75.13 116.61,74.75 116.61,73.55 v2(115.96,72.9)
DDR_A_D31: length 49
  IN1 w0.089: v2(115.8,71.68) 114.81,70.69 114.81,51.54 117.14,49.21 117.14,48.68 117.23,48.59 117.56,48.59 117.66,48.49 117.66,48.3 117.56,48.2 117.23,48.2 117.13,48.1 117.13,47.87 117.22,47.78 117.95,47.78 118.05,47.68 118.05,47.49 117.95,47.39 117.22,47.39 117.13,47.3 117.13,47.08 117.22,46.99 117.95,46.99 118.05,46.89 118.05,46.7 117.95,46.6 117.22,46.6 117.13,46.51 117.13,46.29 117.22,46.2 117.95,46.2 118.05,46.1 118.05,44.65 117.95,44.55 117.64,44.55 117.54,44.65 117.54,45.68 117.44,45.78 v2(117.14,45.78)
  BOTTOM w0.076: 117.32,75.55 117.32,76.64 119.1,78.42 119.1,78.82 119.34,79.06 119.34,80.12 119.31,80.19 119.18,80.62 119.18,80.82 118.91,81.08 UC1.AY59
  BOTTOM w0.102: 117.32,75.55 117.32,74.92 117.05,74.64 117.05,72.93 v2(115.8,71.68) ; JDIMM1.69 116.55,45.88 116.65,45.78 v2(117.14,45.78)
DDR_A_D32: length 50
  IN1 w0.089: v2(136.41,45.53) 136.08,45.53 136.02,45.6 136.02,45.93 136.1,46.02 136.59,46.02 136.68,46.11 136.68,46.33 136.59,46.42 136.1,46.42 136.02,46.5 136.02,46.72 136.1,46.81 136.59,46.81 136.68,46.9 136.68,47.11 136.59,47.2 136.1,47.2 136.02,47.29 136.02,47.51 136.1,47.6 136.59,47.6 136.68,47.69 136.68,47.9 136.59,47.99 136.1,47.99 136.02,48.08 136.02,48.3 136.1,48.38 136.59,48.38 136.68,48.47 136.68,48.69 136.59,48.78 136.1,48.78 136.02,48.87 136.02,49.08 136.1,49.17 136.59,49.17 136.68,49.26 136.68,49.48 136.59,49.57 136.1,49.57 136.02,49.65 136.02,49.87 136.1,49.96 136.42,49.96 136.51,50.05 136.51,50.26 136.42,50.35 136.1,50.35 136.02,50.44 136.02,55.81 128.71,63.11 128.71,70.64 v2(129.85,71.78)
  BOTTOM w0.076: 129.17,77.47 129.17,77.93 129.73,78.49 129.73,78.71 129.57,78.87 129.57,79.59 129.52,79.64 129.52,79.81 129.52,79.81 129.52,80.13 129.58,80.26 129.58,80.28 129.69,80.53 129.69,80.82 129.95,81.08 UC1.AY39
  BOTTOM w0.102: JDIMM1.131 137.55,45.68 137.4,45.53 v2(136.41,45.53) ; v2(129.85,71.78) 129.17,72.45 129.17,77.47
DDR_A_D33: length 48.3
  IN1 w0.089: v2(130.6,77.87) 129.52,76.79 129.52,72.29 128.42,71.19 128.42,62.99 135.72,55.68 135.72,41.65 v2(136.41,40.96)
  BOTTOM w0.076: UC1.AW39 130.61,81.94 130.87,81.67 130.87,81.1 130.89,81.06 130.89,80.88 130.83,80.72 130.83,80.58 130.89,80.36 130.89,80.24 130.85,80.13 130.85,79.78 131.05,79.58 131.05,78.32 v2(130.6,77.87)
  BOTTOM w0.102: v2(136.41,40.96) 136.78,40.96 137.25,40.49 JDIMM1.130
DDR_A_D34: length 49.7
  IN1 w0.089: v2(140.18,41.14) 139.75,41.14 139.34,41.54 139.34,48.14 139.26,48.23 139.08,48.23 138.99,48.32 138.99,48.54 139.08,48.62 139.26,48.62 139.34,48.71 139.34,48.93 139.26,49.02 138.81,49.02 138.72,49.11 138.72,49.32 138.81,49.41 139.26,49.41 139.34,49.5 139.34,49.72 139.26,49.81 138.81,49.81 138.72,49.89 138.72,50.11 138.81,50.2 139.12,50.2 139.21,50.29 139.21,50.5 139.12,50.59 138.81,50.59 138.72,50.68 138.72,55.94 131.25,63.41 131.25,68.88 131.37,69 131.37,71.83 131.64,72.09 131.64,75.77 v2(130.66,76.74)
  BOTTOM w0.076: v2(130.66,76.74) 131.22,77.29 131.22,79.65 131.01,79.85 131.01,80.09 131.07,80.21 131.07,80.35 131,80.58 131,80.71 131.08,80.93 131.08,81.18 UC1.AY37
  BOTTOM w0.102: v2(140.18,41.14) 140.5,41.14 140.85,40.79 JDIMM1.142
DDR_A_D35: length 50.8
  IN1 w0.089: v2(140.17,42.49) 139.73,42.92 139.73,50.87 139.64,50.96 139.13,50.96 139.05,51.05 139.05,51.26 139.13,51.35 139.64,51.35 139.73,51.44 139.73,51.65 139.64,51.74 139.13,51.74 139.05,51.83 139.05,52.05 139.13,52.14 139.64,52.14 139.73,52.23 139.73,52.44 139.64,52.53 139.13,52.53 139.05,52.62 139.05,52.84 139.13,52.92 139.53,52.92 139.62,53.01 139.62,53.23 139.53,53.32 139.13,53.32 139.05,53.41 139.05,56.03 131.72,63.35 131.72,68.44 131.59,68.57 131.59,71.65 132,72.07 132,73.05 v2(132.44,73.49)
  BOTTOM w0.076: 131.78,76.4 131.78,77.2 131.71,77.27 131.71,79.62 131.71,79.62 131.71,80.64 131.49,80.86 131.49,81.41 131.18,81.72 UC1.AW37
  BOTTOM w0.102: v2(140.17,42.49) 139.75,42.07 139.75,40.92 140.25,40.43 JDIMM1.140 ; 131.78,76.4 131.78,74.15 v2(132.44,73.49)
DDR_A_D36: length 48.4
  IN1 w0.089: v2(130.65,73.64) 130.95,73.33 130.95,72.46 130.59,72.1 130.59,70.9 129.83,70.14 129.83,62.82 136.63,56.02 136.63,55.69 136.72,55.61 136.89,55.61 136.98,55.52 136.98,55.3 136.89,55.21 136.72,55.21 136.63,55.12 136.63,54.91 136.72,54.82 137,54.82 137.09,54.73 137.09,54.51 137,54.42 136.72,54.42 136.63,54.34 136.63,54.12 136.72,54.03 137.2,54.03 137.29,53.94 137.29,53.73 137.2,53.64 136.72,53.64 136.63,53.55 136.63,53.33 136.72,53.24 137.2,53.24 137.29,53.15 137.29,43.37 v2(136.41,42.49)
  BOTTOM w0.076: UC1.BB39 129.95,79.74 129.9,79.69 129.9,79.01 130.06,78.85 130.06,78.35 129.72,78.02 129.72,77.46
  BOTTOM w0.102: 129.72,77.46 129.72,74.36 130.45,73.64 v2(130.65,73.64) ; JDIMM1.132 137.85,41.04 v2(136.41,42.49)
DDR_A_D37: length 49.2
  IN1 w0.089: v2(130.57,72.94) 130.57,72.56 130.37,72.35 130.37,71.18 129.36,70.18 129.36,62.88 136.31,55.93 136.31,53.04 136.4,52.95 136.89,52.95 136.98,52.86 136.98,52.65 136.89,52.56 136.4,52.56 136.31,52.47 136.31,52.25 136.4,52.16 136.89,52.16 136.98,52.07 136.98,51.86 136.89,51.77 136.4,51.77 136.31,51.68 136.31,51.46 136.4,51.38 136.89,51.38 136.98,51.29 136.98,51.07 136.89,50.98 136.59,50.98 136.5,50.89 136.5,50.68 136.59,50.59 136.89,50.59 136.98,50.5 136.98,44.58 v2(136.41,44.01)
  BOTTOM w0.076: UC1.BA39 129.95,80.49 129.81,80.35 129.81,80.34 129.81,80.34 129.69,80.09 129.69,79.71 129.74,79.66 129.74,78.94 129.9,78.78 129.9,78.42 129.43,77.95 129.43,77.49
  BOTTOM w0.102: v2(130.57,72.94) 129.43,74.09 129.43,77.49 ; v2(136.41,44.01) 135.99,44.43 135.99,46.11 136.17,46.28 136.57,46.28 136.95,46.66 JDIMM1.129
DDR_A_D38: length 49.7
  IN1 w0.089: v2(140.17,45.53) 140.63,45.53 140.72,45.62 140.72,46.7 140.63,46.79 140.13,46.79 140.04,46.87 140.04,47.09 140.13,47.18 140.6,47.18 140.68,47.27 140.68,47.48 140.6,47.57 140.13,47.57 140.04,47.66 140.04,47.88 140.13,47.97 140.49,47.97 140.58,48.06 140.58,48.27 140.49,48.36 140.13,48.36 140.04,48.45 140.04,48.67 140.13,48.75 140.48,48.75 140.57,48.84 140.57,49.06 140.48,49.15 140.13,49.15 140.04,49.24 140.04,49.45 140.13,49.54 140.48,49.54 140.57,49.63 140.57,49.85 140.48,49.94 140.13,49.94 140.04,50.02 140.04,50.24 140.13,50.33 140.48,50.33 140.57,50.42 140.57,50.63 140.48,50.72 140.11,50.72 140.02,50.81 140.02,53.55 139.93,53.64 139.43,53.64 139.34,53.73 139.34,53.95 139.43,54.04 139.93,54.04 140.02,54.12 140.02,54.34 139.93,54.43 139.43,54.43 139.34,54.52 139.34,54.73 139.43,54.82 139.93,54.82 140.02,54.91 140.02,55.46 132.19,63.3 132.19,68.33 131.79,68.73 131.79,71.41 v2(132.44,72.06)
  BOTTOM w0.076: UC1.BA37 131.28,80.42 131.55,80.16 131.55,79.69 131.55,79.69 131.55,76.75 131.5,76.7 131.5,76.44
  BOTTOM w0.102: JDIMM1.141 140.55,46.73 140.65,46.64 140.65,45.94 140.24,45.53 v2(140.17,45.53) ; 131.5,76.44 131.5,73.01 v2(132.44,72.06)
DDR_A_D39: length 48.8
  IN1 w0.089: v2(132.44,71.35) 132.01,70.92 132.01,68.8 132.66,68.15 132.66,63.24 140.32,55.58 140.32,53.49 140.4,53.4 140.92,53.4 141.01,53.31 141.01,53.09 140.92,53 140.4,53 140.32,52.92 140.32,52.7 140.4,52.61 140.92,52.61 141.01,52.52 141.01,52.31 140.92,52.22 140.4,52.22 140.32,52.13 140.32,51.91 140.4,51.82 140.92,51.82 141.01,51.73 141.01,51.52 140.92,51.43 140.4,51.43 140.32,51.34 140.32,51.13 140.4,51.04 140.92,51.04 141.01,50.95 141.01,44.83 v2(140.19,44.01)
  BOTTOM w0.076: 131.27,76.76 131.38,76.87 131.38,79.89 UC1.BB37
  BOTTOM w0.102: v2(132.44,71.35) 131.16,72.63 131.16,76.66 131.27,76.76 ; JDIMM1.143 141.15,44.97 v2(140.19,44.01)
DDR_A_D40: length 49.9
  IN1 w0.089: v2(132.44,74.14) 132.8,73.78 132.8,69.28 133.13,68.95 133.13,63.43 140.79,55.78 140.79,53.96 140.87,53.87 141.39,53.87 141.48,53.78 141.48,44.63 140.8,43.95 140.8,41.48 140.89,41.39 141.23,41.39 141.32,41.3 141.32,41.08 141.23,40.99 140.89,40.99 140.8,40.9 140.8,40.69 140.89,40.6 142.26,40.6 142.35,40.69 v2(142.35,40.96)
  BOTTOM w0.076: v2(132.44,74.14) 133,74.7 133,77.64 132.37,78.27 132.37,79.31 132.58,79.52 132.58,80.09 132.54,80.18 132.54,80.19 132.54,80.44 132.58,80.53 132.58,80.74 132.55,80.82 132.54,80.82 132.51,80.92 132.51,81.18 UC1.AY35
  BOTTOM w0.102: v2(142.35,40.96) 142.65,40.66 JDIMM1.148
DDR_A_D41: length 50.6
  IN1 w0.089: v2(142.35,42.49) 142.35,42.54 142.26,42.63 141.67,42.63 141.59,42.54 141.59,41.77 141.5,41.68 141.18,41.68 141.09,41.77 141.09,43.83 141.77,44.51 141.77,54.07 141.68,54.16 141.17,54.16 141.08,54.25 141.08,55.9 133.42,63.55 133.42,68.99 133.01,69.4 133.01,74.87 v2(132.44,75.44)
  BOTTOM w0.076: UC1.AW35 132.41,81.75 132.09,81.42 132.09,80.88 131.88,80.67 131.88,79.55 131.88,77.66 132,77.53 132,77.32
  BOTTOM w0.102: v2(142.35,42.49) 141.95,42.08 141.95,40.73 142.05,40.62 JDIMM1.146 ; v2(132.44,75.44) 132.22,75.44 132,75.66 132,77.32
DDR_A_D42: length 50.5
  IN1 w0.089: v2(134.27,70.9) 133.95,70.59 133.95,70.1 135.54,68.52 135.54,64.28 143.87,55.94 143.87,53.48 144.47,52.89 144.47,44.11 144.98,43.59 144.98,41.13 144.72,40.87 144.16,40.87 144.04,40.75 144.04,40.4 144.16,40.27 145.01,40.27 v2(145.7,40.96)
  BOTTOM w0.076: UC1.AY33 133.63,81.08 133.91,80.81 133.91,80.46 133.95,80.36 134.02,80.22 134.07,80.13 134.07,79.76 133.94,79.64 133.94,79.64 133.89,79.58 133.89,79.26 134.11,79.04 134.11,76.11 134.61,75.6 134.61,75.6 134.65,75.56 134.65,71.29 v2(134.27,70.9)
  BOTTOM w0.102: JDIMM1.158 145.65,40.83 145.7,40.88 v2(145.7,40.96)
DDR_A_D43: length 49.3
  IN1 w0.089: v2(134.26,71.54) 134.58,71.54 134.69,71.43 134.69,69.68 135.83,68.54 135.83,64.4 144.17,56.06 144.17,53.6 144.76,53.01 144.76,44.23 145.28,43.71 145.28,42.91 v2(145.7,42.49)
  BOTTOM w0.076: 133.22,77.81 132.54,78.49 132.54,79.25 132.74,79.45 132.74,80.12 132.74,80.12 132.7,80.21 132.7,80.41 132.74,80.5 132.74,80.5 132.74,80.5 132.75,80.51 132.75,80.74 132.7,80.86 132.7,81.12 132.78,81.22 132.78,81.73 132.98,81.94 UC1.AW33
  BOTTOM w0.102: JDIMM1.160 146.25,41.94 v2(145.7,42.49) ; 133.22,77.81 133.22,73.78 133.04,73.6 133.04,72.76 v2(134.26,71.54)
DDR_A_D44: length 48.3
  IN1 w0.089: v2(132.44,76.09) 132.99,76.09 133.19,75.89 133.19,69.67 133.82,69.04 133.82,63.57 141.52,55.87 141.52,55.67 141.37,55.52 141.37,55.33 141.46,55.24 142.07,55.24 142.16,55.15 142.16,54.94 142.07,54.85 141.46,54.85 141.37,54.76 141.37,54.54 141.46,54.45 141.97,54.45 142.06,54.36 142.06,54.18 142.16,54.08 142.16,53.78 142.06,53.69 142.06,53.39 142.16,53.3 142.16,53 142.06,52.9 142.06,52.6 142.16,52.51 142.16,52.21 142.06,52.12 142.06,51.82 142.16,51.72 142.16,51.42 142.06,51.33 142.06,51.03 142.16,50.93 142.16,50.63 142.06,50.54 142.06,50.24 142.16,50.15 142.16,49.85 142.06,49.75 142.06,49.15 142.15,49.06 142.24,49.06 142.33,48.98 142.33,48.76 142.24,48.67 142.15,48.67 142.06,48.58 142.06,48.36 142.15,48.27 142.66,48.27 142.75,48.18 142.75,47.97 142.66,47.88 142.15,47.88 142.06,47.79 142.06,47.57 142.15,47.48 142.66,47.48 142.75,47.39 142.75,47.18 142.66,47.09 142.15,47.09 142.06,47 142.06,46.78 142.15,46.7 142.66,46.7 142.75,46.61 142.75,46.13 142.65,46.03 142.65,45.84 142.75,45.74 142.75,45.25 142.66,45.16 142.44,45.16 142.35,45.25 v2(142.35,45.53)
  BOTTOM w0.076: UC1.BB35 132.21,79.88 132.21,79.42 132.21,79.42 132.21,78.2 132.84,77.57 132.84,76.49 v2(132.44,76.09)
  BOTTOM w0.102: v2(142.35,45.53) 142.95,46.13 JDIMM1.149
DDR_A_D45: length 49
  IN1 w0.089: v2(132.44,77.39) 133.37,76.47 133.37,69.75 133.86,69.25 134.12,69 134.12,63.69 142.45,55.35 142.45,52.78 142.54,52.69 142.65,52.69 142.74,52.6 142.74,52.38 142.65,52.29 142.54,52.29 142.45,52.21 142.45,51.99 142.54,51.9 142.94,51.9 143.03,51.81 143.03,51.6 142.94,51.51 142.54,51.51 142.45,51.42 142.45,51.2 142.54,51.11 142.94,51.11 143.03,51.02 143.03,50.81 142.94,50.72 142.54,50.72 142.45,50.63 142.45,50.42 142.54,50.33 142.94,50.33 143.03,50.24 143.03,50.02 142.94,49.93 142.54,49.93 142.45,49.84 142.45,49.27 143.05,48.68 143.05,44.7 v2(142.35,44.01)
  BOTTOM w0.076: v2(132.44,77.39) 132.04,77.79 132.04,79.48 132.04,79.49 132.04,80.15 132.31,80.41 UC1.BA35
  BOTTOM w0.102: JDIMM1.147 142.35,46.87 141.73,46.24 141.73,44.64 v2(142.35,44.01)
DDR_A_D46: length 49
  IN1 w0.089: v2(145.7,45.51) 145.7,45.23 145.79,45.14 146.06,45.14 146.15,45.23 146.15,46.57 146.06,46.66 145.43,46.66 145.34,46.75 145.34,47.07 145.43,47.16 146.06,47.16 146.15,47.25 146.15,47.46 146.06,47.55 145.43,47.55 145.34,47.64 145.34,47.86 145.43,47.95 146.06,47.95 146.15,48.03 146.15,48.25 146.06,48.34 145.43,48.34 145.34,48.43 145.34,48.64 145.43,48.73 146.06,48.73 146.15,48.82 146.15,49.04 146.06,49.13 145.43,49.13 145.34,49.22 145.34,49.43 145.43,49.52 145.54,49.52 145.62,49.61 145.62,49.83 145.54,49.91 145.43,49.91 145.34,50 145.34,55.98 145.08,56.24 144.81,56.24 136.41,64.64 136.41,68.61 135.09,69.93 135.09,74.57 v2(134.22,75.44)
  BOTTOM w0.076: UC1.BA33 133.63,80.49 133.78,80.35 133.78,80.34 133.78,80.34 133.9,80.09 133.9,79.83 133.72,79.65 133.72,79.19 133.93,78.98 133.93,75.73 v2(134.22,75.44)
  BOTTOM w0.102: v2(145.7,45.51) 145.34,45.87 145.34,46.79 145.35,46.79 JDIMM1.157
DDR_A_D47: length 48.3
  IN1 w0.089: v2(145.7,43.98) 145.42,43.98 145.05,44.35 145.05,53.13 144.46,53.72 144.46,53.89 144.55,53.98 144.96,53.98 145.05,54.07 145.05,54.29 144.96,54.38 144.55,54.38 144.46,54.46 144.46,54.68 144.55,54.77 144.96,54.77 145.05,54.86 145.05,55.07 144.96,55.16 144.55,55.16 144.46,55.25 144.46,55.47 144.55,55.56 144.96,55.56 145.05,55.65 145.05,55.86 144.96,55.95 144.55,55.95 144.46,56.04 144.46,56.18 136.12,64.52 136.12,68.56 134.89,69.79 134.89,74.35 134.45,74.79 v2(134.22,74.79)
  BOTTOM w0.076: UC1.BB33 133.63,79.8 133.56,79.72 133.56,79.12 133.76,78.92 133.76,75.25 v2(134.22,74.79)
  BOTTOM w0.102: JDIMM1.159 145.95,46.67 146.19,46.42 146.19,44.47 v2(145.7,43.98)
DDR_A_D48: length 50.4
  IN1 w0.089: v2(136.1,71.68) 135.72,71.31 135.72,70.47 137.47,68.73 137.47,65.08 145.25,57.3 145.52,57.3 146.4,56.42 146.4,51.2 146.49,51.12 147.07,51.12 147.16,51.03 147.16,50.81 147.07,50.72 146.49,50.72 146.4,50.63 146.4,50.54 147.21,49.74 147.21,43.79 147.49,43.5 147.86,43.5 v2(148.36,44.01)
  BOTTOM w0.076: UC1.AY31 134.93,81.08 134.67,80.82 134.67,80.53 134.5,80.12 134.5,79.76 134.65,79.61 134.65,78.73 134.89,78.5 134.89,73.81
  BOTTOM w0.102: 134.89,73.81 134.89,72.89 v2(136.1,71.68) ; v2(148.36,44.01) 148.25,44.01 147.15,45.11 JDIMM1.163
DDR_A_D49: length 50.5
  IN1 w0.089: v2(148.36,40.96) 147.16,40.96 146.73,41.39 146.73,41.52 146.82,41.61 146.89,41.61 146.98,41.7 146.98,41.91 146.89,42 146.71,42 146.62,42.09 146.62,49.49 145.81,50.3 145.81,56.18 145.28,56.71 145.01,56.71 136.88,64.84 136.88,68.5 135.3,70.08 135.3,76.59 v2(136.1,77.39)
  BOTTOM w0.076: v2(136.1,77.39) 136.12,77.42 136.12,79.31 135.83,79.6 135.83,80.13 135.84,80.16 135.88,80.24 135.88,80.36 135.81,80.58 135.81,80.72 135.87,80.88 135.87,81.06 135.84,81.11 135.84,81.68 135.59,81.94 UC1.AW31
  BOTTOM w0.102: JDIMM1.166 148.05,40.65 v2(148.36,40.96)
DDR_A_D50: length 49.1
  IN1 w0.089: v2(151.22,40.96) 150.59,40.96 150.37,41.18 150.37,42.08 150.55,42.25 150.55,45.1 149.79,45.86 149.79,46.61 148.92,47.47 148.92,53.9 148.13,54.7 148.13,57.36 139.18,66.3 139.18,68.51 137.12,70.58 137.12,75.72 v2(136.1,76.74)
  BOTTOM w0.076: UC1.AY29 136.06,81.18 136.06,80.93 135.99,80.71 135.99,80.58 136.05,80.35 136.05,80.21 135.99,80.09 135.99,79.67 136.29,79.38 136.29,77.81 136.47,77.63 136.47,77.11 136.1,76.74 v2(136.1,76.74)
  BOTTOM w0.102: v2(151.22,40.96) 151.05,40.79 JDIMM1.176
DDR_A_D51: length 50.3
  IN1 w0.089: v2(137.7,73.49) 137.3,73.09 137.3,70.77 139.47,68.59 139.47,66.42 148.42,57.48 148.42,55.57 148.51,55.48 149.09,55.48 149.18,55.39 149.18,55.17 149.09,55.08 148.51,55.08 148.42,54.99 148.42,54.82 148.57,54.66 149.15,54.66 149.21,54.61 149.21,47.59 149.29,47.52 149.41,47.52 149.71,47.82 149.84,47.82 149.99,47.67 149.99,47.54 149.69,47.24 149.69,47.11 149.84,46.96 149.97,46.96 150.27,47.26 150.4,47.26 150.55,47.11 150.55,46.98 150.25,46.68 150.25,46.56 150.4,46.41 150.65,46.41 150.73,46.33 150.73,46.04 150.44,45.75 150.44,45.62 150.92,45.14 151.06,45.14 151.22,45.3 v2(151.22,45.62)
  BOTTOM w0.076: UC1.AW29 136.16,81.72 136.47,81.41 136.47,80.86 136.69,80.64 136.69,79.69 136.78,79.6 136.78,78.03 136.99,77.83 136.99,74.2 v2(137.7,73.49)
  BOTTOM w0.102: v2(151.22,45.62) 150.75,46.09 JDIMM1.175
DDR_A_D52: length 48.6
  IN1 w0.089: v2(148.36,42.49) 148.01,42.13 147.18,42.13 146.91,42.4 146.91,49.61 146.11,50.42 146.11,56.3 145.4,57 145.13,57 137.18,64.96 137.18,68.59 135.5,70.26 135.5,72.89 v2(136.1,73.49)
  BOTTOM w0.076: v2(136.1,73.49) 135.22,74.37 135.22,78.63 134.98,78.87 134.98,79.76 134.93,79.81 UC1.BB31
  BOTTOM w0.102: JDIMM1.164 147.45,42.11 147.82,42.49 v2(148.36,42.49)
DDR_A_D53: length 49.3
  IN1 w0.089: v2(148.36,45.53) 148.36,45.36 148.12,45.12 147.59,45.12 147.5,45.21 147.5,51.35 147.41,51.44 146.79,51.44 146.7,51.53 146.7,51.74 146.79,51.83 147.41,51.83 147.5,51.92 147.5,52.14 147.41,52.23 146.79,52.23 146.7,52.32 146.7,52.53 146.79,52.62 147.41,52.62 147.5,52.71 147.5,52.93 147.41,53.01 146.79,53.01 146.7,53.1 146.7,53.32 146.79,53.41 147.01,53.41 147.1,53.5 147.1,53.71 147.01,53.8 146.79,53.8 146.69,53.9 146.69,56.54 145.64,57.59 145.37,57.59 144.21,58.75 144.21,58.88 144.33,59 144.33,59.12 144.17,59.28 144.05,59.28 143.93,59.16 143.8,59.16 143.65,59.31 143.65,59.44 143.77,59.56 143.77,59.68 143.62,59.83 143.49,59.83 143.37,59.71 143.25,59.71 137.76,65.2 137.76,68.83 136.49,70.09 136.49,72.48 136.09,72.88 v2(136.09,72.88)
  BOTTOM w0.076: UC1.BA31 134.93,80.49 134.79,80.35 134.79,80.34 134.79,80.34 134.67,80.09 134.67,79.83 134.82,79.68 134.82,78.8 135.05,78.56 135.05,73.92 136.09,72.88 v2(136.09,72.88)
  BOTTOM w0.102: v2(148.36,45.53) 147.75,46.15 JDIMM1.165
DDR_A_D54: length 49.7
  IN1 w0.089: v2(137.7,72.12) 137.97,72.39 138.18,72.39 138.35,72.23 138.35,70.39 140.06,68.68 140.06,66.67 149.8,56.93 149.8,48.69 151.96,46.53 151.96,42.59 151.53,42.16 151.31,42.16 151.22,42.25 v2(151.22,42.49)
  BOTTOM w0.076: UC1.BA29 136.26,80.41 136.53,80.14 136.53,79.6 136.62,79.51 136.62,77.96 136.82,77.76 136.82,73 v2(137.7,72.12)
  BOTTOM w0.102: JDIMM1.174 150.45,41.72 v2(151.22,42.49)
DDR_A_D55: length 48.2
  IN1 w0.089: v2(151.22,44.01) 151.22,43.88 151.31,43.79 151.58,43.79 151.67,43.88 151.67,46.41 149.5,48.57 149.5,55.8 149.42,55.88 148.81,55.88 148.72,55.97 148.72,56.19 148.81,56.28 149.08,56.28 149.18,56.38 149.18,57.13 139.77,66.54 139.77,68.59 138.1,70.26 138.1,71.33 137.96,71.46 v2(137.7,71.46)
  BOTTOM w0.076: v2(137.7,71.46) 136.66,72.51 136.66,77.69 136.45,77.89 136.45,79.44 136.26,79.64 UC1.BB29
  BOTTOM w0.102: v2(151.22,44.01) 151.67,44.46 151.67,46.5 151.35,46.82 JDIMM1.177
DDR_A_D56: length 52.1
  IN1 w0.089: v2(137.7,75.44) 138.34,75.44 139.02,74.75 139.02,70.61 139.39,70.24 140.18,70.24 140.87,69.55 140.87,66.93 141.01,66.79 141.14,66.79 141.24,66.89 141.36,66.89 141.51,66.74 141.51,66.61 141.42,66.51 141.42,66.39 141.57,66.23 141.69,66.23 141.79,66.33 141.92,66.33 142.07,66.18 142.07,66.05 141.97,65.96 141.97,65.83 142.13,65.68 142.25,65.68 142.35,65.78 142.48,65.78 142.63,65.62 142.63,65.5 142.53,65.4 142.53,65.27 142.68,65.12 142.81,65.12 142.91,65.22 143.03,65.22 143.19,65.07 143.19,64.94 143.09,64.84 143.09,64.72 143.24,64.56 143.37,64.56 143.46,64.66 143.59,64.66 143.74,64.51 143.74,64.38 143.64,64.28 143.64,64.16 150.56,57.24 150.56,49.01 151.09,48.48 151.22,48.48 151.51,48.77 151.63,48.77 151.78,48.62 151.78,48.49 151.49,48.2 151.49,48.08 151.65,47.92 151.77,47.92 152.06,48.21 152.19,48.21 152.34,48.06 152.34,47.93 152.05,47.64 152.05,47.52 152.2,47.36 152.33,47.36 152.62,47.65 152.75,47.65 152.9,47.5 152.9,47.38 152.61,47.09 152.61,46.96 152.72,46.85 152.72,45.25 152.81,45.16 153.06,45.16 153.15,45.25 v2(153.15,45.53)
  BOTTOM w0.076: v2(137.7,75.44) 138.23,75.97 138.23,77.78 137.44,78.57 137.44,79.72 137.56,79.83 137.56,80.09 137.52,80.18 137.52,80.19 137.52,80.44 137.56,80.53 137.56,80.74 137.53,80.82 137.53,80.82 137.49,80.92 137.49,81.18 UC1.AY27
  BOTTOM w0.102: JDIMM1.183 153.15,46.87 152.71,46.43 152.71,45.97 v2(153.15,45.53)
DDR_A_D57: length 52.7
  IN1 w0.089: v2(137.7,74.14) 138.65,73.19 138.65,70.51 139.13,70.03 140.01,70.03 140.53,69.51 140.53,66.86 150.27,57.12 150.27,48.89 152.43,46.72 152.43,42.39 151.71,41.67 151.71,40.43 151.86,40.28 153.05,40.28 153.15,40.37 v2(153.15,40.96)
  BOTTOM w0.076: UC1.AW27 137.39,81.75 137.07,81.42 137.07,80.88 136.86,80.67 136.86,79.76 136.95,79.67 136.95,78.35 137.27,78.03 137.27,74.57 v2(137.7,74.14)
  BOTTOM w0.102: v2(153.15,40.96) 152.85,40.66 JDIMM1.182
DDR_A_D58: length 52.4
  IN1 w0.089: v2(153.15,44.01) 153.37,44.01 153.55,44.19 153.55,47.26 153.05,47.76 153.05,47.88 153.29,48.12 153.29,48.25 153.14,48.4 153.01,48.4 152.78,48.16 152.65,48.16 152.5,48.32 152.5,48.44 152.73,48.68 152.73,48.81 152.58,48.96 152.46,48.96 152.22,48.72 152.09,48.72 151.94,48.87 151.94,49 152.18,49.24 152.18,49.36 152.02,49.52 151.9,49.52 151.66,49.28 151.54,49.28 151.38,49.43 151.38,49.56 151.62,49.79 151.62,49.92 151.47,50.07 151.34,50.07 151.1,49.84 150.98,49.84 150.85,49.96 150.85,57.37 144.06,64.16 144.06,64.61 141.18,67.49 141.18,69.56 140.24,70.5 139.46,70.5 139.3,70.65 139.3,71.26 139.61,71.58 v2(139.67,71.58)
  BOTTOM w0.076: v2(139.67,71.58) 139.8,71.58 140.07,71.85 140.07,76.46 139.38,77.15 139.38,78.26 139.06,78.58 139.06,80.11 138.94,80.36 138.89,80.46 138.89,80.81 138.62,81.08 UC1.AY25
  BOTTOM w0.102: JDIMM1.181 152.55,46.95 152.2,46.61 152.2,44.96 v2(153.15,44.01)
DDR_A_D59: length 52.9
  IN1 w0.089: v2(139.68,70.89) 140.17,70.89 141.5,69.56 141.5,67.58 141.75,67.33 141.88,67.33 142.15,67.6 142.28,67.6 142.43,67.45 142.43,67.32 142.15,67.05 142.15,66.92 142.31,66.77 142.43,66.77 142.71,67.04 142.83,67.04 142.99,66.89 142.99,66.77 142.71,66.49 142.71,66.37 144.35,64.73 144.35,64.28 151.14,57.49 151.14,50.81 153.84,48.11 153.84,43.18 v2(153.15,42.49)
  BOTTOM w0.076: 138.44,77.81 137.61,78.64 137.61,79.65 137.72,79.76 137.72,80.12 137.72,80.12 137.69,80.21 137.69,80.41 137.72,80.5 137.72,80.5 137.72,80.5 137.73,80.51 137.73,80.74 137.69,80.86 137.69,81.66 137.96,81.94 UC1.AW25
  BOTTOM w0.102: JDIMM1.180 152.25,41.59 v2(153.15,42.49) ; v2(139.68,70.89) 138.25,72.32 138.25,75.63 138.44,75.82 138.44,77.81
DDR_A_D60: length 50.9
  IN1 w0.089: v2(156.92,44.01) 156.61,44.01 156.51,44.11 156.51,48.28 153.15,51.64 153.15,58.32 146.36,65.11 146.36,66.36 143.38,69.33 143.38,69.59 143.68,69.89 143.68,70.07 143.1,70.65 143.1,73.18 139.8,76.48 138.09,76.48 v2(137.7,76.09)
  BOTTOM w0.076: v2(137.7,76.09) 138.07,76.46 138.07,77.71 137.28,78.5 137.28,79.98 UC1.BB27
  BOTTOM w0.102: v2(156.92,44.01) 156.88,44.01 155.55,45.34 JDIMM1.191
DDR_A_D61: length 50.8
  IN1 w0.089: v2(137.7,77.39) 139.56,77.39 143.45,73.5 143.45,70.71 144.16,70 144.16,69.88 143.81,69.53 143.81,69.4 143.97,69.25 144.09,69.25 144.44,69.6 144.56,69.6 144.72,69.44 144.72,69.32 144.37,68.97 144.37,68.85 144.52,68.69 144.65,68.69 144.99,69.04 145.12,69.04 145.27,68.89 145.27,68.76 144.93,68.42 144.93,68.29 145.08,68.14 145.21,68.14 145.4,68.34 145.53,68.34 145.68,68.18 145.68,68.06 145.48,67.86 145.48,67.73 146.65,66.57 146.65,65.23 153.44,58.44 153.44,51.76 156.8,48.4 156.8,46.87 157.35,46.32 157.35,45.68 157.21,45.53 v2(156.92,45.53)
  BOTTOM w0.076: v2(137.7,77.39) 137.7,77.84 137.11,78.43 137.11,79.74 137.02,79.83 137.02,80.15 137.29,80.41 UC1.BA27
  BOTTOM w0.102: v2(156.92,45.53) 156.15,46.3 JDIMM1.193
DDR_A_D62: length 51
  IN1 w0.089: v2(139.68,75.44) 140.07,75.44 142.55,72.96 142.55,70.78 143.09,70.24 143.09,69.21 146.07,66.24 146.07,64.99 152.86,58.2 152.86,51.52 155.95,48.43 155.95,47.4 155.87,47.32 155.7,47.32 155.61,47.23 155.61,47.02 155.7,46.93 156.13,46.93 156.22,46.84 156.22,46.62 156.13,46.53 155.7,46.53 155.61,46.44 155.61,46.23 155.7,46.14 156.13,46.14 156.22,46.05 156.22,43.7 156.46,43.46 156.46,42.95 v2(156.92,42.49)
  BOTTOM w0.076: UC1.BA25 138.62,80.49 138.77,80.34 138.89,80.07 138.89,78.51 139.21,78.19 139.21,75.91 v2(139.68,75.44)
  BOTTOM w0.102: v2(156.92,42.49) 155.85,41.42 JDIMM1.192
DDR_A_D63: length 50.2
  IN1 w0.089: v2(139.68,74.79) 140.2,74.79 141.19,73.81 141.19,72.98 142.17,72 142.17,70.75 142.8,70.12 142.8,69.09 145.77,66.12 145.77,64.87 152.56,58.08 152.56,51.4 155.26,48.7 155.26,45.89 155.35,45.8 155.5,45.8 155.59,45.72 155.59,45.5 155.5,45.41 155.35,45.41 155.26,45.32 155.26,45.11 155.35,45.02 155.84,45.02 155.92,44.93 155.92,44.71 155.84,44.62 155.35,44.62 155.26,44.53 155.26,44.24 156.17,43.33 156.17,41.71 v2(156.92,40.96)
  BOTTOM w0.076: v2(139.68,74.79) 139.05,75.42 139.05,78.12 138.73,78.44 138.73,79.65 138.62,79.76 UC1.BB25
  BOTTOM w0.102: v2(156.92,40.96) 156.88,40.96 156.45,40.53 JDIMM1.194
